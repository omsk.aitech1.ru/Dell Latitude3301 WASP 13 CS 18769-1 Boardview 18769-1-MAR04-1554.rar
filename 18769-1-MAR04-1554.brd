# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 4.4
  BOTTOM w0.102: CPU1.CB36 105.25,43.01 105.27,42.98 105.27,41.04 105.24,41.01 105.24,40.95 104.84,40.55 104.84,39.42 TP2201.1
V0.85A_VID1: length 3.7
  BOTTOM w0.076: CPU1.CB35 105.48,43.65 105.48,43.43 105.51,43.32 105.52,43.31 105.52,43.13 105.46,42.97 105.46,42.56
  BOTTOM w0.102: 105.46,42.56 105.46,40.67 TP2202.1
V3D3_STB: length 1.2
  TOP w0.203: U2701.16 182.91,12.26 182.81,12.16 182.81,11.76 182.92,11.65 182.92,11.58
  vias: v1(183.41,10.89)
VBUS_P_CTRL: length 5.6
  TOP w0.127: v3(25.79,63.68) 25.42,64.05 v1(25.42,64.14) 25.34,64.22 25.34,65.61 26.32,66.58 26.32,67.32 26.15,67.49 Q7404.2
  BOTTOM w0.127: v3(25.79,63.68) 25.96,63.51 25.97,63.51 26.08,63.4 U7201.D7
VBUS_P_CTRL_R: length 5.1
  TOP w0.152: v1(26.51,65.96) 26.59,66.04 26.59,67.33 26.75,67.49 Q7404.5
  TOP w0.203: Q7404.5 Q7404.6
  TOP w0.254: R7423.2 27.3,69.63 R7409.1 27.3,69.63 Q7404.6
VCCCORE_SENSE: length 38.4
  TOP w0.127: v2(87.79,61.82) 87.39,62.23 v1(87.35,62.23) 87.35,63.06 R719.2
  L5 w0.127: v2(87.79,61.82) 87.79,61.77 88.08,61.48 88.08,61.3 87.49,60.71 74.44,60.71 74.18,60.97 63.64,60.97 62.81,61.8 57.51,61.8 56.01,60.3 56.01,59.49 55.86,59.33 55.68,59.33 55.59,59.42 v2(55.55,59.42)
  BOTTOM w0.127: v2(87.79,61.82) 87.73,61.82 CPU1.AN6 ; v2(55.55,59.42) 55.44,59.3 PR4665.1
VCCDSW_EN: length 201.7
  TOP w0.102: v2(161.3,25.35) 160.79,25.35 159.48,24.04 159.48,23.69 160.12,23.05 160.12,19.56 159.75,19.19 159.75,14.41 157.66,12.32 157.13,11.79 157.13,10.73 157.04,10.64 157.04,4.77 156.38,4.11 156.38,4.09 156.18,3.89 v3(156.18,3.56) ; v2(20.26,5.77) v1(20.26,8.37) 20.26,9.69 21.35,10.78 v2(21.48,10.78) ; D2503.2 175.85,32.47 174.23,34.09 172.5,34.09 172.1,34.49 171.21,34.49 v2(171.07,34.35) 170.57,33.85 C2525.1 168.89,33.85 R2520.2
  L5 w0.102: v2(161.3,25.35) 162.13,25.35 162.44,25.04 163.41,25.04 164.06,25.69 164.06,30.97 162.95,32.08 162.95,33.26 164.25,34.55 167.19,34.55 167.95,33.8 170.06,33.8 170.61,34.35 v2(171.07,34.35)
  L8 w0.102: v2(20.26,5.77) 21.18,4.86 25.87,4.86 26.64,5.63 36.43,5.63 36.45,5.62 56.7,5.62 56.76,5.56 57.34,5.56 59.88,8.1 69.64,8.1 69.83,8.29 80.2,8.29 85.54,2.94 87.8,2.94 88.04,2.7 109.42,2.7 109.75,2.37 132.15,2.37 132.4,2.61 145.39,2.61 155.25,2.61 156.18,3.54 v3(156.18,3.56)
  BOTTOM w0.102: v2(21.48,10.78) 21.77,11.06 U2401.88
VCCGT_SENSE: length 38.7
  TOP w0.127: v2(70.08,64.9) 69.83,64.66 R807.2 69.11,64.18 v1(68.94,64.02) ; v2(44.01,58.02) 44.01,58.47 43.5,58.98 43.5,59.16 PR4695.1
  L8 w0.127: v2(44.01,58.02) 43.81,58.22 43.81,58.93 42.32,60.42 42.32,61.1 42.98,61.77 45.52,61.77 45.9,62.15 50.41,62.15 50.52,62.04 53.03,62.04 54.68,60.39 56.94,60.39 57.95,61.4 61.49,61.4 63.27,63.19 68.09,63.19 69.81,64.9 v2(70.08,64.9)
  BOTTOM w0.127: v2(70.08,64.9) 70.08,64.73 70.06,64.72 CPU1.E3
VCCPD_VBUS_ACK: length 214.6
  TOP w0.254: U7419.A2 24.12,73.96 23.8,74.28 23.36,74.28 22.93,74.71 v2(22.87,74.71) ; v2(42.34,17.09) 42.26,17.17 v1(42.26,17.84)
  L3 w0.254: v2(16.87,40.11) 16.73,40.25 16.73,42.6 16.09,43.24 16.09,45.13 16,45.22 16,45.31 15.25,46.06 15.25,49.27 15.56,49.57 15.56,49.57 15.99,50.01 15.99,50.01 15.99,50.94 16.42,51.37 16.42,52.89 16.4,52.91 16.4,53.33 16.42,53.34 16.42,56.6 18.1,58.27 18.1,59.4 17.25,60.24 17.25,62 18.05,62.8 18.05,65.38 19.2,66.54 19.2,68.5 21.07,70.37 21.07,74.75 21.98,75.66 22.42,75.66 22.87,75.21 v2(22.87,74.71)
  L5 w0.254: v2(42.34,17.09) 43.12,16.31 44.4,16.31 44.79,16.31 46.37,14.74 56.1,14.74 56.37,15 88.69,15 90.07,13.62 90.33,13.62 91.23,13.62 93.07,11.77 108.05,11.77 108.32,11.5 116.67,11.5 116.74,11.46 117.59,10.61 120.66,10.61 123.16,13.11 123.69,13.11 123.99,13.41 123.99,13.72 127.75,17.48 127.75,21.51 128.28,22.04 134.14,22.04 134.2,21.98 134.62,21.98 134.67,22.04 138.31,22.04 138.83,21.52 144.27,21.52 144.28,21.52 145.55,21.52 145.55,21.52 148.62,21.52 150.4,23.3 v2(150.4,23.81) ; v2(41.08,32.4) 31.87,32.4 30.64,33.63 27.55,33.63 27.52,33.61 27.22,33.3 26.47,33.3 26.17,33.6 26.17,34.4 25.02,35.55 25.02,36.65 22.8,38.87 19.11,38.87 17.87,40.11 v2(16.87,40.11)
  L8 w0.254: v2(43.42,22.13) 43.1,22.45 43.1,30.38 v2(41.08,32.4)
  BOTTOM w0.254: v2(43.42,22.13) 43.5,22.05 43.5,20.69 42.46,19.64 42.46,17.21 v2(42.34,17.09) ; R7424.2 20.71,71.3 21.73,72.32 21.73,73.64 22.79,74.71 v2(22.87,74.71) ; PR4494.1 150.72,24.13 v2(150.4,23.81)
VCCRTCEXT: length 1.6
  TOP w0.254: C2201.1 100.22,51.44 v2(100.22,51.32)
  BOTTOM w0.254: v2(100.22,51.32) 100.22,51.29 99.94,51 CPU1.BP24
VCCSA_SENSE: length 63.9
  TOP w0.127: R810.2 95.28,60.52 v2(95.28,61.19) ; v2(37.6,63.87) 37.61,63.87 v1(38.01,64.27)
  L5 w0.127: v2(95.28,61.19) 94.87,61.19 94.42,61.64 93.89,61.64 91.03,64.5 90.12,64.5 89.42,63.8 81.07,63.8 80.61,63.33 72.23,63.33 72.21,63.36 64,63.36 63.18,62.54 53.22,62.54 52.41,63.36 48.78,63.36 48.51,63.09 45.01,63.09 43.86,64.23 40.54,64.23 39.96,64.23 39.73,64.46 38.25,64.46 37.67,63.87 v2(37.6,63.87)
  BOTTOM w0.127: CPU1.BG7 95.69,61.42 95.43,61.16 95.3,61.16 95.3,61.17 95.28,61.19 v2(95.28,61.19) ; v2(37.6,63.87) 37.79,64.06 PR4693.2
VCCST_PWRGD: length 124.5
  TOP w0.254: v2(75.2,69.02) 75.2,68.94 72.86,66.6 65.25,66.6 61.06,62.41 55.46,62.41 50.99,66.88 50.86,66.88 50.45,67.29 v2(48.98,67.29)
  L3 w0.254: v2(36.66,62.87) 36.66,61.03 35.06,59.42 35.06,49.27 33.93,48.14 33.59,48.14 32.8,47.35 32.8,42.61 31.94,41.74 31.94,40.13 32.27,39.79 32.27,32.84 29.67,30.24 29.67,28.59 30.04,28.22 32.59,28.22 32.95,27.86 32.95,26 v2(31.1,24.15)
  L5 w0.254: v2(48.98,67.29) 48.37,66.68 44.96,66.68 43.64,65.36 42.74,65.36 42.72,65.33 42.3,65.33 42.19,65.44 38.66,65.44 38.57,65.36 37.23,65.36 36.91,65.03 36.91,63.11 v2(36.66,62.87) ; v2(31.1,24.15) 31.2,24.15 34.76,20.58 v2(34.76,19.48)
  L8 w0.254: v2(89.32,71.3) 89.32,71.2 90.22,70.3 90.22,67.79 89.42,66.99 85.99,66.99 85.18,66.19 84.39,66.19 83.73,65.52 79.11,65.52 75.61,69.02 v2(75.2,69.02)
  BOTTOM w0.203: R2482.1 35.15,19.87 34.76,19.49 v2(34.76,19.48) ; v2(48.98,67.29) 48.96,67.26 PU4601.40
  BOTTOM w0.254: v2(89.32,71.3) v1(90.03,71.3) 90.34,71.61 R1716.1 ; v2(36.66,62.87) R4011.2 36.69,62.03 R4005.2
VCCST_PWRGD_R: length 13.5
  BOTTOM w0.254: C1711.1 R1719.1 ; C1711.1 91.45,73.25 90.51,73.25 R1716.2 ; C1711.1 92.18,72.74 R1718.2 92.7,71.44 ED1707.1 92.65,71.23 93.07,70.81 93.6,70.81 93.92,70.49 v1(93.92,69.89) 93.92,69.29 93.9,69.27 93.9,67.41 94.81,66.5 95.62,66.5 96.38,65.74 96.38,65.38 96.81,64.94 CPU1.BJ2
VCCSTG_EN_L1: length 2.3
  BOTTOM w0.102: R4039.1 134.76,32.19 v1(134.76,33.25) 134.75,33.25 134.06,33.95 U4008.4
VCCSTG_EN_R1: length 161.6
  TOP w0.102: U4003.4 108.08,85.59 107.91,85.76 107.64,85.76 107.12,86.27 C4040.1 107.12,86.58 v2(107.99,87.45) ; v2(101.05,36.04) 100.79,36.3 99.89,36.3 99.38,35.8 U4002.4
  L3 w0.102: v2(133.18,67.67) 132.94,67.67 132.24,66.96 132.24,66.53 134.72,64.05 134.72,61.23 134.03,60.53 133.97,60.53 133.23,59.79 133.23,57.42 133.39,57.27 133.39,51.57 133.35,51.54 133.35,49.3 133.68,48.98 133.68,46.77 134.77,45.68 134.77,42.9 135.25,42.42 135.25,39.14 134.16,38.05 134.16,24.85 134.13,24.82 134.71,24.24 134.71,22.85 134.61,22.75 v2(134.37,22.75)
  L5 w0.102: v2(136.92,76.85) 136.61,77.16 136.61,77.17 136.31,77.48 136.31,80.88 137.27,81.84 137.27,84.97 136.08,86.16 132.65,86.16 v2(130.95,87.86)
  L6 w0.102: v2(107.99,87.45) 108.09,87.55 109.55,87.55 110.58,86.52 129.98,86.52 130.95,87.48 v2(130.95,87.86) ; v2(136.92,76.85) 136.36,76.3 136.36,73.4 133.18,70.22 v2(133.18,67.67) ; v2(101.05,36.04) 101.05,34.84 104.92,30.97 113.08,30.97 118.1,25.95 118.1,24.41 118.69,23.82 119.1,23.82 119.19,23.91 120.14,23.91 120.19,23.86 123.28,23.86 125.17,21.96 132.67,21.96 133.22,22.52 133.22,22.86 133.53,23.16 133.96,23.16 v2(134.37,22.75)
  BOTTOM w0.102: v2(134.37,22.75) 134.37,22.52 134.58,22.31 136.62,22.31 136.87,22.56 136.87,24.43 135.07,26.23 135.07,29.57 135.96,30.46 135.96,30.81 v1(135.73,31.04) 135.48,31.3 R4039.2
VCCSTU_EN_R: length 3.3
  TOP w0.102: U4006.4 133.48,83.47 R4024.2 132.5,83.31 C4034.1 132.42,83.33 v1(131.56,83.33)
VDD: length 59.8
  TOP w0.254: v2(154.05,10.69) 153.42,10.69 152.6,9.87 152.05,9.87 150.36,8.18 150.36,5.74 150.48,5.62 150.48,5.22 150.47,5.2 150.47,5.1 149.8,4.43 146.91,4.43 PR44B5.2
  TOP w0.508: PR44C6.1 163.5,29.84 PR44A4.1 163.34,29.52 163.64,29.21 v1(163.64,25.19) 163.64,24.35 164.17,23.83 164.17,23.37 165.38,22.15 165.43,22.15 165.8,21.78 165.8,20.51 v2(165.85,20.46) ; PR4429.1 154.85,10.64 154.13,10.64 154.08,10.69 v2(154.05,10.69)
  L6 w0.508: v2(147.09,18.39) 147.6,18.39 147.63,18.42 147.88,18.42 148.74,19.28 151.98,19.28 154.38,16.88 154.38,16.82 154.45,16.75 154.45,16.23 154.38,16.16 154.38,16.16 v2(154,15.77) 154.66,15.11 154.68,15.11 155.05,14.73 155.05,11.54 154.22,10.71 154.07,10.71 v2(154.05,10.69)
  L8 w0.305: v2(154,15.77) 156.2,17.97 157.23,17.97 158.09,18.83 158.95,18.83 159.17,18.61 164.06,18.61 164.59,19.14 165.12,19.14 165.85,19.87 v2(165.85,20.46)
  BOTTOM w0.203: v2(154,15.77) 153.89,15.77 153.4,15.28 PU4401.18
  BOTTOM w0.508: v2(154,15.77) 155.12,15.77 PC4422.1 155.26,15.8 PR4442.1 ; PR4405.2 147.19,18.29 v2(147.09,18.39)
VSSCORE_SENSE: length 39.5
  TOP w0.127: R720.1 88,62.63 v2(87.85,62.48)
  L5 w0.127: v2(87.85,62.48) 88.34,61.99 88.34,61.2 87.6,60.46 74.33,60.46 74.08,60.71 63.54,60.71 62.7,61.55 57.62,61.55 56.27,60.2 56.27,59.38 v2(55.61,58.72)
  BOTTOM w0.127: CPU1.AN5 87.5,62.83 v2(87.85,62.48) ; v1(56.09,59.04) 55.92,59.04 v2(55.61,58.72) 55.41,58.53 PR4666.1
VSSGT_SENSE: length 42
  TOP w0.127: v1(67.15,63.99) 67.86,63.99 R808.1 68.43,64.17 69.73,65.47 v2(69.73,65.99) ; v2(43.37,58.04) 43.49,58.17 43.49,58.63 43.24,58.88 43.24,59.14 PR4694.1
  L8 w0.127: v2(69.73,65.99) 69.73,65.19 67.99,63.44 63.17,63.44 61.39,61.66 57.84,61.66 56.83,60.65 54.78,60.65 53.13,62.3 50.62,62.3 50.52,62.4 45.79,62.4 45.41,62.02 42.88,62.02 42.07,61.21 42.07,60.31 43.55,58.83 43.55,58.65 43.37,58.46 v2(43.37,58.04)
  BOTTOM w0.127: v2(69.73,65.99) 69.73,65.32 69.57,65.15 CPU1.D2
VSSSA_SENSE: length 64
  TOP w0.127: v1(94.79,62.76) 94.79,61.97 94.65,61.83 ; 94.65,61.83 v2(95.26,61.83) ; 94.65,61.83 R809.1
  L5 w0.127: v2(37.6,64.71) 39.83,64.71 40.06,64.48 40.43,64.48 40.43,64.48 43.97,64.48 45.11,63.34 48.41,63.34 48.68,63.61 52.51,63.61 53.33,62.79 63.08,62.79 63.89,63.61 72.31,63.61 72.33,63.59 80.5,63.59 80.96,64.05 89.32,64.05 90.02,64.75 91.14,64.75 93.99,61.9 94.53,61.9 94.6,61.83 v2(95.26,61.83)
  BOTTOM w0.127: v2(37.6,64.71) 37.84,64.95 PR4692.2 ; CPU1.BE7 95.06,61.82 95.26,61.82 95.26,61.83 v2(95.26,61.83)
0D6V_VREF_S0:
  vias: v1(113.67,15.17) v2(28.49,38.08) v2(28.49,37.44) v2(43.03,37.64) v2(43.56,37.29) v2(59.38,20.45) v2(59.73,20.97)
1D0V_S5: length 156.2
  TOP w0.254: PG5210.1 116.11,85.88 v4(116.01,85.78)
  TOP w0.305: R2202.1 111.27,62.56 113.87,62.56 114.39,63.07 114.39,63.37 v2(114.45,63.44)
  TOP w0.508: R2205.1 106.11,77.8 106.11,82.41
  L5 w0.508: v2(99.61,53.01) 97,53.01 95.99,52 80.23,52 79.47,51.24 75.42,51.24 72.98,53.68 70.92,53.68 70.45,53.22 70.45,53.1 70.1,52.74 70.03,52.74 69.72,52.43 65.46,52.43 65.18,52.14 60.88,52.14 51.33,42.59 51.33,40.15 49.18,38 47.31,38 46.85,38.46 v2(46.85,38.95)
  L6 w0.508: 115.63,76.17 115.63,76.17 115.63,67.62 115.28,67.26 115.28,64.27 114.45,63.45 v2(114.45,63.44)
  L8 w0.508: v2(46.85,38.95) 46.18,38.28 42.79,38.28 42.78,38.28 42.77,38.28 42.4,37.9 42.4,37.89 42.28,37.77 42.28,32.03 43.75,30.56 43.75,22.7 44.05,22.4 44.05,21.57 43.05,20.57 40.25,20.57 39.27,21.54 32.98,21.54 32.32,20.89 30.59,20.89 28.66,22.81 27.21,22.81 27.19,22.84 21.61,22.84 21.39,22.62 20.04,22.62 19.1,23.56 18.65,23.56 18.65,23.56 15.96,23.56 15.69,23.83 14.84,23.83 11.82,20.81 11.82,13.23 v2(13.67,11.37)
  BOTTOM w0.508: v4(134.15,81.81) 134.33,82 C2216.1 ; R2402.1 v2(13.67,11.37)
  vias: v1(111.86,84.24) v2(100.24,53.85) v2(100.91,58.07) v2(100.92,54.69) v2(100.9,53.85) v2(101.56,58.06) v2(101.56,57.2) v2(101.56,55.5) v2(102.22,57.23) v2(102.2,53.85) v2(102.22,53.01) v2(102.83,53.85) v2(102.86,53.02) v2(103.49,55.52) v2(103.49,53.85) v2(103.52,53.01) v2(104.15,57.2) v2(104.15,55.55) v2(104.15,54.68) v2(104.15,53.85) v2(105.44,57.2) v4(106.25,83.65) v4(107.18,84.37) v4(107.27,83.44) v4(109.66,86.09) v4(110.75,85.62) v4(110.85,84.62) v4(110.85,83.75) v4(112.79,85.73) v4(113.73,85.76) v4(114.9,85.78) v4(133.78,84.85) v4(134.31,82.75) v4(135.21,82.73)
1D0V_VCCA_XTAL: length 6
  TOP w0.254: v1(110.03,64.51) 110.55,63.99 R2202.2 111.21,63.95 C2219.1 112.51,64.24 113.34,64.24 v2(113.5,64.39)
  BOTTOM w0.254: CPU1.CP5 112.58,63.15 112.84,63.41 112.84,63.94 113.11,64.22 113.33,64.22 v2(113.5,64.39)
1D0V_VCCAMPHYPLL: length 49.2
  TOP w0.254: v2(107.43,75.51) 107.43,74.8 107.19,74.56 v1(107.19,74.51) C2208.1 106.15,75.45 C2209.1 106.11,76.33 R2205.2
  L5 w0.254: v2(102.34,66.29) 102.85,65.78 108.96,65.78 114.25,71.07 120.42,71.07 121.79,72.43 121.79,72.62 122.09,72.92 122.27,72.92 122.42,73.06 122.42,76.17 120.74,77.85 114.93,77.85 114.07,78.71 110.38,78.71 107.43,75.76 v2(107.43,75.51)
  BOTTOM w0.152: v2(102.34,66.29) 102.35,65.63 CPU1.BV2
1D0V_VCCDSW: length 1.2
  TOP w0.254: C2213.1 101.69,51.16 v2(101.52,51.32)
  BOTTOM w0.254: CPU1.BT24 101.51,51.18 101.51,51.32 v2(101.52,51.32)
1D0V_VCCPRIM_MPHY:
  vias: v1(103.26,60.1) v2(102.85,58.06) v2(103.49,58.04)
1D2V_S3: length 47.1
  TOP w0.203: v3(50.15,27.42) 49.83,27.1 RAM1.G5 ; RAM1.D6 47.88,27.71 v3(47.57,27.4) ; RAM1.J9 51.46,30.55 v3(51.46,30.61)
  TOP w0.254: RAM1.P4 54.38,26.21 v3(54.71,26.61) 54.38,27.01 ; RAM1.H5 50.48,27.01 v3(50.14,26.61) ; 51.78,27.81 RAM1.J6 51.13,27.81 ; 51.78,27.81 RAM1.K6 ; 51.78,27.81 v3(52.1,27.41) ; 54.38,27.01 v3(54.71,27.41) 54.38,27.81 RAM1.P6 ; 54.38,27.01 RAM1.P5 ; v3(49.18,24.12) 49.18,24.61 RAM1.F2 ; RAM2.G2 68.96,20.87 ; 68.96,20.87 69.61,21.67 RAM2.H3 ; 68.96,20.87 v3(68.66,20.37) ; v3(52.1,27.41) 52.43,27.01 RAM1.L5 ; v3(52.1,27.41) 51.78,27.01 RAM1.K5 ; v3(54.04,28.92) 53.73,29.41 RAM1.N8 ; v3(88.21,21.27) 88.21,21.34 88.53,21.67 RAM3.H3 ; RAM3.F2 87.23,20.87 87.47,20.5 87.47,20.43 ; RAM3.M2 91.13,20.87 v3(91.13,20.37) 90.98,20.37 90.48,20.87 RAM3.L2 ; RAM2.M2 72.21,20.87 72.21,20.42 v3(72.17,20.37) ; 87.47,20.43 87.48,20.43 87.79,20.85 87.88,20.87 RAM3.G2 ; 87.47,20.43 v3(87.52,20.43) ; RAM1.G2 49.83,24.61 v3(50.17,25.02) 50.48,25.41 RAM1.H3 ; v3(110.42,20.36) 110.31,20.47 110.31,20.87 RAM4.M2 ; RAM2.F2 68.31,20.87 v3(68.62,21.28) ; v3(73.84,28.49) 73.67,28.49 73.67,28.49 73.35,28.49 ; v3(109.59,20.37) 109.59,20.38 109.66,20.45 109.66,20.87 RAM4.L2 ; v3(48.82,28.93) 48.83,29.04 48.53,29.41 RAM1.E8 ; v3(50.15,27.42) 50.48,27.81 RAM1.H6 51.13,27.81 ; RAM1.J5 51.13,27.01 51.13,27.81 ; 47.88,27.01 47.88,27.05 47.57,27.4 v3(47.57,27.4) ; 47.88,27.01 v3(47.55,26.62) 47.88,26.21 RAM1.D4 ; 47.88,27.01 RAM1.D5 ; v3(51.45,29.81) 51.45,29.74 RAM1.K8 ; RAM1.M2 RAM1.L2 52.43,24.61 52.73,24.31 v3(52.73,23.76) ; RAM4.F2 106.41,20.87 v3(106.41,20.35) ; RAM4.H3 107.71,21.67 107.71,21.59 v3(107.39,21.27) 107.39,21.19 107.06,20.87 RAM4.G2 ; RAM2.L2 71.56,20.87 71.51,20.81 71.51,20.52 v3(71.38,20.4)
  TOP w0.305: 109.17,28.87 RAM4.K12 ; 89.91,28.87 RAM3.K12 ; 71.05,28.87 RAM2.K12 ; RAM1.K12 51.78,32.61
  TOP w0.508: 43.37,36.58 40.96,36.58 39.81,35.43 35.33,35.43 34.87,35.89 ; R1222.1 64.89,33.37
  BOTTOM w0.102: v3(78.78,42.16) 78.82,42.21 CPU1.Y36 ; CPU1.AH36 83.85,43.3 83.85,42.6 83.46,42.21 83.46,41.22 v3(83.26,41.03) ; CPU1.AY36 91.41,42.3 v3(91.43,42.28)
  BOTTOM w0.127: v3(97.05,42.12) 96.81,42.12 96.61,42.31 96.61,42.64 96.45,42.81 96.45,43.11 96.44,43.11 CPU1.BH36
  BOTTOM w0.152: v3(81.4,42.31) 81.4,43.26 CPU1.AD36 ; CPU1.AM36 86.37,43.14 86.35,43.1 v3(86.35,42.36)
  BOTTOM w0.254: CPU1.BE32 94.86,45.89 95.19,46.22 ; v2(91.52,46.31) 91.1,45.89 CPU1.AW32
  BOTTOM w0.279: 95.19,46.6 v2(95.16,46.94)
  BOTTOM w0.305: v2(75.11,46.3) 75.16,46.3 CPU1.R32 ; v3(86.98,45.68) 86.98,45.68 87.03,45.68 87.25,45.89 CPU1.AN32 ; v2(83.3,45.41) 83.3,45.47 83.73,45.89 CPU1.AH32 ; 95.19,46.22 95.19,46.6
  vias: v1(115.08,27.2) v2(45.43,29.55) v2(106.15,25.17) v3(45.37,31.62) v3(45.39,30.21) v3(47.33,33.1) v3(48.37,33.12) v3(49.83,33.17) v3(51.45,31.39) v3(54.08,33.12) v3(55.36,33.03) v3(56.62,29.82) v3(56.87,32.07) v3(64.35,28.26) v3(64.7,26.09) v3(65.41,25.2) v3(66.42,29.36) v3(66.69,23.67) v3(66.69,22.87) v3(66.69,22.04) v3(68,25.25) v3(68.41,30.56) v3(68.64,22.87) v3(69.24,29.34) v3(69.29,28.45) v3(69.29,23.67) v3(69.29,22.87) v3(69.93,27.66) v3(69.94,26.85) v3(69.93,26.06) v3(70.59,23.67) v3(70.57,22.89) v3(70.78,25.13) v3(71.24,23.67) v3(71.23,22.89) v3(71.91,30) v3(71.89,22.89) v3(72.59,25.14) v3(73.84,23.67) v3(73.82,22.88) v3(73.84,22.07) v3(75.85,25.27) v3(75.9,26.06) v3(75.98,28) v3(83.58,27.69) v3(83.63,26.09) v3(85.38,29.92) v3(85.61,23.67) v3(85.62,22.87) v3(85.63,22.07) v3(86.04,30.66) v3(86.27,25.2) v3(87.56,22.87) v3(88.04,25.18) v3(88.21,23.67) v3(88.23,22.88) v3(88.31,29.34) v3(88.83,27.66) v3(88.85,26.85) v3(89.5,26.05) v3(89.52,25.17) v3(89.51,23.67) v3(90.16,23.67) v3(90.16,22.87) v3(90.81,22.87) v3(91.36,30.11) v3(91.45,25.15) v3(92.5,30.03) v3(93.38,22.07) v3(94.88,28.05) v3(102.54,26.52) v3(102.58,28.48) v3(104.81,29.26) v3(104.8,23.68) v3(104.79,22.87) v3(104.78,22.05) v3(106.74,22.87) v3(107.4,23.68) v3(107.39,22.87) v3(107.98,29.29) v3(108.04,28.47) v3(108.05,26.88) v3(108.02,26.07) v3(108.7,25.17) v3(108.7,24.59) v3(108.69,22.87) v3(109.33,24.56) v3(109.97,23.67) v3(110.44,29.74) v3(110.63,25.04) v3(111.82,29.92) v3(111.94,23.67) v3(111.94,22.87) v4(44.67,34.6) v4(44.67,33.71) v4(44.67,32.87) v4(44.67,32.03) v4(44.81,35.49) v4(45.6,36.22)
1D2V_VCCSFR_OC: length 12.3
  TOP w0.254: U4002.7 95.31,33.57 C4007.1 94.42,34.45 94.42,37.3 94.73,37.61 95.14,37.61 96.59,36.16 96.59,35.96 96.87,35.68 97.53,35.68 97.74,35.88 ; v2(98.81,48.85) 98.62,48.85 98.07,49.4 C803.2
  BOTTOM w0.254: CPU1.BL27 98.35,49.05 98.56,48.85 v2(98.81,48.85) CPU1.BM26
  vias: v1(97.88,36.6)
1D8V_AON_S0: length 151.5
  TOP w0.381: v2(140.77,55.99) 140.77,54.82 141.28,54.31 141.28,52.38 v2(142.47,51.19)
  TOP w0.508: v2(173.99,50.26) 173.39,49.67 168.39,49.67 167.9,49.18 164.6,49.18 163.02,47.6 v2(162.22,47.6) ; Q7906.G 138.1,55.66 138.6,55.16 v2(138.86,55.16)
  L3 w0.508: v2(132.83,73.75) 131.48,72.41 131.48,69.24 130.94,68.69 128.95,68.69 128.13,69.52 v2(127.71,69.52) 127.71,69.04 129.5,67.25 130.63,67.25 134.29,63.59 v2(134.29,61.4) ; v2(140.18,48.28) 140.18,48.89 v2(142.47,51.19)
  L6 w0.508: v2(140.77,55.99) 140.66,55.88 139.34,55.88 138.95,55.49 138.95,55.25 v2(138.86,55.16) ; v2(155.87,81) 155.68,81.19 154.81,81.19 151.11,77.49 150.52,77.49 150.12,77.89 150.12,78.25 148.53,79.85 146.22,79.85 145.86,79.49 139.79,79.49 v2(139.02,78.72)
  L8 w0.508: v2(140.77,55.99) 141.32,55.99 142.54,57.21 143.22,57.21 144.46,55.97 144.46,55.39 143.94,54.87 v2(143.83,54.87) ; v2(162.22,47.6) 162.75,48.13 164.05,48.13 165.54,49.62 v2(165.54,50.09) ; v2(139.02,78.72) 137.58,77.28 137.58,75.7 135.63,73.75 v2(132.83,73.75)
  L8 w1.016: v2(159.53,57.7) 159.19,58.04 156.36,58.04 151.51,62.89 144.08,62.89 143.73,63.24 136.3,63.24 134.46,61.4 v2(134.29,61.4)
  BOTTOM w0.305: R7928.1 140.67,53 R7925.1 140.43,53.24 140.33,53.24 140.3,53.27 139.8,53.27 RN7901.2 139.05,54.02 139.05,54.91 138.86,55.11 v2(138.86,55.16) ; v2(140.77,55.99) 140.84,56.06 R7933.1
  BOTTOM w0.356: v2(140.77,55.99) RN7910.2 140.3,55.25 140.15,55.1 140.15,54.74 140.3,54.58 RN7910.1 ; RN7901.1 138.42,54.72 v2(138.86,55.16) ; GPU1.G12 159.96,58.46 159.96,58.13 v2(159.53,57.7) 159.1,57.27 158.77,57.27 GPU1.G10
  BOTTOM w0.381: R7917.1 144.5,54.19 143.83,54.87 v2(143.83,54.87) ; v2(142.47,51.19) 142.47,51.31 142.91,51.75 143.85,51.75 R7919.1
  BOTTOM w0.508: R7909.1 140.65,49.92 R7938.1 140.85,48.95 140.85,48.43 R7914.1 140.78,48.28 v2(140.18,48.28) ; R8637.1 133.84,61.65 134.08,61.4 v2(134.29,61.4) 134.29,60.93 134.79,60.43 134.79,59.39 136.11,58.06 137.03,58.06 137.66,57.43 137.83,57.43 R7603.1 138.04,57.08 R7949.1 138.8,55.63 138.86,55.57 v2(138.86,55.16) ; PR8650.1 128.39,68.84 v2(127.71,69.52) 127.14,68.95 Q8601.G ; R7905.1 161.24,46.54 R7701.1 161.24,46.63 v2(162.22,47.6) ; R8625.1 154.95,81.92 v2(155.87,81) ; R7935.1 R7918.1 173.14,51.11 v1(173.43,50.82) v2(173.99,50.26) R7920.1
1D8V_AON_S0_DISCHG: length 4.7
  BOTTOM w0.102: v1(155.65,82.88) 155.51,82.88 155.45,82.94 R8625.2 154.33,82.41 153.01,81.08 153.01,80.9 Q8614.3
1D8V_CPVDD: length 3.6
  TOP w0.203: R2709.2 186.2,17.13 185.62,16.56 U2701.29
  TOP w0.508: C2704.1 187.22,17.39 C2705.1 187.44,17.13 R2709.2
1D8V_EN#: length 2.9
  TOP w0.102: v1(189.18,24.03) 188.77,23.61 R4035.1 187.95,23.19 Q4001.D 188.1,23.5 R4034.2
1D8V_EN_R#: length 12.1
  TOP w0.102: R4035.2 193.97,17.12 v1(193.97,16.52) 193.97,15.6 C4038.2 193.97,15.09 v2(194.98,14.07)
  BOTTOM w0.102: v2(194.98,14.07) 195.28,14.37 Q4002.G
1D8V_FBA_PLL_AVDD: length 10.1
  TOP w0.305: C7827.1 162.36,66.86 161.69,67.53 v2(161.69,67.93) 161.29,67.53 L7801.1 ; v2(162.28,60.21) v1(162.28,59.65) ; v2(163.88,64.45) 163.78,64.35 163.06,64.35 C7805.1
  TOP w0.508: C7808.1 162.12,64.19 C7805.1 ; v2(162.28,60.21) 162.26,60.23 161.29,60.23 C7818.1
  BOTTOM w0.305: v2(162.28,60.21) 162.29,60.21 162.84,60.21 GPU1.F16 ; GPU1.P22 v2(161.69,67.93) ; v2(163.88,64.45) 163.91,64.48 164.89,64.48 165.19,64.78 165.19,64.96 165.19,64.97
1D8V_S0: length 317.3
  TOP w0.305: R2709.1 186.31,18 185.91,17.6 v2(185.91,17.53)
  TOP w0.381: v2(14.65,72.85) 14.42,72.62 R6406.1
  TOP w0.508: v1(89.32,8.11) 89.41,8.02 v2(89.94,8.02) ; v2(194.56,17.97) C4039.1 ; R2719.1 186.18,21.12 v2(186.18,21.32)
  L3 w0.381: v2(89.94,8.02) 89.25,7.33 83.71,7.33 83.23,6.85 82.03,6.85 81.18,7.7 81.16,7.7 80.93,7.93 71.51,7.93 70.66,7.07 66.12,7.07 64.82,5.77 38.76,5.77 38.43,5.44 38.1,5.1 34.35,5.1 33.65,5.81 33.65,5.83 26.92,5.83 26.86,5.89 26.84,5.89 26.7,6.04 24.36,6.04 23.52,5.2 19.23,5.2 18.28,4.25 18.08,4.25 17.83,4 16.44,4 16.17,4.27 14.36,4.27 14.18,4.1 10.09,4.1 v2(9.19,5) ; v2(194.56,17.97) 194.33,17.73 194.33,15.3 193.06,14.03 193.06,8.79 192.73,8.45 192.65,8.45 192.48,8.28 191.3,8.28 189.11,6.08 167.28,6.08 164.76,3.57 162.94,3.57 161.74,4.77 160.62,4.77 160.48,4.91 158.54,4.91 158.5,4.95 158.41,4.95 157.8,5.56 157.02,5.56 156.59,5.13 v2(156.59,5.08)
  L5 w0.381: v2(14.65,72.85) 14.54,72.74 14.54,69.56 13.71,68.73 13.71,67.06 13.72,67.06 13.72,65.52 13.13,64.94 13.13,51.38 10.71,48.95 10.35,48.95 v2(9.77,48.38) ; v2(115.81,4.68) 116.44,5.31 120.8,5.31 120.89,5.22 149.35,5.22 149.87,4.7 152.38,4.7 152.64,4.45 154.56,4.45 155.2,5.08 v2(156.59,5.08)
  L6 w0.381: v2(89.94,8.02) 90.14,8.22 90.58,8.22 91.07,8.71 95.11,8.71 98.46,5.36 115.13,5.36 v2(115.81,4.68)
  L8 w0.381: v2(9.19,5) 4.85,9.34 4.85,21.76 4.48,22.14 4.48,24.06 6.29,25.87 8.24,25.87 9.23,26.87 9.23,27.04 9.81,27.62 9.99,27.62 11.04,28.67 11.22,28.67 13.65,31.1 13.65,32.73 13.64,32.74 13.64,34.29 11.89,36.04 10.93,36.04 10.59,36.38 10.59,37.88 9.97,38.5 9.24,38.5 8.37,39.37 8.37,39.58 7.11,40.84 6.88,40.84 4.56,43.16 4.56,45.84 6.86,48.14 9.53,48.14 v2(9.77,48.38)
  L8 w0.508: v2(185.91,17.53) 184.62,16.24 184.62,16.17 184.25,15.8 182.45,15.8 182.08,16.17 182.08,17.45 183.53,18.9 183.89,18.9 184.35,19.35 184.35,19.47 186.18,21.3 v2(186.18,21.32) 186.83,21.97 189.01,21.97 189.38,21.59 189.92,21.59 193.54,17.97 v2(194.56,17.97)
  BOTTOM w0.508: v2(194.56,17.97) 194.56,17.02 195.07,16.51 Q4002.D
1D8V_S3: length 35.1
  TOP w0.254: RAM4.A10 103.1,27.32 102.49,27.32 v3(102.42,27.26) ; RAM4.U10 113.56,27.27 114.01,27.27 114.01,27.36 v3(114.05,27.36) ; RAM3.A10 83.98,27.27 83.69,26.97 83.62,26.97 83.62,26.95 v3(83.6,26.95) ; RAM1.U10 56.77,31.01 57.95,29.83 v3(57.95,29.44) ; v3(64.71,26.92) 64.71,26.92 65.06,27.27 RAM2.A10 ; v3(94.96,26.81) 94.84,26.81 94.38,27.27 RAM3.U10 ; RAM1.A10 v2(45.39,31.01)
  TOP w0.305: RAM2.U10 75.46,27.27 v3(75.89,27.02)
  TOP w0.508: v2(45.39,31.01) 43.98,31.01 PG5152.1
  L3 w0.254: v3(64.66,23.64) 64.22,24.08 64.22,26.43 v3(64.71,26.92) ; v3(57.95,29.44) 57.95,28.51 v2(56.79,27.35)
  L5 w0.254: v3(83.6,26.95) 83.62,26.95 83.62,26.91 83.14,26.43 83.14,24.44 v3(83.48,24.1) ; v3(75.89,27.02) 76.64,26.27 76.64,24.53 v3(75.87,23.75)
  L6 w0.254: v3(94.96,26.81) 94.96,25.71 94.48,25.23 94.48,24.59 94.79,24.27 v3(94.79,22.87)
  L6 w0.305: v3(114.05,27.36) 113.83,27.36 113.46,26.99 113.46,25.61 113.67,25.4 113.67,24.98 113.49,24.8 113.49,24.21 v3(113.94,23.75)
  L8 w0.254: v3(102.42,27.26) 101.66,26.5 101.66,24.59 102.56,23.69 v3(102.84,23.69)
  vias: v1(101.45,22.09) v2(44.54,27.11) v2(44.54,26.47) v2(44.54,25.84) v2(56.89,22.28) v2(57.62,22.28) v2(61.96,18.71) v2(62.6,18.71) v2(76.4,18.7) v2(77.07,18.68) v2(81.92,18.78) v2(82.58,18.78) v2(94.99,18.6) v2(95.72,18.6) v2(101.05,18.6) v2(101.82,18.6) v2(113.72,18.77) v2(114.06,19.3) v3(45.5,27.41)
1D8V_S5: length 3.7
  TOP w0.508: C4037.1 195.18,15.89 C4038.1 195.51,15.6 v4(195.79,15.32) ; v4(187.27,25.31) 187.6,24.97 R4034.1
  BOTTOM w0.508: v2(126.46,54.62) 126.73,54.9 R6121.1
  vias: v1(123.96,51.4) v2(36.13,17.5) v3(165.66,25.22) v4(8.96,72.15) v4(17.98,47.27) v4(28.32,46.66) v4(32.19,46.33) v4(34.26,46.81) v4(45.3,17.93) v4(123.84,49.59) v4(133.06,28.17) v4(162.72,25.62) v4(162.84,21.12) v4(170.15,25.64)
1D8V_S5_KBC: length 3.3
  BOTTOM w0.203: 33.34,17.87 U2401.54
  BOTTOM w0.508: 33.34,17.87 33.72,17.49 v1(33.72,17.47) 34.24,17.47 R2401.2 34.64,17.87 C2423.1
1D8V_VCCPRIM: length 90.4
  TOP w0.508: R1512.1 125.34,32.77 124.89,32.32 124.5,32.32 v2(124.28,32.09) ; R2113.1 113.71,51.76 v2(113.03,51.76) ; v2(111.81,33.71) 111.86,33.76 111.86,33.86 112.05,34.05 112.08,34.05 112.45,34.42 112.45,34.45 R1821.1 113.08,35.08 R1738.1 ; R1104.2 126.82,56.56 v2(126.3,57.08) 126.52,57.08 v1(127.11,57.67) 128.02,58.58 128.02,59.1 127.65,59.47 127.12,59.47 126.86,59.21 124.82,59.21 124.05,58.44 124.05,58.33 120.73,55.02 120.7,55.02 120.45,54.76 114.7,54.76 114.4,55.07 v2(113.07,55.07)
  L5 w0.305: v2(131.47,57.31) 131.47,56.77 131.74,56.5 131.74,49.65 131.47,49.38 131.47,47.17 131.66,46.99 131.66,45.43 131.79,45.3 131.79,39.91 128.84,36.96 126.93,36.96 124.59,34.62 124.59,33.95 124.79,33.75 124.79,32.61 v2(124.28,32.09)
  L5 w0.508: v2(113.03,51.76) 112.23,52.56 112.23,54.47 112.82,55.07 v2(113.07,55.07)
  L6 w0.305: v2(126.3,57.08) 127.63,57.08 127.68,57.14 129.35,57.14 129.52,57.31 v2(131.47,57.31)
  L6 w0.508: v2(111.81,33.71) 112.39,34.29 113.23,34.29 116.77,30.75 118.68,30.75 119.57,31.64 123.82,31.64 v2(124.28,32.09)
  BOTTOM w0.127: CPU1.CP23 112.96,51.69 v2(113.03,51.76)
  BOTTOM w0.254: CPU1.CD15 CPU1.CD16 ; CPU1.CD16 105.79,56.59 CPU1.CC15 ; CPU1.CD16 106.44,55.85 v2(106.11,55.52) ; CPU1.CC19 CPU1.CC18 106.11,55.43 v2(106.11,55.52) ; v2(106.11,55.52) 106.44,55.2 CPU1.CD18 CPU1.CD19 ; CPU1.CP17 112.59,55.47
  BOTTOM w0.305: v2(113.07,55.07) 113.07,55.09 112.69,55.47 112.59,55.47
  BOTTOM w0.508: R2117.1 126.3,56.4 v2(126.3,57.08) 126.45,57.23 R2111.1
1D8V_VGA_EN: length 10.8
  TOP w0.102: v2(127.66,66.77) 127.57,66.68 v1(127.01,66.68) ; PC8612.1 132.26,63.01 v2(132.09,63.19)
  L3 w0.102: v2(127.66,66.77) 127.81,66.77 130.2,64.38 130.2,64.37 130.46,64.11 130.46,64.11 131.39,63.19 v2(132.09,63.19)
  BOTTOM w0.102: v2(127.66,66.77) 127.66,66.61 127.61,66.56 Q8613.G ; R8621.2 133.66,62.58 133.38,62.87 132.41,62.87 v2(132.09,63.19)
1D8V_VGA_EN#: length 3.8
  BOTTOM w0.102: PR8650.2 126.94,67.79 Q8613.D 125.94,68.22 v1(125.94,68.96) 125.94,69.82 R8620.1
1D8V_VGA_EN_OR: length 5.2
  BOTTOM w0.102: Q8602.D 132,63.71 131.66,63.37 131.66,62.54 131.76,62.43 v1(131.82,62.43) R8621.1 132.8,62.43 R8637.2
1D8V_VGA_EN_OR#: length 14.2
  BOTTOM w0.102: Q8602.G 132.99,63.55 v1(132.99,65.7) 132.99,65.75 132.56,66.18 131.52,66.18 131,66.7 R8634.2 131.49,66.78 Q8603.G 131.87,67.52 132.63,68.28 132.63,72.03 132.52,72.13 Q8612.6 132.08,71.57 131.78,71.27 131.01,71.27 130.78,71.04 Q8612.3
1D8V_VGA_EN_R: length 19.4
  TOP w0.102: v2(136.82,78.75) 137.23,79.15 140.69,79.15 142.11,80.57 144.7,80.57 145.27,80.01 v1(146.25,80.01) 146.62,79.64 146.66,79.64 146.91,79.39 146.91,79.35 147.52,78.74 149.63,78.74 151.73,80.83 PR8621.2
  BOTTOM w0.102: PU8601.7 135.79,79.13 PC8607.1 136.14,78.8 136.77,78.8 v2(136.82,78.75)
1D8V_VGA_EN_R#: length 10.5
  BOTTOM w0.102: C8601.2 131.21,75.82 Q8611.G 130.55,75.15 129.92,75.15 129.48,75.6 128.67,75.6 127.79,74.72 v1(127.79,73.67) 127.99,73.47 127.99,72.44 127.73,72.18 127.44,72.18 126.43,71.18 126.43,71.17 R8620.2
1D8V_VGA_PLL: length 2.7
  BOTTOM w0.203: GPU1.M6 GPU1.N6 v2(152.86,59.1) ; v2(154.47,57.67) 154.1,57.3 GPU1.L6
  BOTTOM w0.305: GPU1.F11 159.93,57.3 159.93,56.74 v2(159.97,56.7)
  vias: v1(154.53,58.97)
1D8V_VGA_S0: length 60.1
  TOP w0.305: Q7601.G 139.04,52.89 R7957.1 ; C7631.1 154.01,69.75 v2(154.01,69.67)
  TOP w0.508: v2(137.01,53.44) 137.1,53.44 137.48,53.82 Q7601.G ; R8529.1 145.62,79.32 145.83,79.32 145.95,79.2 146.48,79.2 v2(146.48,79.21)
  L6 w0.508: v2(146.48,79.21) 146.12,78.85 145.23,78.85 144.4,78.03 143.36,78.03 143.34,78.05 131.35,78.05 129.48,76.19 129.48,74.06 v2(129.08,73.66) ; v2(150.2,64.42) 147.63,61.85 146.61,61.85 145.15,60.39 145.15,59.96 144.79,59.6 144.76,59.6 141.79,56.63 140.51,56.63 140.44,56.56 139.17,56.56 139.06,56.45 139.02,56.45 137.95,55.38 137.95,54.38 v2(137.01,53.44)
  L8 w0.508: v2(150.79,61.41) 151.38,60.81 151.91,60.81 152.26,60.46 152.26,59.95 152.23,59.92 152.23,58.3 154.41,56.13 156.09,56.13 156.17,56.22 156.68,56.22 156.77,56.13 158.17,56.13 v2(158.18,56.11)
  BOTTOM w0.356: GPU1.G8 157.57,56.15 157.61,56.11 v2(158.18,56.11) 158.18,56.69 158.2,56.7 GPU1.G9
  BOTTOM w0.508: Q8611.D v2(129.08,73.66) 128.92,73.5 C8602.1 128.92,72.09 R8623.1
  vias: v1(158.32,82.34) v2(150.66,64.98) v2(156.88,81.44) v2(156.89,78.78) v2(157.67,81.97)
1D8V_VGA_S0_DISCHG: length 3.3
  BOTTOM w0.102: R8623.2 v1(129.69,70.97) 129.69,70.73 130.03,70.4 130.03,70.12 130.48,69.67 130.48,69.66 130.84,69.3 Q8603.D
1D8V_VGA_S0_PG: length 3.1
  BOTTOM w0.102: PR8624.2 130.97,78.3 131.78,78.3 v1(132,78.53) 132.61,79.13 PU8601.2
1D24V_VCCDPHY: length 2.3
  BOTTOM w0.254: CPU1.CA24 104.34,51.05 103.98,51.05 CPU1.BY24 CPU1.BY23 CPU1.CA23
1D24V_VCCDPHY_EC: length 5.2
  TOP w0.254: C2218.1 114.49,49.61 115.15,49.61 115.37,49.83 v2(115.35,49.83)
  BOTTOM w0.254: CPU1.CP25 114.76,50.43 v2(115.35,49.83) 115.35,49.88 v1(115.76,50.29)
1D35V_PGOOD: length 68.6
  L3 w0.102: v2(144.57,81.83) 144.62,81.79 144.62,80.97 145.95,79.64 146.66,79.64 152.02,74.28 154.96,74.28 155.92,73.32 155.92,67.56 156.02,67.47 156.02,66.73 153.76,64.47 153.76,60.72 157.78,56.71 158.45,56.71 161.15,54.02 162.68,54.02 166.15,50.55 166.15,49.04 165.85,48.75 165.85,48.37 166.18,48.04 168.27,48.04 171.52,44.78 171.52,36.86 171.62,36.75 171.62,36.7 v2(173.37,34.95)
  BOTTOM w0.102: v2(173.37,34.95) 173.37,34.51 173.69,34.19 v1(173.98,34.19) 174.44,34.66 PR8630.1 ; v2(144.57,81.83) 144.52,81.88 R8530.1
1D35V_PGOOD_L: length 2
  BOTTOM w0.102: U8502.2 144.66,83.5 R8530.2 144.49,83.39 v1(144.49,84.28)
1D35V_PWR:
  vias: v1(183.38,41.35)
1D35V_VGA_EN: length 22.6
  TOP w0.102: v2(186.01,40.31) 186.18,40.48 v1(186.73,40.48) 187.43,40.48 R8604.1
  L6 w0.102: v2(186.01,40.31) 185.97,40.31 185.58,39.91 185.58,37.12 184.63,36.17 179.09,36.17 179.06,36.21 178.7,36.21 178.67,36.17 178.53,36.17 176.8,34.44 175.61,34.44 175.06,34.99 v2(174.1,34.99)
  BOTTOM w0.102: PR8631.1 174.44,34.99 v2(174.1,34.99) ; D8601.3 185.79,40.09 v2(186.01,40.31) 186.19,40.31 186.94,41.05 Q8616.2
1D35V_VGA_EN#: length 6.1
  TOP w0.102: v2(190.23,40.09) 189.5,40.82 v1(189.07,40.82) 188.99,40.75 188.99,40.31 R8616.2
  BOTTOM w0.102: Q8616.6 189.87,40.4 189.9,40.37 189.95,40.37 v2(190.23,40.09) 190.23,40.47 189.65,41.05 Q8616.5
1D35V_VGA_S0: length 37
  TOP w0.508: R7816.1 182.27,63.58 181.72,64.12 v2(181.72,64.24) ; C8226.1 185.86,75.43 185.32,74.89 v2(185.2,74.89)
  L5 w0.076: 186.7,58.73 186.7,58.35 ; 178.65,81.67 178.98,81.67 ; 180.3,56.32 180.3,55.99 ; 182.93,57.34 183.26,57.34 ; 181.1,56.33 181.1,56 ; 189.11,56.32 189.11,56 ; 180.3,51.54 180.3,51.21 ; 178.13,50.97 178.48,50.97 ; 173.06,81.67 173.39,81.67 ; 186.44,50.97 186.14,50.97 ; 176.23,80.87 176.58,80.87 ; 178.65,80.85 178.98,80.85 ; 188.3,56.32 188.3,56.01 ; 181.13,55.39 181.13,55.07 ; 190.23,50.16 190.58,50.16 ; 188.3,51.54 188.3,51.19 ; 176.8,80.62 176.8,80.35 ; 179.51,56.3 179.51,56 ; 187.72,49.36 188.07,49.36 ; 177.9,51.52 177.9,51.2 ; 184.29,58.73 184.29,58.37 ; 186.7,51.54 186.7,51.16 ; 186.94,50.97 187.26,50.97 ; 182.41,83.01 182.41,82.68 ; 173.36,80.86 173.03,80.86 ; 179.69,50.96 180.1,50.96 ; 178.95,56.56 179.27,56.56 ; 182.66,74.48 182.99,74.48 ; 187.51,51.5 187.51,51.2 ; 184.8,81.46 184.8,81.1 ; 177.1,56.32 177.1,55.96 ; 179.46,74.47 179.76,74.47 ; 187.74,55.76 188.1,55.76 ; 179.2,74.7 179.2,75.02 ; 180.55,56.55 180.87,56.55 ; 178.63,82.48 178.98,82.48
  L6 w0.076: 184.8,81.46 184.8,81.1 ; 182.93,57.34 183.26,57.34 ; 187.74,55.76 188.1,55.76 ; 190.5,50.17 190.5,50.16 190.23,50.16 ; 181.13,55.39 181.13,55.07 ; 176.8,80.62 176.8,80.35 ; 182.66,74.48 182.99,74.48 ; 186.94,50.97 187.26,50.97 ; 180.55,56.55 180.87,56.55 ; 178.65,80.85 178.98,80.85 ; 179.46,74.47 179.76,74.47 ; 181.1,56.33 181.1,56 ; 179.2,74.7 179.2,75.02 ; 180.3,51.54 180.3,51.21 ; 186.7,51.54 186.7,51.16 ; 188.3,51.54 188.3,51.19 ; 176.23,80.87 176.58,80.87 ; 187.51,51.5 187.51,51.2 ; 179.69,50.96 180.1,50.96 ; 186.44,50.97 186.14,50.97 ; 179.51,56.3 179.51,56 ; 184.29,58.73 184.29,58.37 ; 186.7,58.73 186.7,58.35 ; 173.36,80.86 173.03,80.86 ; 177.1,56.32 177.1,55.96 ; 178.65,81.67 178.98,81.67 ; 173.06,81.67 173.39,81.67 ; 180.3,56.32 180.3,55.99 ; 188.3,56.32 188.3,56.01 ; 177.9,51.52 177.9,51.2 ; 187.72,49.36 188.07,49.36 ; 178.95,56.56 179.27,56.56 ; 189.11,56.32 189.11,56 ; 178.63,82.48 178.98,82.48 ; 178.13,50.97 178.48,50.97 ; 182.41,83.01 182.41,82.68
  BOTTOM w0.203: 167.48,67.25 166.89,67.25 166.46,66.82 166.46,66.23 166.35,66.12 GPU1.H24
  BOTTOM w0.305: v2(164,67.89) 164.58,67.89 164.6,67.88 164.6,67.88 ; GPU1.L26 165.73,69.01 165.88,69.01 166.69,69.82 166.76,69.82 166.79,69.84 v2(167.23,69.84) ; v2(169.71,65.79) 169.41,65.5 GPU1.E26
  BOTTOM w0.356: 170.98,63.76 GPU1.B26 ; 170.98,63.76 171.62,63.76 171.63,63.77 171.71,63.77 171.71,63.77 171.76,63.77 171.76,63.74 171.84,63.66 171.84,63.68 v2(171.86,63.68) ; 170.98,63.76 170.97,63.76 169.85,63.76 GPU1.C25 ; v2(166.93,63.79) 166.94,63.78 167.49,63.78 167.51,63.76 GPU1.E23 ; 167.48,67.25 GPU1.H26 167.57,67.34 167.63,67.34 v2(167.94,67.64)
  BOTTOM w0.508: v2(188.77,42.88) 188.77,43.4 188.28,43.89 R8622.1
  vias: v1(171.15,84.57) v1(177.06,61.12) v1(187.43,72.54) v1(191.26,52.57) v2(157.72,70.52) v2(161.09,68.5) v2(161.62,61.06) v2(161.68,59.62) v2(163.41,66.12) v2(163.74,63.01) v2(164.03,65.55) v2(164.38,63.96) v2(172.17,81.57) v2(173.08,83.79) v2(173.21,74.89) v2(173.75,72.24) v2(173.9,76.54) v2(174,81.24) v2(174,80.48) v2(174.15,79.56) v2(174.81,80.48) v2(174.81,74.89) v2(175.15,72.29) v2(175.6,81.27) v2(175.64,79.62) v2(176.34,83.83) v2(176.43,76.59) v2(176.85,72.33) v2(177.08,84.52) v2(177.19,74.9) v2(177.25,47.93) v2(177.42,59.49) v2(177.5,50.58) v2(177.98,82.87) v2(177.99,82.06) v2(178,74.86) v2(178.17,52.29) v2(178.27,72.28) v2(178.3,56.94) v2(178.72,55.15) v2(179.01,59.52) v2(179.1,51.36) v2(179.11,50.56) v2(179.58,47.99) v2(179.76,52.3) v2(179.9,56.96) v2(180.05,55.26) v2(180.4,82.07) v2(180.39,74.87) v2(180.62,72.27) v2(180.58,59.5) v2(180.74,84.56) v2(181.17,81.26) v2(181.5,50.56) v2(181.57,72.25) v2(181.69,84.49) v2(182,82.07) v2(182.02,80.46) v2(181.98,76.56) v2(182,74.07) v2(182.3,56.16) v2(182.3,49.77) v2(182.8,82.05) v2(182.8,80.46) v2(183.21,72.14) v2(183.58,74.87) v2(184.39,82.07) v2(184.38,79.64) v2(184.37,76.51) v2(184.68,57.75) v2(184.7,49.76) v2(184.92,59.49) v2(185.1,72.24) v2(185.23,84.02) v2(185.5,56.16) v2(185.94,60.08) v2(186.02,47.18) v2(186.3,57.76) v2(186.3,49.76) v2(186.45,52.43) v2(187.61,60.33) v2(187.58,47.74) v2(187.89,50.56) v2(188.05,54.62) v2(188.07,52.39) v2(188.52,47.23) v2(189.55,59.45) v2(189.5,56.93) v2(189.47,55.28) v2(189.51,50.58) v4(175.81,46.14) v4(176.65,46.13) v4(177.49,46.14) v4(178.32,46.13) v4(179.21,46.13) v4(180.08,46.13) v4(186.81,79.74)
1D35V_VGA_S0_DISCHG: length 2.8
  BOTTOM w0.102: Q8616.3 188.05,42.55 188.05,43 R8622.2 188.07,43.03 187.46,43.65 v1(187.19,43.65)
2ND_M2_SSD_PEDET#: length 119.1
  TOP w0.102: v1(36.68,34.73) 36.17,34.73 v2(35.99,34.55)
  L3 w0.102: v2(35.99,34.55) 36.18,34.55 36.61,34.12 36.61,25.4 v2(34.34,23.13)
  L5 w0.102: v2(115.26,60.95) 114.22,60.95 112.34,59.07 112.34,56.43 110.82,54.91 110.82,50.84 110.15,50.17 106.16,50.17 105.58,49.59 102.05,49.59 100.84,48.38 100.48,48.38 100.22,48.64 100.22,49.85 99.81,50.26 98.72,50.26 98.59,50.14 74.88,50.14 73.04,51.98 72.12,51.98 72.09,51.95 71.37,51.95 71.03,51.6 71.03,51.54 70.79,51.3 65.26,51.3 62.37,48.41 58.05,48.41 52.43,42.79 52.43,40.05 49.59,37.21 45.34,37.21 43.24,35.11 36.45,35.11 35.99,34.65 v2(35.99,34.55)
  BOTTOM w0.076: CPU1.CM10 110.87,60.17 112.03,60.17 112.11,60.26 112.2,60.26 112.34,60.4 114.03,60.4
  BOTTOM w0.102: 114.03,60.4 114.71,60.4 v2(115.26,60.95) ; v2(34.34,23.13) 34.47,23.26 R1605.1
3D3V_AUX_S5: length 342.7
  TOP w0.508: R2463.1 20.79,22.92 v2(21.12,23.25) ; v2(188.43,39.15) 188.5,39.22 R8616.1 ; v2(146.75,49.06) 147.02,48.79 154.84,48.79 156.86,46.77 163.88,46.77 v2(165.31,48.19) ; v2(97.02,15.07) 95.24,15.07 94.83,14.66 92.41,14.66 91.75,14 91.75,12.51 91.39,12.15 89.08,12.15 88.41,11.48 v2(88.41,11.23) 88.41,9.74 87.54,8.87 PR4505.1 ; v2(14.1,46.28) 14.11,46.28 14.17,46.34 R6743.1 14.91,46.52 R6744.1 ; v2(145.26,81.65) 145.31,81.61 145.96,81.61 R8612.1 ; 125.08,64.78 v2(125.1,64.78) ; 125.08,64.78 125.66,65.36 R1726.1 126.2,65.36 126.91,66.07 R1727.1 ; 125.08,64.78 124.74,64.44 124.74,63.16 125.35,62.55 R1737.1 ; v2(38.44,9.26) 38.44,11 39.24,11.8 39.24,14.62 41.05,16.43 41.05,17.37 40.02,18.4 38.28,18.4 36.38,20.3 36.08,20.3 34.51,21.87 v2(34.51,22.51) ; v2(150.55,80.6) 149.97,80.02 R8613.2
  L3 w0.508: v2(88.41,11.23) 88.2,11.02 80.78,11.02 80.24,10.48 61.5,10.48 59.75,8.73 38.98,8.73 v2(38.44,9.26) ; v2(188.43,39.15) 187.03,39.15 185.43,37.55 185.43,35.07 184.92,34.56 183.16,34.56 181.53,32.93 181.53,32.73 181.16,32.36 180.96,32.36 180.86,32.26 179.48,32.26 178.89,32.85 175.74,32.85 174.27,34.32 173.11,34.32 172.74,34.69 172.74,34.97 171.19,36.52 171.19,36.57 171.03,36.73 171.03,37.31 170.92,37.42 170.92,44.69 170.8,44.8 170.8,44.89 168.14,47.55 168.09,47.55 168.09,47.55 167.73,47.55 167.73,47.55 165.95,47.55 v2(165.31,48.19) ; v2(146.75,49.06) 146.75,49.97 143.28,53.45 142.4,53.45 141.77,54.08 141.77,57.05 141.94,57.22 141.94,57.75 141.22,58.47 v2(141.22,58.7) ; v2(21.12,23.25) 21.15,23.25 21.15,23.27 21.6,22.81 30.83,22.81 30.91,22.9 31.44,22.9 31.98,22.36 34.36,22.36 v2(34.51,22.51)
  L5 w0.508: v2(145.26,81.65) 145.16,81.55 145.16,79.01 144.86,78.71 144.86,76.9 142.46,74.49 142.46,72.44 142.64,72.26 142.64,61.09 141.22,59.67 v2(141.22,58.7) ; v2(97.02,15.07) 97.65,15.7 97.91,15.96 102.29,15.96 102.95,16.63 113.13,16.63 113.71,16.06 114.7,16.06 119.59,20.95 119.59,21.34 119.62,21.37 119.62,21.9 119.59,21.92 119.59,21.99 119.61,22.01 119.61,22.43 119.68,22.5 119.79,22.5 122.04,24.75 122.04,30.82 122.62,31.4 122.62,38.96 123.93,40.27 124.45,40.27 125.17,40.99 125.17,45.22 125.72,45.77 125.72,47.53 126.46,48.26 126.46,48.84 125.5,49.8 125.5,50.55 124.56,51.49 124.56,54.63 123.22,55.97 123.22,58.38 124.31,59.46 124.31,63.98 v2(125.1,64.78)
  L6 w0.508: v2(21.12,23.25) 19.71,21.84 19.71,20.25 19.12,19.66 18.6,19.66 17.75,18.82 17.75,16.46 17.46,16.18 17.46,14.4 18.67,13.2 18.67,8.52 v2(18.03,7.88)
  L8 w0.508: v2(14.1,46.28) 13.33,46.28 10.01,42.96 10.01,41.96 11.53,40.43 13.25,40.43 15.01,38.68 15.01,34.33 15.31,34.03 15.31,31.54 15.15,31.38 15.15,27.96 18.24,24.87 19.3,24.87 20.9,23.27 21.1,23.27 v2(21.12,23.25) ; v2(145.26,81.65) 145.66,81.25 147.06,81.25 147.71,80.6 v2(150.55,80.6)
  BOTTOM w0.203: v1(88.61,11.99) 88.61,11.43 v2(88.41,11.23) 88.19,11.01 PG4532.1
  BOTTOM w0.508: v2(146.75,49.06) 146.35,48.66 145.18,48.66 R7952.1 ; v2(14.1,46.28) 14.49,46.68 R6702.1 ; v2(18.03,7.88) 17.8,7.65 R2505.1
3D3V_CAMERA_S0: length 9.6
  TOP w0.508: R5501.2 58.99,80.92 58.2,80.92 C5503.1 56.92,81.5 56.81,81.39 v1(56.2,81.39) 52.82,81.39 52.39,80.95 v2(52.21,80.95)
  BOTTOM w0.203: v2(52.21,80.95) 52.21,80.78 51.88,80.45 51.88,79.58 51.6,79.3 LCD1.33
3D3V_CARD: length 1.2
  TOP w0.508: CARD1.4 v2(2.51,13.69)
  vias: v1(5.64,11.69) v2(3.23,9.63)
3D3V_CARD_S5:
  vias: v1(13.3,15.28) v2(3.21,14.76) v2(14.11,15.68)
3D3V_ECVBAT: length 7.6
  TOP w0.508: R2473.2 16.93,24.24 18.34,24.24 v2(18.38,24.19) 18.38,24.47 18.77,24.87 ; R2497.1 20.1,25.45 20.3,25.24 20.95,25.24 21.42,24.77 22.26,24.77 v1(22.36,24.86) C2428.1
  BOTTOM w0.203: U2401.122 18.06,23.87 v2(18.38,24.19)
3D3V_FLASH: length 26.6
  TOP w0.254: R7222.1 30.54,61.5 30.6,61.44 ; v2(34.38,65.54) 34.18,65.74 R7230.2 R7225.2 33.41,66.43 R7226.2 ; v3(30.6,61.45) 30.6,61.44 ; 30.6,61.44 30.69,61.52 30.94,61.52 C7211.1 ; v2(30.06,58.63) 29.28,57.85 v1(28.38,57.85) 25.99,57.85 R7204.1
  L3 w0.254: v2(30.06,58.63) 30.05,58.62 29.39,58.62 29.1,58.92 29.1,59.94 v3(30.6,61.45)
  L5 w0.254: v3(30.6,61.45) 30.66,61.45 31.86,62.64 31.86,63.23 34.17,65.54 v2(34.38,65.54)
  BOTTOM w0.152: v3(30.6,61.45) 30.24,61.45 30.04,61.64 U7201.G1
  BOTTOM w0.254: R7228.2 34.05,65.54 v2(34.38,65.54) ; v2(34.38,65.54) 35.19,66.35 U7202.8 ; v2(34.38,65.54) 34.44,65.54 34.89,65.09 34.89,65.03 35.8,64.11 C7244.1
3D3V_FPR_VDD: length 4
  TOP w0.305: v2(143.88,8.44) 143.94,8.37 C9201.1
  TOP w0.356: v1(141.15,9.47) R9201.1
  TOP w0.508: v2(143.88,8.44) 143.07,9.24 R9213.2 142.89,9.47 R9201.1
3D3V_GSEN2: length 16.7
  TOP w0.254: v2(195.63,33.14) R7001.2 193.95,33.14 C7006.1 193.99,32.97 C7005.1 193.99,32.08 U7002.9 193.97,31.1 U7002.10 ; v2(192.01,27.26) 192.01,27.15 192.48,26.69 v1(192.53,26.69) 193.02,26.69 R7016.2 194.19,27.07 R7008.1
  BOTTOM w0.254: v2(195.63,33.14) 196.25,32.52 196.25,28.81 195.49,28.05 192.39,28.05 192.01,27.67 v2(192.01,27.26)
3D3V_HINGE_S0:
  vias: v1(62.7,78.59)
3D3V_LCDVDD_R:
  vias: v1(44.01,81.44) v2(44.46,81.1) v2(63.17,81.68) v4(43.92,80.59) v4(55.92,75.33) v4(56.93,75.33) v4(63.23,80.95)
3D3V_LCDVDD_R_SEN: length 102.4
  TOP w0.127: v2(48.12,81.01) 47.87,81.01 47.71,81.16 47.71,81.46 47.56,81.62 ; v1(47.71,81.77) 47.56,81.62 ; 47.56,81.62 47.41,81.77 45.94,81.77 R6620.1
  L3 w0.127: v2(116.76,88.11) 116.76,88.27 116.37,88.66 93,88.66 92.99,88.65 87.38,88.65 87.3,88.56 63.47,88.56 63.33,88.71 61.28,88.71 60.49,87.91 58.63,87.91 57.81,87.1 57.81,87.06 57.7,86.94 57.7,83.87 55.29,81.47 48.58,81.47 v2(48.12,81.01)
  L8 w0.127: v2(122.3,72.41) 122.3,72.81 122.43,72.94 122.81,72.94 124.7,74.83 124.7,77.07 125.74,78.1 125.74,79.45 124.44,80.75 124.44,84.19 123.24,85.39 123.21,85.39 122.81,85.78 122.81,85.82 122.03,86.59 121.29,86.59 120.8,86.59 117.67,86.59 117.02,87.24 117.02,87.85 v2(116.76,88.11)
  BOTTOM w0.127: v2(122.3,72.41) 122.59,72.7 122.59,73.3 122.65,73.36 CN1.6
3D3V_LCDVDD_S0: length 6.3
  TOP w0.203: R6621.2 45.22,80.99 v2(45.11,80.87)
  L3 w0.508: v2(45.11,80.87) 45.11,81.35 45.09,81.36 45.09,81.36 44.72,81.74 44.72,81.74 44.6,81.85 42.09,81.85 v2(40.65,80.42)
  vias: v1(39.79,69.66) v2(39.24,71.41) v2(39.16,70.76) v4(40.57,79.69)
3D3V_LCDVDD_S0_R: length 103.7
  TOP w0.127: R6621.1 45.89,81.51 47.3,81.51 47.46,81.36 47.46,81.26 v2(47.18,80.98) ; v1(117.16,88.53) v2(117.58,88.11)
  L3 w0.127: v2(47.18,80.98) 47.9,81.7 55.2,81.7 57.47,83.97 57.47,87.04 57.58,87.15 57.58,87.19 58.54,88.14 58.76,88.14 60.4,88.14 61.19,88.93 63.43,88.93 63.57,88.79 87.2,88.79 87.29,88.88 92.9,88.88 92.91,88.89 116.46,88.89 116.73,88.62 117.07,88.62 v2(117.58,88.11)
  L8 w0.127: v2(122.95,72.41) 122.95,72.75 124.93,74.74 124.93,76.97 125.97,78.01 125.97,79.55 124.67,80.85 124.67,84.28 123.33,85.62 123.3,85.62 123.04,85.88 123.04,85.91 122.13,86.82 121.29,86.82 120.8,86.82 117.76,86.82 117.25,87.34 117.25,87.78 v2(117.58,88.11)
  BOTTOM w0.127: v2(122.95,72.41) 122.98,72.41 122.82,72.57 122.82,72.57 122.82,73.21 123.05,73.43 CN1.8
3D3V_MIC_VCC: length 12.1
  TOP w0.254: v2(51.35,79.79) 52.12,79.79 53.06,80.73 v1(54.53,80.73) 55.71,80.73 56.93,79.51 57.32,79.51 57.75,79.08 57.75,78.3 58.27,77.79 R5511.2 58.51,76.81 C5515.1
  BOTTOM w0.203: LCD1.32 51.2,79.64 v2(51.35,79.79)
3D3V_MUX: length 50
  TOP w0.203: v2(17.21,39.43) 18.37,39.43 18.57,39.22 U7101.28 ; U7101.20 22.51,38.18 v2(22.64,38.31) ; U7101.1 18.18,33.04 18,33.23 v2(17.92,33.23) ; U7101.6 v2(20.57,32.14)
  TOP w0.381: v2(17.39,30.99) 17.39,30.78 17.67,30.49 17.79,30.49 R7147.1
  TOP w0.508: R7118.1 16.54,39.46 16.57,39.43 v2(17.21,39.43) ; v2(14.21,32.97) 14.2,32.99 14.2,33.71 R7140.1 ; v2(22.64,38.31) 22.64,39.07 23.41,39.83 23.41,40.7 C7117.1 ; v2(23.23,33.99) 23.44,33.78 R7145.1 ; R7147.1 R7152.1 18.82,29.9 17.92,29 C7115.1
  L5 w0.508: v2(17.39,30.99) 18.44,30.99 19.02,31.56 19.54,31.56 20.12,32.14 v2(20.57,32.14)
  L8 w0.508: v2(17.21,39.43) 17.92,38.71 v2(17.92,33.23) 18.07,33.08 19.98,33.08 20.57,32.49 v2(20.57,32.14)
  BOTTOM w0.508: v2(17.21,39.43) 17.23,39.4 C7116.1 ; 23.53,35.93 23.53,35.25 23.49,35.2 23.49,34.82 R7124.2 23.47,34.23 v2(23.23,33.99) 21.5,33.99 20.66,33.15 20.66,32.76 20.57,32.68 v2(20.57,32.14) ; 23.53,35.93 23.74,36.14 23.74,38.77 23.38,39.13 R7174.1 22.78,38.44 v2(22.64,38.31) ; 23.53,35.93 23.15,36.31 R7171.1 ; C7116.1 17.44,38.48 C7119.1 18.24,38.46 R7101.1 ; C7116.1 16.7,38.69 16.4,38.38 16.4,37.68 v1(16.34,37.63) 15.79,37.08 15.79,36.56 R7121.1 15.67,35.93 R7142.1 14.85,35.26 14.65,35.06 14.59,35.06 14.37,34.84 14.37,34.78 14.11,34.52 14.11,33.08 v2(14.21,32.97) ; v2(17.92,33.23) 18.11,33.41 C7118.1
3D3V_RTC: length 205.8
  TOP w0.508: R2473.1 16.93,22.95 16.36,22.38 14.74,22.38 v2(14.48,22.12) ; v2(161.46,2.24) 161.95,2.74 162.33,2.74 163.1,3.51 164.47,3.51 165.85,4.89 165.85,5.25 167.25,6.65 168.61,6.65 169.36,5.9 175.94,5.9 175.95,5.89 176.13,5.89 176.35,5.66 176.35,5.49 176.35,4.78 176.86,4.27 179.75,4.27 182.69,7.21 182.69,8.14 183.29,8.74 R2708.1
  L3 w0.508: v2(161.46,2.24) 161.33,2.37 159.05,2.37 158.6,1.92 155.9,1.92 155.61,1.63 150.26,1.63 149.97,1.92 147.4,1.92 146.64,2.69 138.76,2.69 138.41,2.34 136.11,2.34 135.69,1.92 133.08,1.92 132.88,1.72 129.7,1.72 129.49,1.92 111.1,1.92 110.95,1.93 110.83,1.93 110.02,1.94 108.6,1.94 108.19,2.36 108.17,2.36 101.86,8.67 84.24,8.67 82.99,7.42 82.27,7.42 81.41,8.27 81.39,8.27 81.17,8.5 71.28,8.5 70.42,7.64 65.88,7.64 64.58,6.34 38.53,6.34 37.86,5.68 34.59,5.68 34.22,6.05 34.22,6.06 33.82,6.46 27.08,6.46 26.93,6.61 24.12,6.61 23.61,6.09 21.98,6.09 21.36,6.71 v2(19.12,6.71)
  L8 w0.508: v2(19.12,6.71) 17.31,6.71 14.36,9.65 14.36,11.58 12.53,13.41 12.53,20.07 13.4,20.93 13.69,20.93 14.48,21.72 v2(14.48,22.12)
  BOTTOM w0.508: Q2507.S 18.93,5.81 18.93,6.52 v2(19.12,6.71) 18.86,6.97 v1(18.86,7.39) C2503.1 18.11,8.7 D2501.3
3D3V_RTC_SYS: length 5
  BOTTOM w0.254: v1(14.44,10.19) 14.44,10.18 15.43,9.19 D2501.1 16.21,8.32 16.24,8.29 16.43,8.29 17.04,7.67 17.04,6.99 R2505.2
3D3V_S0: length 516.2
  TOP w0.203: 122.62,35.62 121.35,34.35 119.86,34.35 118.31,35.9 118.3,35.92 118.12,36.1 117.92,36.23 117.7,36.32 117.69,36.33 117.6,36.42 R1820.1 ; R6612.1 118.34,18.98 118.81,18.52
  TOP w0.305: R5540.1 34.1,69.13 v2(34.1,69.98) ; R7001.1 v2(195.6,32.27) ; EC8943.1 v2(33.03,81.39) ; EC8947.1 127.57,81.11 v4(127.47,81.01) ; EC8944.1 64.55,12.85 v4(64.88,13.18) ; R2489.1 15.07,11.66 13.66,10.25 13.23,10.25 12.4,9.42 v2(12.4,9.12) ; R2043.1 121.56,21.01 121.56,15.79 121.14,15.37 119.17,15.37 119.09,15.45 119.03,15.45 119.02,15.46 119.06,15.46 119.06,15.46 v4(119.04,15.46) ; v2(15.41,54.06) 15.86,54.51 15.86,55.53 RN401.2 15.31,55.57 15.15,55.73 15.15,56.11 15.29,56.24 RN401.1 15.99,56.32 EC8948.1 15.89,57.08 v2(15.35,57.61)
  TOP w0.356: R5517.1 50.66,80.34 v2(50.66,80.9)
  TOP w0.381: v2(35.17,22.24) 35.95,21.46 38.93,21.46 39.92,20.47 39.92,19.47 40.06,19.33 40.06,19.17 41.62,17.61 41.62,16.65 Q2414.G ; v2(124.5,44.12) 124.5,45.25 127.22,47.98 127.22,49.92 v2(127.56,50.25)
  TOP w0.508: R5518.1 48.03,78.54 47.57,79 R5504.1 47.33,79.61 v2(47.28,79.66) ; v2(30.98,21.52) 30.98,21.53 30.84,21.67 DB1.10 28.4,21.67 27.89,22.18 25.23,22.18 R2430.1 R2449.1 ; R2053.1 125.77,40.81 125.48,41.1 124.63,41.1 v2(124.51,41.23) ; v2(118.67,14.5) 117.68,13.5 117.68,8.06 R6502.1 ; v2(189.02,33.06) 189.03,33.04 R9102.1 ; v2(127.38,58.84) 127.12,58.58 125.08,58.58 124.69,58.18 124.69,57.19 120.33,52.84 116.32,52.84 116.03,53.13 ; v2(15.35,57.61) 14.6,58.37 v2(14.6,59.31) ; PR8634.1 178.22,38.21 v2(177.9,38.52)
  L3 w0.254: v2(15.41,54.06) 15.46,54.06 15.35,54.16 v2(15.35,57.61)
  L3 w0.381: v2(50.05,70.72) 48.93,71.84 40.01,71.84 39.77,72.08 36.17,72.08 34.1,70.01 v2(34.1,69.98) ; v2(123.67,62.77) 123.67,62.01 126.85,58.84 v2(127.38,58.84) ; v2(33.03,81.39) 33.03,81.23 27.91,76.11 20.88,76.11 19.54,74.77 19.54,72.16 18.59,71.21 v2(18.59,70.11)
  L3 w0.508: v2(195.6,32.27) 195.6,32.27 194.81,33.06 v2(189.02,33.06) ; v2(53.99,80.22) 53.99,79.8 54.84,78.95 60.35,78.95 60.96,78.35 v4(61.9,78.35) ; v2(35.17,22.24) 35.35,22.24 35.97,22.86 41.04,22.86 v2(41.77,22.12)
  L5 w0.381: v2(99.68,70.58) 99.68,70.58 100.35,71.25 105.35,71.25 106.97,69.64 v2(112,69.64)
  L5 w0.508: v2(127.56,50.25) 127.56,50.46 128.16,51.05 128.36,51.05 128.73,51.43 128.73,52.5 128.07,53.17 128.07,55.01 127.38,55.71 127.38,58.83 v2(127.38,58.84) ; v2(129.36,32.73) 132.31,32.73 134.95,30.09 134.95,30.04 v2(135.67,29.32) 135.8,29.46 140.38,29.46 141.69,28.14 141.69,27.62 142.48,26.84 143,26.84 144.12,27.95 145.8,27.95 146.9,29.06 146.9,29.36 147.61,30.07 149.77,30.07 150.17,29.67 153.35,29.67 154.82,28.21 159.49,28.21 161.34,26.36 162.2,26.36 163.63,27.79 163.63,30.8 162.52,31.9 162.52,33.44 164.07,34.98 168.31,34.98 168.7,34.59 170.09,34.59 170.48,34.98 171.54,34.98 172.37,34.16 173.28,34.16 v2(174.01,33.43) 176.37,33.43 177.9,34.97 v2(177.9,38.52) 178.59,38.52 181.72,41.65 186.06,41.65 187.3,42.89 187.3,42.92 v2(187.36,42.98) 187.36,38.75 188.82,37.29 188.82,34.74 189.02,34.54 v2(189.02,33.06) ; v2(28.92,2.49) 24.07,2.49 22.32,4.24 22.32,5.49 17.71,10.09 15.62,10.09 14.99,9.45 12.73,9.45 v2(12.4,9.12) ; v2(149.29,73.05) 147.63,74.71 147.63,82.2 v2(147.61,82.22)
  L6 w0.508: v2(123.67,62.77) 123.25,62.35 121.62,62.35 119.19,59.92 v2(119,59.92) ; v2(30.52,9.09) 30.52,12.37 30.99,12.84 30.99,15.04 30.18,15.86 30.18,20.72 v2(30.98,21.52) ; 37.13,41.04 37.19,41.1 47.69,41.1 47.77,41.01 48.84,41.01 v2(48.93,41.1)
  L8 w0.356: v2(50.66,80.9) 50.66,80.09 50.23,79.66 v2(47.28,79.66)
  L8 w0.381: v2(50.66,80.9) 51.18,80.38 52.45,80.38 52.78,80.71 53.56,80.71 53.99,80.29 v2(53.99,80.22) ; v2(47.28,79.66) 46.76,79.14 41.39,79.14 40.81,78.57 37.34,78.57 36.82,78.05 36.01,78.05 35.37,78.68 35.37,79.7 33.68,81.39 v2(33.03,81.39)
  L8 w0.508: v2(30.98,21.52) 31.56,21.52 33.83,23.8 34.91,23.8 35.28,23.43 35.28,22.35 v2(35.17,22.24) ; v2(124.5,44.12) 123.86,43.48 123.86,41.66 124.29,41.23 v2(124.51,41.23) ; v2(112,69.64) 112.46,69.64 118.14,63.96 121.78,63.96 122.96,62.77 v2(123.67,62.77) ; v2(18.59,70.11) 17.81,69.33 17.81,67.13 17.51,66.83 17.51,66.2 16.37,65.06 16.37,63.96 15.33,62.92 14.44,62.92 13.55,62.03 13.55,60.36 v2(14.6,59.31) ; v2(147.61,82.22) 147.61,82.24 146.94,82.91 144.6,82.91 142.9,81.2 v2(141.49,81.2)
  BOTTOM w0.203: 124.27,71.13 123.56,71.84 123.56,73.15 123.85,73.43 CN1.12
  BOTTOM w0.305: v2(15.35,57.61) 15.46,57.51 Q5702.5 ; v2(127.56,50.25) 127.56,48.84 R7948.1 ; v2(15.41,54.06) 15.46,54.06 Q5702.2 ; Q2601.2 125.85,44.42 125.26,43.83 124.83,43.83 124.54,44.12 v2(124.5,44.12) ; U8604.5 146.92,75.42 v2(149.29,73.05) ; 121.65,37.08 121.47,37.26 RN2602.1 120.32,37.86 v2(120.21,37.96) 120.21,38.01 120.73,38.53 RN2602.2
  BOTTOM w0.356: C2601.1 125.48,41.22 125.48,40.39 126.11,39.75 U2601.1 ; R7948.1 127.35,48.54 126.9,48.08 126.8,48.08 125.85,47.13 Q2601.5 ; U8605.5 141.07,78.91 140.72,79.26 140.72,80.07 141.18,80.52 R8541.1 141.28,80.99 v2(141.49,81.2)
  BOTTOM w0.381: U8502.5 147.39,82.44 v2(147.61,82.22) ; PR4609.1 50,70.67 v2(50.05,70.72) ; v2(99.68,70.58) 98.78,71.48 97.58,71.48 96.97,72.09 93.69,72.09 R1718.1
  BOTTOM w0.508: 121.65,37.08 122.26,36.47 123.69,36.47 124.28,35.87 124.28,34.41 125.84,32.85 127.11,32.85 R2603.1 128.48,33.45 C2602.1 129.2,32.73 v2(129.36,32.73) 129.5,32.58 R4041.1 ; 128.76,77.08 127.45,77.08 126.25,75.87 126.25,75.83 126.28,75.81 126.28,72.02 125.23,70.97 124.43,70.97 ; v2(187.36,42.98) 187.36,42.96 186.8,42.4 R7953.1 ; R8634.1 131,65.45 v2(131.24,65.2) ; v2(174.01,33.43) 174.45,33.43 PR8611.1 175.08,33.71 175.08,32.58 175.87,31.79 175.87,31.02 175.68,30.84 175.68,30.03 176.1,29.62 176.1,27.73 176.7,27.12 178.07,27.12 179.48,25.72 179.48,17.09 175.85,13.46 v2(174.24,13.46) ; v2(18.59,70.11) 18.73,70.26 R6405.1 ; v2(37.52,60.52) 37.45,60.58 R4005.1 ; Q5701.C 15.1,59.31 v2(14.6,59.31) ; v2(28.92,2.49) 28.92,5.9 30.7,7.68 30.7,8.91 v2(30.52,9.09) ; R507.1 v2(48.93,41.1) ; 124.43,70.97 125.07,70.34 125.07,69.43 124.57,68.93 124.57,65.61 124.58,65.59 R1606.1 124.47,64.63 R402.1 124.46,63.58 R1608.1 124.41,63.32 123.86,62.77 v2(123.67,62.77) ; 124.43,70.97 124.27,71.13 ; v2(127.38,58.84) 127.7,59.16 R2010.1 R2044.1 127.6,60.39 127.48,60.51 126.97,60.51 126.91,60.56 126.39,60.56 126.34,60.51 126.12,60.51 R2110.1 ; v2(115.35,53.44) 115.76,53.03 R2038.1 115.99,53.03 115.99,53.19 116.82,54.03 R2046.1 R2035.1 ; C2601.1 v2(124.51,41.23)
  vias: v1(60.54,12.73) v2(135.55,23.4) v2(136.15,23.06) v2(140.41,62.3) v2(141.09,62.27) v2(146.06,87.63) v2(146.72,87.62) v4(62.3,13.21) v4(63.14,13.2) v4(64.01,13.19) v4(118.47,17.28) v4(119.04,16.31) v4(127.56,80.12)
