# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PQ3802_1: length 4.2
  TOP w0.305: R4309.1 28.41,51.99 v1(28.41,52.83)
  TOP w0.635: R4309.1 29.17,51.94 v2(29.27,52.04)
  BOTTOM w0.635: v2(29.27,52.04) R4302.2 29.89,52.8 Q4302.B
PQ4405_2: length 13.9
  TOP w0.102: v2(143.38,23.82) 143.38,23.45 143.65,23.18 148.99,23.18 149.21,23.4 149.21,24.1 149.37,24.27 149.37,24.47 PR4463.2 150.75,24.72 v1(150.85,24.61) 151.37,24.61 151.93,25.18 153.3,25.18 153.62,24.85 PQ4405.2
  BOTTOM w0.102: v2(143.38,23.82) 143.38,23.6 143.78,23.19 PR4487.2
PQ4405_3: length 2.3
  TOP w0.089: v1(152.07,24.77) 152.07,24.46 v3(152.38,24.15) 152.54,24.15 152.59,24.2 PQ4405.3
  BOTTOM w0.089: PR4497.2 152.74,24.52 v3(152.38,24.15)
PQ4405_5: length 3.9
  TOP w0.102: PR4438.1 PC4468.2 153.56,22.49 PQ4405.5 153.62,23.09 153.44,23.28 152.21,23.28 v1(152.14,23.35)
PQ4405_6: length 7
  TOP w0.102: PQ4405.6 154.27,21.75 PC4468.1 154.47,21.53 154.01,21.06 151.66,21.06 151.31,21.41 151.31,21.9 151.04,22.18 PR4443.2 150.67,22.57 v1(150.1,23.14)
PQ4408_C: length 3
  BOTTOM w0.102: PR4439.1 142.1,24.93 PQ4408.C 141.97,23.89 141.97,23.06 v1(142,23.04) 142.39,23.04 142.44,23.09 PR4487.1
PQ4408_E: length 5.2
  TOP w0.102: v2(138.45,23.81) 139.22,24.58 PR4437.2 139.36,24.49 PR4436.1
  BOTTOM w0.102: v1(137.68,23.17) 137.8,23.17 v2(138.45,23.81) 139.21,23.81 139.95,24.55 PQ4408.E
PQ4417_D: length 13.6
  TOP w0.127: PR4486.1 v3(146.22,18.45) 146.21,18.43 PR4462.2
  BOTTOM w0.127: v3(146.22,18.45) 146.29,18.45 147.34,19.5 147.34,20.28 147.6,20.54 147.64,20.54 148.64,21.54 148.64,22.24 149.74,23.34 150.56,23.34 v1(151.74,24.52) 151.82,24.6 151.82,26.68 PQ4417.D
PQ4417_G: length 2.4
  BOTTOM w0.254: PR4494.2 149.33,25.27 v1(148.83,25.27) 149.13,25.58 PQ4417.G
PQ4418_2: length 5.3
  TOP w0.127: PR4486.2 147.7,19.19 148.51,19.99 149.08,19.99 149.38,19.69 PQ4418.2 149.38,19 148.63,18.26 PR4459.2 148.5,18.22 v1(148.5,17.09)
PQ4418_3: length 37.4
  TOP w0.089: v3(161.43,22.78) v1(161.43,22.01) ; v3(150.56,17.88) 150.44,18.01 150.44,19.17 150.33,19.28 PQ4418.3
  L5 w0.089: v3(161.43,22.78) 160.25,22.78 157.69,25.34 157.23,25.34 157.08,25.49 156.52,25.49 155.97,26.05 v3(153.54,26.05)
  L8 w0.076: v3(161.43,22.78) 162.55,23.89 163.49,23.89 165.58,21.8 165.58,21.06 165.16,20.64 165.16,19.88 164.91,19.64 164.39,19.64 164.21,19.46 163.03,19.46 163.01,19.44 162.71,19.44 162.38,19.11 162.03,19.11 162.01,19.13 161.28,19.13 160.95,19.46 157.4,19.46 156.41,18.47 155.99,18.47 155.61,18.08 150.76,18.08 v3(150.56,17.88)
  BOTTOM w0.089: PR4496.2 154.58,24.96 154.09,25.45 154.09,25.49 v3(153.54,26.05)
PQ4418_5: length 4.7
  TOP w0.127: PR4461.1 151.11,18.82 151.11,19.34 v1(150.92,19.53) 150.61,19.84 150.39,19.84 150.28,19.95 150.27,19.95 150,20.22 149.6,20.22 149.38,20.45 PQ4418.5 149.38,21.82 PC4467.2
PQ4418_6: length 2.9
  TOP w0.127: PR4460.2 v1(147.78,21.71) 148.05,21.98 PC4467.1 148.73,21.88 PQ4418.6
PQ4451_D: length 32
  TOP w0.254: v3(172.86,12.04) 172.86,11.46 172.56,11.16 PR4465.2 172.08,10.84 PR4469.1
  L5 w0.254: v3(172.3,18.16) 171.81,18.64 171.44,18.64 170.53,19.55 170.53,20.63 167.07,24.09 167.07,31.25 166.34,31.99 166.34,32.56 165.41,33.49 165.25,33.49 v3(164.9,33.84)
  L8 w0.254: v3(172.86,12.04) 173.68,12.87 173.68,16.26 174.33,16.91 174.33,17.33 173.5,18.16 v3(172.3,18.16)
  BOTTOM w0.254: v3(164.9,33.84) 164.81,33.84 164.25,34.4 v1(164.25,34.73) 164.25,35.61 PQ4451.D
PQ4451_G: length 39.3
  TOP w0.254: v3(172.29,11.58) 172.2,11.67 171.18,11.67 PR4464.1 171.25,10.96 171.25,10.81 PR4469.2 172.63,10.3 PR4466.2 ; v1(175.92,18.41) 175.85,18.49 v3(175.25,18.49)
  L3 w0.254: v3(172.29,11.58) 172.29,12.23 174.39,14.32 175.37,14.32 176.36,15.32 176.36,16.25 175.02,17.59 175.02,18.26 v3(175.25,18.49)
  L8 w0.254: v3(175.25,18.49) 175.74,18.49 176.05,18.8 176.05,20.05 174.44,21.67 174.44,25.64 172.32,27.75 171.36,27.75 167.61,31.5 166.83,31.5 166.21,32.12 166.21,32.15 166.17,32.35 166.09,32.53 165.98,32.7 165.65,33.03 165.65,35.12 v2(166.3,35.77)
  BOTTOM w0.254: PQ4451.G 166.6,36.07 v2(166.3,35.77)
PQ4452_G: length 5.8
  TOP w0.102: 137.25,2.61 137.03,2.39 PQ4452.2 135.72,2.39 135.35,2.76 135.35,3.44 135.45,3.55 PR4471.2 ; 137.25,2.61 137.72,2.61 PR4470.1 ; 137.25,2.61 v1(137.25,2.61)
PRD_CC1: length 4.6
  BOTTOM w0.089: U7201.K9 25.3,59.92 25.3,58.64 25.29,58.63
  BOTTOM w0.254: R7211.1 23.39,56.63 24.66,57.91 24.66,58.01 v1(24.88,58.22) 25.29,58.63
PRD_CC2: length 3.9
  TOP w0.254: R7212.1 23.39,57.54 v1(23.76,57.91) 24.09,58.24 v3(24.09,58.6)
  BOTTOM w0.089: U7201.K10 24.8,59.92 24.8,59.31 v3(24.09,58.6)
PRIM_PWRGD: length 25.4
  TOP w0.102: v1(31.23,26.66) 31.17,26.59 v2(30.24,26.59)
  L3 w0.102: v2(30.24,26.59) 30.24,26.64 29.79,27.09 29.62,27.09 28.03,28.68 28.03,32.47 29.96,34.4 29.96,37.22 27.94,39.23 25.96,39.23 25.06,40.14 25.06,43.49 v2(25.36,43.79)
  BOTTOM w0.102: PR5311.1 24.74,44.42 v2(25.36,43.79) ; U2401.30 30.17,26.67 v2(30.24,26.59)
PROCHOT: length 4.4
  TOP w0.089: v2(23.77,14.13) 23.64,14.26 Q2408.G 21.97,15.09 21.63,15.09 v1(21.53,15.18)
  BOTTOM w0.089: U2401.83 v2(23.77,14.13)
PROCHOT#_CPU: length 253.3
  TOP w0.089: PR4603.2 49.21,70.44 v2(49.07,70.58) ; Q2408.D 23.74,15.74 23.65,15.64 v2(23.65,15.61) ; v1(30.36,42.15) 30.36,41.72 v2(30.21,41.57)
  L3 w0.076: v2(49.07,70.58) 48.62,71.04 44.51,71.04 43.29,69.82 39.55,69.82 39.22,70.15 38.93,70.15 38.61,70.47 36.77,70.47 32.14,65.84 v2(31.45,65.84) ; v2(40.42,17.11) 39.24,17.11 38.04,15.91 37.32,15.91 37.15,15.74 34.4,15.74 33.91,16.23 31.85,16.23 31.37,15.75 28.91,15.75 28.59,16.07 24.24,16.07 23.82,15.64 23.65,15.64 v2(23.65,15.61)
  L5 w0.089: v2(22.62,41.51) 23.89,41.51 24.94,42.56 26.35,42.56 27.27,41.64 30.14,41.64 v2(30.21,41.57) ; v3(154.82,22.42) 153.57,22.42 153,23 151.65,23 149.69,21.04 145.35,21.04 145.35,21.04 144.47,21.04 144.47,21.04 132.3,21.04 123.89,12.63 123.36,12.63 120.86,10.14 117.39,10.14 116.5,11.02 108.12,11.02 107.85,11.3 91.72,11.3 88.49,14.52 56.56,14.52 56.3,14.26 46.17,14.26 44.6,15.84 41.69,15.84 v2(40.42,17.11)
  L6 w0.089: v2(30.21,41.57) 30.21,42.61 31.67,44.08 31.67,50.21 34.63,53.17 34.63,56.65 32.2,59.08 31.74,59.6 31.74,64.7 31.45,64.99 31.45,65.83 v2(31.45,65.84) ; v2(23.65,15.61) 23.65,18.39 24.09,18.83 24.09,21.53 23.17,22.45 23.17,23.93 22.56,24.54 22.56,25.54 22.74,25.72 22.74,26.94 22.33,27.34 22.33,29.78 21.76,30.34 21.76,39.08 22.62,39.94 v2(22.62,41.51)
  L8 w0.076: v2(68.48,69.38) 67.5,70.36 60.68,70.36 60.4,70.64 52.52,70.64 51.99,71.17 49.66,71.17 v2(49.07,70.58)
  BOTTOM w0.089: v3(154.82,22.42) 154.3,22.94 PQ4416.6 154.21,23.37 154.01,23.57 154.01,23.58 153.72,23.87 PR4496.1 153.6,24.32 PR4497.1 ; v2(49.07,70.58) 49.24,70.41 PR4607.1 ; R302.1 69.01,68.88 R301.2 68.92,68.94 v2(68.48,69.38)
PROCHOT#_CPU_R: length 13.7
  BOTTOM w0.089: CPU1.Y4 78.91,64.16 78.91,64.7 79.05,64.85 79.05,66.24 78.4,66.9 77.9,66.9 77.38,67.43 77.38,67.6 v1(76.72,68.26) 76.21,68.77 76.21,69.41 75.62,69.99 71.33,69.99 70.68,69.34 70.68,68.88 R302.2
PROJECT_ID0: length 7.5
  TOP w0.102: R2114.1 113.84,52.66 R2113.2 113.28,52.19 v1(112.54,52.19) 111.49,52.19 111.21,51.91 111.2,51.91 110.49,51.2 108.84,51.2 v2(108.46,50.81)
  BOTTOM w0.102: CPU1.CH23 108.56,50.92 v2(108.46,50.81)
PROJECT_ID1: length 18.2
  BOTTOM w0.102: CPU1.CK19 110.6,54.43 110.68,54.51 112.59,54.51 112.71,54.63 114.16,54.63 114.92,55.4 117.49,55.4 117.57,55.47 121.07,55.47 121.23,55.63 121.68,55.63 121.69,55.64 121.98,55.64 121.99,55.63 122.16,55.63 R2112.1 123.36,56.83 124.77,56.83 125.21,57.27 ; v1(125.21,57.28) 125.21,57.27 ; 125.21,57.27 125.78,57.84 125.78,58.43 R2111.2
PROJECT_ID2: length 2
  TOP w0.102: R2116.1 107.56,55.94 v2(107.58,55.92) 107.25,55.59 R2115.2
  BOTTOM w0.102: CPU1.CG17 107.91,55.58 107.58,55.91 v2(107.58,55.92)
PROJECT_ID3: length 16.1
  BOTTOM w0.102: CPU1.CN20 111.35,53.83 112.69,53.83 112.71,53.8 113.6,53.8 115,55.21 117.57,55.21 117.65,55.28 v1(121.84,55.28) 122.58,55.28 R2118.1 123.3,55.1 124.65,55.1 125.04,55.48 125.04,56 R2117.2
PS_ID: length 44.5
  TOP w0.305: v2(33.97,25.51) v1(33.97,24.95)
  L3 w0.635: v2(17.93,32.44) 18.12,32.44 18.62,32.94 18.62,34.31 18.51,34.42 18.51,40.13 17.57,41.07 17.57,45.71 18.81,46.96 18.81,48.1 18.33,48.59 v2(18.33,48.8)
  L5 w0.508: v2(33.97,25.51) 33.97,26.27 33.58,26.66 33.58,29.05 31.99,30.64 24.95,30.64 22.76,32.83 18.96,32.83 18.56,32.44 v2(17.93,32.44)
  BOTTOM w0.203: v2(33.97,25.51) 33.53,25.07 U2401.36
  BOTTOM w0.635: R4304.2 R4305.2 17.28,49.68 D4302.3 18.33,49.63 v2(18.33,48.8)
PS_ID_R: length 43.7
  TOP w0.102: AFTP4304.1 32.44,72.99 32.44,73.66 32.21,73.89 v2(32.21,74.19) ; v2(23.56,59.61) 23.44,59.49 EC4303.1 22.71,59.49 21.89,60.31 v1(21.89,60.38)
  L6 w0.102: v2(25.13,49.99) 24.5,50.63 24.5,58.77 23.66,59.61 v2(23.56,59.61)
  L8 w0.102: v2(23.56,59.61) 24.64,60.69 24.64,66.66 23.54,67.76 23.54,69.13 24.51,70.1 24.51,73.16 25.29,73.94 25.74,73.94 26.11,73.57 31.58,73.57 v2(32.21,74.19)
  BOTTOM w0.102: R4317.1 23.99,50.09 24.09,49.99 v2(25.13,49.99) ; DCIN1.4 33.05,76.1 32.21,75.25 v2(32.21,74.19)
PS_ID_R1: length 15.3
  TOP w0.102: v2(27.93,50.63) 27.54,50.63 R4306.2 27.8,49.76 27.8,49.44 26.89,48.52 25.31,48.52 25.03,48.24 24.28,48.24 v1(24.16,48.12) 24.16,47.87 23.48,47.19 22.65,47.19 21.69,48.16 21.69,48.17 21.58,48.27 17.89,48.27 v2(17.62,48.54)
  BOTTOM w0.102: v2(17.62,48.54) 17.61,48.54 17.59,48.52 R4305.1 ; v2(27.93,50.63) 27.32,50.63 Q4301.S
PS_ID_R2: length 1.7
  TOP w0.635: v2(27.22,52.71) 27.49,52.43 R4309.2 27.49,51.45 R4306.1
  vias: v1(26.57,52.89)
PSID_DISABLE#_R_C: length 3.9
  BOTTOM w0.635: v1(31.66,50.33) 31.66,51.22 Q4302.C 30.44,51.35 R4303.2 29.94,51.34 Q4301.G
PTP_DIS#: length 128.8
  TOP w0.102: v2(118.02,16.41) 118.02,16.4 118.02,15.79 118.07,15.74 118.17,15.59 118.18,15.56 118.82,14.93 118.85,14.93 119.1,14.67 119.1,14.32 119.1,14.32 119.1,14.14 119.13,14.11 119.13,13.97 118.11,12.95 118.11,10.28 119.95,8.44 119.96,8.44 120.15,8.26 120.94,8.26 121.67,7.52 123.97,7.52 124.88,8.43 124.88,8.44 AFTP6537.1 125.85,8.46 v2(127.21,8.46)
  L3 w0.102: v2(43.07,17.11) 42.65,17.53 42.3,17.53 42.29,17.54 38.58,17.54 38.41,17.38 38.23,17.38 36.99,16.13 35.49,16.13 34.9,16.72 30.09,16.72 29.83,16.46 23.88,16.46 23.1,15.67 23.1,14.07 v2(20.02,10.99)
  BOTTOM w0.102: v2(43.07,17.11) 44.73,18.77 53.35,18.77 55.12,17 111.59,17 114.72,13.87 117.4,13.87 118.28,14.75 118.28,14.77 118.28,16.13 118.28,16.16 v2(118.02,16.41) ; TPAD1.3 128.1,7.47 127.21,8.35 v2(127.21,8.46) ; v2(20.02,10.99) 20.64,10.99 20.97,11.32 U2401.90
PU44C1_ADJ: length 4.7
  TOP w0.203: PR44C2.2 157.96,28.54 v1(157.96,29.49) 158.7,30.23 v3(158.77,30.23) 158.78,30.22 159.41,30.22 PR44C3.1
  BOTTOM w0.203: v3(158.77,30.23) 158.77,30.23 158.24,29.7 PU44C1.4
PU44C1_EN: length 2.8
  TOP w0.203: PR44C7.2 158.08,32.95 PR44C1.1 158.5,32.96 v1(158.94,33.41) 159.56,32.79 PR44C4.1
PU44C1_EN_R: length 3.9
  TOP w0.203: v2(158.78,32.2) 159.06,32.2 159.46,31.8 PR44C4.2 160.13,31.8 PC44C1.1 160.61,31.63 v1(160.61,31.06)
  BOTTOM w0.203: v2(158.78,32.2) 158.24,31.66 PU44C1.3
PURE_HW_SHUTDOWN#: length 162.2
  TOP w0.102: D4001.K 13.17,22.08 14.15,23.06 14.15,25.22 15.37,26.43 v1(15.37,29.08) 15.37,29.4 v2(15.81,29.84) ; v2(123.89,19.21) 123.52,19.57 123.52,22.51 123.36,22.67 123.36,26.96 125.07,28.67 125.07,29.78 126.53,31.24 126.53,39.53 128.15,41.16 128.15,43.51 127.36,44.3 127.24,44.3 126.68,44.86 Q2602.D 127.01,45.31 127.11,45.2 127.22,45.2 127.26,45.17 127.61,45.17 127.65,45.2 127.75,45.2 C2610.1
  L5 w0.102: v2(15.81,29.84) 16.39,30.42 17.22,30.42 17.23,30.42 18.6,30.42 19.03,30.86 19.06,30.86 19.31,30.86 19.51,31.06 19.75,31.06 19.98,31.29 23.57,31.29 24.72,30.13 28.54,30.13 29.57,29.1 29.57,28.8 30,28.37 30.03,28.37 33.66,24.75 33.8,24.75 37.45,21.09 40.15,21.09 42.02,19.22 42.02,18.82 42.6,18.24 43.06,18.24 43.8,18.24 44.86,17.18 45.15,17.18 45.32,17.18 46.87,15.63 55.77,15.63 56.01,15.86 89.05,15.86 90.28,14.63 91.43,14.63 93.43,12.64 108.4,12.64 108.68,12.36 117.7,12.36 118.69,13.35 121.05,13.35 121.94,14.24 122.07,14.33 122.08,14.39 123.05,15.36 123.05,18.38 v2(123.89,19.21)
PWR_1D0V_PG: length 3
  TOP w0.203: PR5208.2 v1(124.22,85.95) 124.16,85.88 123.66,85.88 v2(123.48,86.06)
  BOTTOM w0.203: v2(123.48,86.06) 123.48,85.66 123.95,85.2 PU5201.1
PWR_1D05V_BT: length 2.9
  TOP w0.305: PC5204.2 124.24,83.42 v1(123.77,83.42) 123.19,83.42 v2(122.8,83.02)
  BOTTOM w0.254: PU5201.20 v2(122.8,83.02)
PWR_1D05V_EN: length 2.5
  BOTTOM w0.203: PU5201.2 124.71,85.64 124.24,86.1 PC5214.1 124.15,86.8 PR5210.2
PWR_1D05V_PFM: length 1.6
  BOTTOM w0.203: PU5201.3 125.21,85.71 125.03,85.89 PR5203.1
PWR_1D05V_PH: length 2.1
  TOP w0.508: v2(122.74,81.61) 123.26,82.13 v1(123.56,82.13) PC5204.1
PWR_1D05V_SS: length 2.5
  BOTTOM w0.203: PC5213.1 122.93,86.47 122.93,85.53 123.53,84.92 PU5201.22
PWR_1D05V_TON: length 1
  BOTTOM w0.203: PU5201.6 126.71,86.13 PR5201.2
PWR_1D05V_VFB: length 3.6
  BOTTOM w0.305: PU5201.5 126.21,85.76 126.18,85.78 126.18,86.52 126.21,86.55 126.21,86.61 PC5212.2
  BOTTOM w0.381: PC5212.2 126.53,87.34 126.64,87.44 126.64,87.78 PR5204.1 126.65,88.54 PR5202.2
PWR_1D05V_VFB_A: length 14.2
  TOP w0.254: 117.31,87.15 PG5210.2
  TOP w0.381: 117.31,87.15 117.66,86.81 119.84,86.81 v1(120.3,87.27) 121.95,88.92 123.53,88.92 123.57,88.97 124.82,88.97 125.2,88.58 125.2,88.56 126.99,88.56 v2(127.66,87.9)
  BOTTOM w0.381: PR5202.1 127.55,88.04 127.66,87.93 v2(127.66,87.9) 127.66,87.2 127.44,86.99 127.44,86.94 PC5212.1
PWR_1D8V:
  vias: v1(27.89,46.05)
PWR_1D8V_EN: length 4.3
  TOP w0.203: PC5307.1 25.29,47.84 25.57,48.11 26.26,48.11 v1(26.54,47.83) 26.93,47.45 PR5310.2 27.46,46.8 v2(27.5,46.77)
  BOTTOM w0.203: v2(27.5,46.77) 27.39,46.77 27.11,47.05 PU5301.7
PWR_1D8V_FB: length 5.7
  BOTTOM w0.305: PU5301.1 24.8,46.43 25.56,45.67
  BOTTOM w0.381: 25.56,45.67 25.56,45.3 26.1,44.76 PR5304.1 26.73,43.91 v1(26.76,43.89) 27.08,43.89 27.46,44.26 27.52,44.26 27.57,44.32 PR5305.2 28.31,44.32 PC5305.2
PWR_1D8V_PG: length 3.1
  BOTTOM w0.203: PU5301.2 24.45,47.05 23.96,46.56 PR5306.2 24.01,45.3 PR5311.2
PWR_1D8V_PH:
  vias: v1(28.1,50.04)
PWR_1D8V_PHASE:
  vias: v1(137.64,78.7)
PWR_1D8V_PVDD:
  vias: v1(130.09,78.88)
PWR_1D8V_VGA: length 7.5
  L8 w1.016: v2(140.25,80.57) 137.08,80.57 135.52,79.01 v2(135.52,76.85)
  vias: v1(134.98,77.47)
PWR_1D8V_VGA_FB:
  vias: v1(131.49,77.3)
PWR_1D8V_VIN: length 1.1
  BOTTOM w0.305: PC5301.1 23.82,47.55 PU5301.3
  vias: v1(22.39,47.66)
PWR_1D35V_BOOT:
  vias: v1(181.25,36.95)
PWR_1D35V_BOOT_R:
  vias: v1(185.23,38.05)
PWR_1D35V_BYP: length 3.6
  TOP w0.508: v2(176.59,36.96) 176.68,37.05 PC8618.1 177.23,37.7 PR8634.2 177.22,37.95 v1(177.22,38.71)
  BOTTOM w0.203: PU8602.15 176.88,36.67 v2(176.59,36.96)
PWR_1D35V_EN: length 4.5
  TOP w0.203: v2(176.62,34.87) 176.62,34.09 v1(176.97,33.74) 177.44,34.21 PC8616.1
  BOTTOM w0.203: PR8631.2 176,35.2 176.16,35.2 176.49,34.87 v2(176.62,34.87) PU8602.11
PWR_1D35V_IMAX: length 2.9
  TOP w0.203: PR8632.1 177.3,35.04 v1(177.25,34.98) 177.2,34.98 v2(176.62,35.57)
  BOTTOM w0.203: PU8602.13 176.83,35.77 v2(176.62,35.57)
PWR_1D35V_LDO_P5:
  vias: v1(175.73,37.12)
PWR_1D35V_PGOOD:
  vias: v1(176.7,33.61)
PWR_1D35V_PHASE: length 5.6
  TOP w0.635: v1(179.91,34.39) 180.11,34.39 v4(180.51,33.99)
  L3 w0.635: v4(180.35,37.81) 180.51,37.66 v4(180.51,33.99)
  BOTTOM w0.203: PU8602.6 180.12,34.48 180.51,34.09 v4(180.51,33.99)
PWR_1D35V_VFB: length 4.5
  TOP w0.381: v1(175.77,35.08) 175.77,35.9 PC8602.2 175.91,36.18 176.17,36.18 176.21,36.22 v2(176.52,36.22) 176.54,36.25 PR8626.1
  BOTTOM w0.203: PU8602.14 v2(176.52,36.22)
  BOTTOM w0.381: PR8627.2 176.51,36.23 v2(176.52,36.22)
PWR_1D35V_VFB1: length 10.3
  TOP w0.381: PC8602.1 v2(174.18,35.97)
  L3 w0.381: v2(179.47,40.91) 178.86,40.91 174.18,36.23 v2(174.18,35.97)
  BOTTOM w0.203: PG8613.2 v2(179.47,40.91)
  BOTTOM w0.254: v2(174.18,35.97) 173.6,35.97 v1(173.56,36.01)
  BOTTOM w0.381: v2(174.18,35.97) 174.45,36.23 PR8627.1
PWR_1V:
  vias: v1(133.96,86.16)
PWR_1V_FB: length 1
  BOTTOM w0.381: v1(141.65,87.56) 141.46,87.75 PR8620.1
PWR_1V_PHASE:
  vias: v1(137.59,83.75)
PWR_1V_PVDD: length 2.4
  BOTTOM w0.305: v2(141.56,86.18) 141.52,86.14 141.49,86.14 140.9,85.55 PU8603.3
  BOTTOM w0.508: v2(141.56,86.18) 142.15,86.18 v1(142.18,86.15)
PWR_3D3V_BOOT: length 3.3
  TOP w0.254: PR4501.2 90.72,3.79 89.8,4.7 v1(89.46,4.7) v2(88.58,4.7)
  BOTTOM w0.254: PU4501.1 88.52,4.7 v2(88.58,4.7)
PWR_3D3V_BOOT_A: length 2
  TOP w0.305: PR4501.1 92.3,3.95 PC4506.2 93.07,4.8 v1(93.09,4.82)
PWR_3D3V_EN: length 3.3
  BOTTOM w0.203: PU4501.12 86.72,8.24 85.99,8.96 ; 85.99,8.96 v1(85.99,8.96) ; 85.99,8.96 85.86,9.1 R4502.1 85.1,9.87 PR4514.1
PWR_3D3V_EN2: length 6.2
  TOP w0.203: v2(84.54,7.9) 84.45,7.99 PC4508.2
  BOTTOM w0.203: v1(84.75,8.86) 84.54,8.66 v2(84.54,7.9) 84.48,7.97 PR4509.2 ; v1(84.75,8.86) 85.2,8.41 86.07,8.41 86.27,8.21 PU4501.11 ; v1(84.75,8.86) 84.27,9.34 PR4508.1
PWR_3D3V_FB: length 3.7
  BOTTOM w0.203: PU4501.13 87.17,8.34 86.91,8.61 86.91,8.65 86.75,8.8 v1(86.75,9.91) 86.75,11.1 PC4526.1
PWR_3D3V_FB2:
  vias: v1(85.77,12.04)
PWR_3D3V_LDO: length 6
  BOTTOM w0.203: PG4532.2 88.19,8.89 v1(88.2,8.88) 89.05,8.88 PC4507.1 89.31,7.29 ; PU4501.16 89.25,7.35 89.31,7.29 ; 89.31,7.29 89.31,7.06 89.15,6.9 PU4501.17
PWR_3D3V_PH: length 8.9
  TOP w0.305: PC4506.1 91.39,5.09 v2(91.03,5.45) 90.48,5.45 v1(90.4,5.53)
  L8 w0.508: v2(91.03,5.45) 90.92,5.55 85.08,5.55 v2(84.86,5.33)
  BOTTOM w0.254: v2(84.86,5.33) 85.08,5.55 PU4501.6
PWR_3D3V_VOUT: length 8.3
  BOTTOM w0.203: PU4501.14 87.62,8.56 87.47,8.71 PR4506.1 87.95,11.71 87.95,11.71 87.95,11.72 87.95,12.11 88.44,12.6 89.04,12.6 89.23,12.79 v1(90.23,12.79) 90.35,12.68 PG4530.1
PWR_5V_BOOT: length 4.8
  BOTTOM w0.254: PU4551.1 76.81,7.99 76.41,8.38
  BOTTOM w0.305: PR4554.1 75.45,9.34 v1(75.63,9.17) 76.41,8.38
PWR_5V_BOOT_A: length 2.5
  BOTTOM w0.305: PR4554.2 72.02,9.42 72.02,10.42 v1(71.94,10.5) 71.55,10.5 PC4553.1
PWR_5V_EN2: length 5.6
  TOP w0.203: v2(79.72,3.38) 79.62,3.48 v1(79.62,3.98) 79.54,3.98 PR4558.1 78.18,4.64 PC4564.2
  BOTTOM w0.203: PU4551.11 78.61,4.26 78.97,3.9 79.21,3.9 79.73,3.38 ; 79.73,3.38 v2(79.72,3.38) ; 79.73,3.38 79.73,3.72 80.08,4.07 PR4557.2
PWR_5V_FB: length 1.6
  BOTTOM w0.254: PU4551.13 77.71,3.98 78.27,3.42 v2(78.27,3.29)
  vias: v1(77.63,3.81)
PWR_5V_FB_A: length 0.8
  TOP w0.305: PC4563.2 78.13,1.95 PR4555.2
PWR_5V_LDO: length 5.3
  TOP w0.305: PG4565.1 76.28,3.3 76.45,3.14 76.45,3.1 v2(76.8,3.1) 76.8,4.08 PC4551.1 76.19,4.69 v1(75.47,4.69)
  BOTTOM w0.254: PU4551.15 76.81,3.12 v2(76.8,3.1)
PWR_5V_PG: length 4.9
  TOP w0.203: R4503.1 80.61,5.77 80.35,5.51 PR4552.2 80.05,4.77 79.84,4.97 v2(79.84,5.26)
  BOTTOM w0.203: PU4551.10 79.68,5.1 v2(79.84,5.26) ; v2(79.84,5.26) 79.84,5.35 79.64,5.55 PU4551.9 ; v2(79.84,5.26) 80.33,5.26 v1(80.41,5.35)
PWR_5V_PH: length 5.5
  L8 w0.508: v2(75.41,7.12) 75.46,7.07 79.54,7.07 v2(79.8,7.33)
  BOTTOM w0.254: PU4551.6 79.37,6.9 v2(79.8,7.33)
  vias: v1(75.28,7.79)
PWR_5V_VCC: length 1.8
  TOP w0.305: v2(75.7,4.04) 75.65,3.99 PC4562.1
  vias: v1(75.45,4.54)
PWR_5V_VOUT: length 7.4
  TOP w0.305: v2(77.62,3.25) 77.62,2.97 76.66,2.01 PR4555.1 76.65,1.94 74.98,1.94 v1(74.41,2.51) 74.1,2.51 73.58,1.99 PG4562.1
  BOTTOM w0.254: PU4551.14 77.26,3.5 77.52,3.25 v2(77.62,3.25)
PWR_AC_IN#: length 2.4
  TOP w0.203: PR4491.2 143.1,5.84 v1(142.93,5.67) 142.49,5.23 PQ4415.3
PWR_AD_A: length 298.8
  TOP w0.203: v2(168.55,10.34) 169.04,10.83 170.08,10.83 170.1,10.85 170.52,10.85 170.82,10.56 170.82,9.95 171.03,9.74 172.11,9.74 172.65,9.2 PR4466.1 173.23,9.2 PC4469.1 173.65,8.8 PR4468.1
  TOP w0.305: PR44C7.1 157.32,31.27 PC44C3.1 157.19,31.04 v3(156.59,30.44)
  L3 w0.203: v2(168.55,10.34) 172.19,10.34 176.9,15.04 176.9,16.4 176.5,16.8 176.5,17.2 176.51,17.21 176.51,18.08 v3(175.57,19.02)
  L5 w0.203: v2(19.06,48.88) 20.89,50.72 20.89,57.82 20.43,58.28 19.8,58.28 19.52,58.56 19.52,60.25 18.86,60.91 18.86,63.66 21.04,65.84 21.58,65.84 ; 21.58,65.84 22.16,65.84 23.69,67.37 26.18,67.37 27.39,68.58 27.39,69.83 v2(27.96,70.39) ; 21.58,65.84 v2(21.58,65.83) ; v2(18.27,41.38) 18.27,40.89 18.97,40.19 21.02,40.19 21.37,40.54 22.06,40.54 22.59,40.01 24.7,40.01 25.5,39.21 27.94,39.21 28.11,39.04 28.51,39.04 28.68,39.21 30.33,39.21 31.07,38.47 v2(31.76,38.47)
  L6 w0.203: v2(31.76,38.47) 31.76,38.12 32.97,36.91 32.97,36.91 32.99,36.89 32.99,34.12 33.2,33.9 33.2,26.32 33.13,26.25 33.13,19.05 36.15,16.03 52.31,16.03 56.19,12.14 69.86,12.14 70.08,12.35 82.86,12.35 83.19,12.02 89.01,12.02 89.01,12.02 89.62,12.02 89.63,12.02 90.43,12.02 90.55,12.15 96.44,12.15 97.42,11.17 99.74,8.85 99.87,8.72 121.4,8.72 122.65,7.47 129.65,7.47 130.63,8.44 137.2,8.44 137.83,7.8 146.22,7.8 147.48,9.07 149.58,9.07 151.12,10.61 152.08,10.61 152.93,11.47 v2(152.93,16.29) ; v3(156.59,30.44) 156.94,30.79 160.37,30.79 161.42,31.84 163.41,31.84 164.37,30.88 165.72,30.88 v3(165.93,31.09)
  L8 w0.203: v2(168.55,10.34) 167.42,11.47 167.15,11.47 166.42,12.2 166.37,12.41 166.37,13.8 163.35,16.83 162.68,16.83 162.53,16.67 161.33,16.67 160.47,17.53 158.09,17.53 155.51,14.94 155.51,14.88 154.61,13.99 154.02,13.99 152.93,15.07 v2(152.93,16.29) ; v3(175.57,19.02) 175.54,19.02 173.83,20.73 173.83,23.42 170.06,27.19 170.06,28.53 167.5,31.09 v3(165.93,31.09) ; v2(19.06,48.88) 19.06,47.05 17.69,45.68 17.69,41.95 v2(18.27,41.38)
  BOTTOM w0.203: v3(156.59,30.44) 156.59,30.82 156.33,31.07 PU44C1.1 155.55,32.02 PU44B1.5 154.02,32.02 153.36,32.68 151.38,32.68 150.8,32.09 150.8,29.16 v1(151.35,28.61) 151.25,28.51 151.25,28.15 151.6,27.81 151.62,27.81 152.12,27.3 152.12,26.53 PU44A1.5 ; PQ4451.S 166.48,34.88 165.67,34.06 165.67,33.02 166.18,32.51 166.18,31.61 165.93,31.36 v3(165.93,31.09) ; v2(152.93,16.29) 152.98,16.29 152.98,16.24 PU4401.16
  vias: v2(26.63,74.7) v2(27.24,72.24) v2(27.35,74.69) v2(27.29,74.05) v2(28.2,71.25)
PWR_AD_A_SW: length 293.7
  TOP w0.203: PU4415.4 31.03,70.82 31.86,71.65 31.86,71.72 31.91,71.77 31.91,73.26 v2(32.01,73.36) ; PR4465.1 173.42,10.54 173.64,10.32 PC4469.2 173.67,9.67 PR4468.2 174.85,9.25 174.85,9.24 174.92,9.18 174.92,8.48 174.78,8.35 174.24,8.35 174.09,8.19 174.09,7.44 173.75,7.1 172.99,7.1 172.99,7.1 172.43,7.1 171.59,7.93 169.89,7.93 169.41,7.45 v2(169.41,7.35) ; v3(131.58,2.98) 130.99,2.39 130.99,1.41 130.96,1.39 ; 130.96,1.39 132.2,1.39 PR4467.1 ; 130.96,1.39 111.1,1.39 109.6,2.89 v2(109.6,3.13) ; v2(11.82,4.98) 13.32,4.98 v1(14,4.3)
  L3 w0.203: v2(11.82,4.98) 13.13,6.3 16.47,6.3 16.73,6.56 18.1,6.56 19.28,7.74 64.58,7.74 65.47,8.63 70.01,8.63 70.87,9.49 81.58,9.49 81.8,9.26 82.2,9.26 82.65,9.71 102.49,9.71 109.07,3.13 v2(109.6,3.13)
  L5 w0.203: v2(12.13,68.54) 12.5,68.91 12.5,71.48 14.54,73.51 19.87,73.51 21.99,75.64 29.21,75.64 31.49,73.36 v2(32.01,73.36)
  L8 w0.203: v3(131.58,2.98) 132.17,3.57 137.33,3.57 138.04,4.27 148.85,4.27 148.87,4.25 148.93,4.25 149.34,3.84 149.35,3.84 149.36,3.83 150.02,3.83 150.45,3.4 154.83,3.4 155.95,4.52 156.92,4.52 157.27,4.87 158.43,4.87 158.71,4.6 160.45,4.6 160.68,4.83 165.15,4.83 166.09,3.89 167.22,3.89 169.41,6.08 v2(169.41,7.35) ; v2(11.82,4.98) 11.82,9.35 11.88,9.4 11.88,11.88 10.88,12.87 10.88,17.29 8.29,19.89 8.29,20.33 9.7,21.74 9.7,24.98 10.62,25.9 10.62,26.63 12.12,28.13 12.88,28.13 14.54,29.79 14.54,31.64 14.7,31.79 14.7,33.78 14.4,34.08 14.4,36.7 9.58,41.52 6.98,41.52 5.11,43.38 5.11,45.62 7.08,47.59 9.75,47.59 10.25,48.09 10.25,48.76 v2(9.63,49.39)
  BOTTOM w0.203: v2(12.13,68.54) 12.13,67.87 13.12,66.88 13.12,65.36 11.14,63.38 11.14,54.4 13.05,52.49 13.05,51.19 11.24,49.39 v2(9.63,49.39)
PWR_AD_A_SW_R1: length 1.2
  TOP w0.203: PR4467.2 133.42,1.74 PQ4452.6
PWR_AD_B: length 9.9
  TOP w0.305: C8902.1 74.35,10.41 v2(73.56,11.2) ; C8903.1 41.73,10.58 v2(40.73,9.58) ; v2(63.92,3.76) 63.64,4.04 C8901.1
  BOTTOM w0.203: EC4408.1 v2(73.56,11.2) ; EC4407.1 v2(63.92,3.76) ; EC4401.1 33.67,71.39 v4(33.39,71.67) ; v2(26.51,38.72) 26.38,38.59 25.81,38.59 EC4402.1
  BOTTOM w0.305: EC4405.1 40.41,9.91 v2(40.73,9.58)
  vias: v1(133.69,9.57) v4(31.97,70.72) v4(32.6,71.98) v4(32.73,71.15) v4(32.88,70.24) v4(32.92,69.37) v4(132.51,4.32) v4(133.36,4.32) v4(134.22,4.32) v4(135.1,4.32) v4(139.99,13.03) v4(140.02,12.2) v4(140.02,11.35) v4(140.83,13.04) v4(140.86,12.2) v4(140.87,11.35)
PWR_CHG_ACIN: length 12.7
  TOP w0.203: PR4404.2 159.3,21.93 PR44A5.2 159.69,20.18 157.84,18.33 157.82,18.33 v1(156.32,16.83) 156.32,16.26 155.63,15.56 155.63,15.33 PC4420.1 155.36,15.14 153.97,15.14 153.78,14.95 v2(153.74,14.95) 153.46,15.23 PR4406.1
  BOTTOM w0.203: v2(153.74,14.95) 153.68,14.88 PU4401.19
PWR_CHG_ACIN_A: length 13.2
  TOP w0.203: PR44A5.1 159.69,22.82 159.13,23.38 159.13,24.19 160.88,25.94 v1(161.87,25.94) 162.06,25.94 163.16,27.04 163.16,28.01 162.58,28.58 161.7,28.58 161.7,28.57 PQ44A1.6 160.58,28.57 160.2,28.2 160.2,27.63 159.85,27.27 PQ44A1.3
PWR_CHG_ACOK: length 78.5
  TOP w0.203: v2(156.61,11.41) 155.75,12.27 PR4429.2 ; v2(162.67,27.73) 162.67,27.2 161.87,26.4 160.69,26.4 159.14,24.85 157.64,24.85 156.99,25.5 156.15,25.5 156.15,25.5 155.98,25.5 v1(155.91,25.58) 155.9,25.58 151.76,25.58 151.64,25.46 149.74,25.46 PR4463.1 ; PR4459.1 149.95,18.26 149.96,18.26 v3(150.04,18.26) ; PR4429.2 155.62,12.64 PR4426.1 ; PR4429.2 155.57,12.22 153.72,12.22 v2(153.5,12.44) 153.5,11.53 153.47,11.51 153.47,11.42 152.31,10.26 151.79,10.26 150.01,8.48 150.01,7.57 147.97,5.52 145.3,5.52 144.39,4.61 PG4408.2
  L3 w0.203: v2(156.61,11.41) 156.68,11.41 156.73,11.36 158.28,11.36 160.99,14.07 163.06,14.07 163.25,14.26 163.65,14.26 163.88,14.03 171.74,14.03 171.92,13.85 171.92,13.85 v2(171.92,13.85) ; v3(150.04,18.26) 150.12,18.34 150.9,18.34 151.13,18.11 151.13,16.95 152.54,15.53 152.54,13.39 v2(153.5,12.44)
  L8 w0.203: v2(162.67,27.73) 163.12,27.28 163.55,27.28 165.16,25.68 165.85,25.68 165.9,25.63 165.92,25.63 166.13,25.42 166.13,24.7 168.02,22.81 168.02,22.77 169.62,21.17 169.96,21.17 170.24,20.89 170.24,18.73 171.84,17.14 171.84,13.93 v2(171.92,13.85)
  BOTTOM w0.203: v2(153.5,12.44) 153.27,12.44 153,12.71 PU4401.24
PWR_CHG_AIN: length 3.1
  TOP w0.508: PD4408.3 156.84,24.24 v1(157.58,24.24) 157.79,24.24 158.52,23.51 158.52,23.12 158.73,22.91 PR4404.1
PWR_CHG_AMON: length 12.3
  TOP w0.203: PR4492.1 142.52,6.74 v1(145.49,6.74) 147.46,6.74 148.81,8.09 148.81,8.83 150.28,10.3 150.28,10.69 v2(150.3,10.71)
  BOTTOM w0.203: v2(150.3,10.71) 150.74,11.15 150.74,11.58 150.85,11.68 PU4401.29
PWR_CHG_ASGATE: length 2.5
  TOP w0.203: v2(151.73,17.49) 151.73,17.4 TP4401.1
  BOTTOM w0.203: PU4401.13 151.25,16.93 151.74,17.42 151.74,17.49 151.73,17.49 v2(151.73,17.49)
PWR_CHG_BAT_IN#: length 13.9
  BOTTOM w0.203: PR4498.2 148.8,2.49 149.82,2.49 150.5,3.17 150.5,5.6 150.31,5.78 150.31,7.81 152.38,9.87 154.43,9.87 PR4409.1
PWR_CHG_BATGONE: length 4.1
  BOTTOM w0.203: PU4401.25 152.72,12.32 153.09,11.96 153.85,11.96 153.99,12.09 v1(154.36,12.09) 154.57,11.89 155.01,11.89 PC4430.1 155.15,11.45 PR4409.2
PWR_CHG_BGATE: length 32.4
  L6 w0.508: v2(123.38,10.29) 125.22,10.29 125.67,10.74 126.2,10.74 126.67,10.26 129.83,10.26 129.86,10.29 141.93,10.29 143.1,11.46 146.29,11.46 146.34,11.51 146.42,11.51 147.01,12.11 148.51,12.11 149.01,11.6 v2(149.01,11.3)
  BOTTOM w0.203: v2(149.01,11.3) 149.65,11.93 PU4401.32
  BOTTOM w0.305: PU4412.4 121.47,11.72 v1(121.73,11.99)
  BOTTOM w0.381: PU4412.4 121.97,11.03 122.46,10.53 122.46,10.23 PC4429.1 123.27,10.29 v2(123.38,10.29)
PWR_CHG_BTST1: length 3.6
  BOTTOM w0.203: PR4402.1 150.63,19.19 v1(150.63,18.42) 150.66,18.42 151.05,18.04 151.05,17.2 150.92,17.06 150.92,16.31 PU4401.12
PWR_CHG_BTST1_A:
  vias: v1(148.09,19.6)
PWR_CHG_BTST2: length 3.6
  BOTTOM w0.203: 147.04,13.43 147.05,13.42 147.71,13.42 147.79,13.5 147.99,13.5 148.46,13.97 148.51,13.97 148.63,14.08 PU4401.4 ; 147.04,13.43 v1(147.04,12.42) ; 147.04,13.43 PR4408.1
PWR_CHG_BTST2_A: length 2.3
  BOTTOM w0.635: PC4423.1 145.55,14.77 PR4408.2 145.55,12.51 v1(145.54,12.51)
PWR_CHG_CLK: length 2.4
  BOTTOM w0.203: PU4401.22 153.95,13.68 154.16,13.48 v1(154.16,13.45) 155.11,13.45 PR4489.2
PWR_CHG_COMP: length 5.7
  BOTTOM w0.203: PC4433.1 148.58,9.34 v1(148.77,9.15) 149.57,9.15 PR4411.1 151.25,10.99 PU4401.28
PWR_CHG_COMP_R: length 6.3
  BOTTOM w0.203: PR4411.2 148.73,7.44 PC4431.1 148.52,6.65 v1(148.77,6.39)
PWR_CHG_CSIN: length 6.1
  TOP w0.203: v1(152.41,16.88) 152.39,16.9 v2(152.39,17.44) 152.69,17.74 PC4417.1
  BOTTOM w0.203: PR4482.2 151.71,19.36 PC4415.2 152.39,17.93 v2(152.39,17.44) 151.65,16.7 PU4401.14
PWR_CHG_CSIN_R: length 228.1
  TOP w0.203: v1(22.86,47.54) 22.75,47.66 v2(22.75,48.21) ; PG4402.2 31.93,67.85 32.11,68.03 32.56,68.03 v2(33,67.59)
  L5 w0.203: v2(33,67.59) 33,67.54 32.43,66.97 28.67,66.97 28.29,66.59 27.4,66.59 26.79,65.97 25.35,65.97 23.62,64.24 23.42,64.24 21.73,62.55 21.73,62.15 21.62,62.04 21.62,58.94 21.81,58.75 21.81,49.33 22.75,48.39 v2(22.75,48.21)
  L6 w0.203: v2(22.75,48.21) 22.75,47.92 24.6,46.07 24.6,34.25 24.49,34.14 24.49,31.36 25.81,30.04 25.81,28.89 26.2,28.51 26.2,26.31 25.33,25.44 25.33,25.04 24.29,24.01 24.29,22.9 25.56,21.63 25.56,15.48 25.55,15.47 25.55,14.92 25.46,14.84 25.46,14.44 25.54,14.36 25.54,13.8 25.56,13.78 25.56,13.2 25.62,13.14 25.62,9.75 25.25,9.38 25.25,7.04 25.68,6.61 29.13,6.61 33.26,10.75 39.5,10.75 39.55,10.71 59.71,10.71 60.13,11.13 64.58,11.13 65.13,10.57 79.73,10.57 80.03,10.88 88.07,10.88 88.21,10.74 89.46,10.74 90.02,11.31 96.27,11.31 96.82,10.76 96.91,10.67 99.24,8.35 99.57,8.01 121.25,8.01 122.38,6.88 148.22,6.88 151.48,10.15 156.69,10.15 157.26,10.72 157.26,12.32 156.98,12.6 156.95,12.6 155.85,13.71 155.85,16.78 153.97,18.65 153.97,19.34 v2(154.81,20.18)
  BOTTOM w0.203: PR4482.1 151.88,20.39 154.41,20.39 154.63,20.18 v2(154.81,20.18)
PWR_CHG_CSIP: length 7.2
  TOP w0.203: v2(153.02,17.13) 153.4,17.13 153.87,17.6 PC4416.1
  BOTTOM w0.203: PC4415.1 153.39,19.4 PR4422.2 ; PC4415.1 153.39,17.34 153.19,17.13 v2(153.02,17.13) 152.71,16.83 152.26,16.83 152.05,16.62 PU4401.15 ; PC4415.1 154.28,18.61 v1(154.44,18.77)
PWR_CHG_CSIP_R: length 220.8
  TOP w0.203: PG4401.2 28.92,67.51 28.71,67.3 v2(28.21,67.3)
  L5 w0.203: v2(28.21,67.3) 28.21,67.12 28,66.92 27.27,66.92 26.65,66.3 25.21,66.3 23.48,64.57 23.28,64.57 21.4,62.69 21.4,62.29 21.29,62.18 21.29,58.8 21.48,58.62 21.48,49.19 22.08,48.59 v2(22.08,48.38)
  L6 w0.203: v2(154.83,19.49) 154.59,19.49 154.3,19.2 154.3,18.79 156.18,16.91 156.18,13.85 157.09,12.93 157.12,12.93 157.59,12.46 157.59,10.59 156.82,9.81 151.62,9.81 148.36,6.55 122.24,6.55 121.11,7.68 99.44,7.68 99,8.11 98.16,8.96 96.68,10.43 96.58,10.53 96.13,10.98 90.16,10.98 89.59,10.41 88.07,10.41 87.94,10.55 80.17,10.55 79.87,10.24 64.99,10.24 64.44,10.8 60.27,10.8 59.85,10.38 39.41,10.38 39.37,10.42 33.4,10.42 29.26,6.28 25.55,6.28 24.92,6.91 24.92,9.52 25.29,9.89 25.29,13 25.23,13.06 25.23,13.64 25.21,13.66 25.21,14.22 25.13,14.3 25.13,14.97 25.22,15.06 25.22,15.6 25.23,15.62 25.23,21.49 23.96,22.76 23.96,24.14 25,25.18 25,25.58 25.87,26.44 25.87,28.37 25.48,28.76 25.48,29.9 24.16,31.22 24.16,34.28 24.27,34.38 24.27,45.93 22.08,48.13 v2(22.08,48.38)
  BOTTOM w0.203: v1(28.39,67.83) 28.21,67.64 v2(28.21,67.3) ; PR4422.1 154.17,19.49 v2(154.83,19.49)
PWR_CHG_CSON: length 8.1
  TOP w0.203: PC4451.2 145.99,10.02 v1(147.81,10.02) v3(147.81,10.89)
  BOTTOM w0.203: PU4401.1 149.09,12.02 148.85,11.78 148.81,11.78 148.53,11.5 148.53,11.25 148.17,10.89 v3(147.81,10.89) 147.73,10.89 146.94,10.1 146.94,9.91 PC4425.2 146.9,9.87 PR4425.1
PWR_CHG_CSON_R: length 25.7
  TOP w0.203: PG4406.1 121.39,9.38 122.34,8.43 123.04,8.43 v2(123.04,8.41)
  L6 w0.203: v2(123.04,8.41) 123.46,8.41 123.48,8.38 123.88,8.38 124.19,8.69 126.59,8.69 126.88,8.99 129.88,8.99 130.25,9.35 142.66,9.35 143.3,10 v2(143.73,10)
  BOTTOM w0.203: v2(143.73,10) 143.78,10 144.15,9.63 v1(144.2,9.63) 144.82,9.63 PR4425.2
PWR_CHG_CSOP: length 7.5
  TOP w0.203: v3(148.07,11.44) 148.05,11.42 147.68,11.42 147.35,11.08 v1(146.78,11.08) PC4424.2
  BOTTOM w0.203: PR4424.1 146.4,10.7 PC4425.1 147.35,11.19 147.59,11.44 v3(148.07,11.44) 148.07,11.52 148.07,11.53 148.07,11.69 148.5,12.11 148.5,13.08 148.71,13.28 PU4401.2
PWR_CHG_CSOP_R: length 24.2
  TOP w0.203: v2(123.68,8.87) 123.68,9.32 v1(123.58,9.42) PG4405.1
  L6 w0.203: v2(144.37,10.22) 144.02,10.56 143.41,10.56 142.52,9.68 130.11,9.68 129.74,9.32 126.75,9.32 126.45,9.02 123.84,9.02 v2(123.68,8.87)
  BOTTOM w0.203: PR4424.2 144.57,10.7 144.37,10.5 v2(144.37,10.22)
PWR_CHG_DATA: length 2.4
  BOTTOM w0.203: PR4488.2 155.15,13.95 154.26,13.95 154.13,14.08 PU4401.21
PWR_CHG_DCIN: length 2.6
  BOTTOM w0.203: v2(153.81,16.49) PU4401.17
  BOTTOM w0.508: v2(153.81,16.49) 154.37,17.05 154.7,17.05 PR4403.2
  vias: v1(154.66,15.61)
PWR_CHG_DCIN_R: length 4.1
  TOP w0.508: PD4407.K 156.42,20.67 v1(156.42,19.61) 156.42,19.51 v2(155.99,19.08)
  BOTTOM w0.508: v2(155.99,19.08) 156.38,18.68 PD4401.3 156.68,17.35 PR4403.1
PWR_CHG_LGATE1: length 23.1
  TOP w0.635: PU4402.8 132.77,14.83 132.13,14.19 v4(132.13,14.08)
  L8 w0.635: v4(132.13,14.08) 134.3,16.25 134.3,16.9 135.49,18.08 136.79,18.08 138.21,19.51 143.35,19.51 145.18,17.68 v4(147.94,17.68)
  BOTTOM w0.203: PU4401.9 149.38,16.24 v1(148.43,17.19) v4(147.94,17.68)
PWR_CHG_LGATE2: length 17
  TOP w0.356: v4(147.96,15.95) v1(147.49,15.48)
  TOP w0.635: PU4403.8 136.08,20.17 v4(136.13,20.12)
  L3 w0.635: v4(147.96,15.95) 146.13,17.77 145.95,17.77 145.73,17.99 144.93,17.99 143.38,19.54 136.71,19.54 v4(136.13,20.12)
  BOTTOM w0.203: PU4401.7 148.67,15.28 148.01,15.95 v4(147.96,15.95)
PWR_CHG_OTGEN: length 3
  TOP w0.203: v1(154.88,14.15) 154.56,14.47 v2(154.41,14.47) 154.05,14.11 PR4417.1
  BOTTOM w0.203: v2(154.41,14.47) 154.41,14.47 154.41,14.46 153.4,14.46 153.38,14.48 PU4401.20
PWR_CHG_OTGPG: length 1.9
  BOTTOM w0.203: PU4401.26 152.05,11.98 152.89,11.14 TP4402.1
PWR_CHG_PHASE1: length 10
  L8 w0.635: v4(149.24,17.22) 148.61,17.22 148.27,16.88 147.09,16.88 146.75,16.54 144.71,16.54 143.46,17.79 v4(143.25,17.79)
  BOTTOM w0.203: v4(149.24,17.22) 149.43,17.03 149.58,17.03 150.02,16.6 150.02,16.53 150.05,16.5 PU4401.10
  BOTTOM w0.635: PC4436.2 149.24,18.92 v4(149.24,17.22)
  vias: v1(139.57,14.75) v4(141.31,18.71) v4(141.49,17.82) v4(142.18,18.7) v4(142.36,17.77) v4(143.02,18.67)
PWR_CHG_PHASE2: length 21.3
  L3 w0.635: v4(130.45,14.08) 130.45,14.73 131.08,15.37 140.07,15.37 140.39,15.68 145.1,15.68 145.9,14.88 v4(148.13,14.88)
  BOTTOM w0.203: PC4423.2 146.98,14.88 v4(148.13,14.88) PU4401.6
  vias: v1(130.84,14.83) v4(129.53,14.08) v4(129.88,13.31) v4(130.8,13.31) v4(131.28,14.08)
PWR_CHG_PROCHOT#: length 41.2
  L3 w0.203: v2(154.14,12.7) 157.38,15.94 158.98,15.94 159.56,15.36 162.96,15.36 163.93,16.33 163.93,17.03 162.42,18.54 161.54,18.54 161.3,18.78 158.24,18.78 157.53,18.07 155.07,18.07 153.05,20.09 v2(147.78,20.09)
  BOTTOM w0.203: PQ4416.5 153.56,23.39 153.3,23.65 152.63,23.65 152.31,23.33 151.68,23.33 v1(151.27,22.92) 150.87,22.52 149.64,22.52 149.31,22.19 149.31,21.62 v2(147.78,20.09) ; PR4435.2 155.22,12.53 154.32,12.53 v2(154.14,12.7) 153.56,13.28 PU4401.23
PWR_CHG_PROCHOT#_R: length 4.4
  BOTTOM w0.203: PQ4402.G 149.91,21.82 PR4472.2 151.04,21.52 v1(151.64,20.92) 152.54,20.92 PQ4416.3 PQ4416.2
PWR_CHG_PROG: length 2.6
  TOP w0.203: v3(151.81,11.49) 151.77,11.45 151.43,11.45 151.23,11.66 v1(151.23,11.67) 151.14,11.76 151.14,12.45 PR4410.1
  BOTTOM w0.203: v3(151.81,11.49) 151.81,11.73 151.65,11.89 PU4401.27
PWR_CHG_SNB: length 3.1
  TOP w0.305: v1(141.8,19.69) 141.64,19.54 140.54,19.54 PR4416.2
  TOP w0.635: PC4435.1 139.36,20.33 139.99,19.7 PR4416.2
PWR_CHG_UGATE1: length 27.4
  TOP w0.635: PU4402.1 132.47,8.94 131.84,9.57 v1(131.84,10.14) v4(131.84,12.02)
  L8 w0.635: v4(131.84,12.02) 133.65,13.84 145.03,13.84 145.59,13.28 148.08,13.28 148.96,14.16 148.96,15.63 150.25,16.92 v4(150.25,17.22)
  BOTTOM w0.203: PU4401.11 150.45,17.03 v4(150.25,17.22)
PWR_CHG_UGATE2: length 31.9
  TOP w0.305: v4(147.74,14.08) 147.74,13.28 v1(147.81,13.21)
  TOP w0.635: v4(129.18,21.03) 129.18,20.43 PU4403.1
  L3 w0.635: v4(129.18,21.03) 128.71,20.56 128.71,13.8 128.73,13.78 128.73,13.75 129.08,13.39 129.08,12.98 129.55,12.51 129.57,12.51 129.58,12.5 131.18,12.5 131.51,12.82 132.51,12.82 134.09,14.41 142.79,14.41 143.48,13.71 147.38,13.71 v4(147.74,14.08)
  BOTTOM w0.203: v4(147.74,14.08) 147.88,14.08 148.1,14.3 148.37,14.3 148.56,14.48 PU4401.5
PWR_CHG_VBAT1: length 14.2
  TOP w0.203: v2(149.16,10.55) 149.16,9.83 148.35,9.02 148.35,8.39 147.75,7.79 PC4440.1 146.41,7.79 145.82,7.2 142.22,7.2 141.97,6.94 139.81,6.94 PR4483.1
  BOTTOM w0.203: PU4401.31 150.05,11.82 149.62,11.39 149.62,11.02 v1(149.55,10.95) v2(149.16,10.55)
PWR_CHG_VBATIN: length 7.8
  TOP w0.203: R6625.2 124.48,8.6 123.81,7.92 121.84,7.92 121.1,8.66 120.32,8.66 119.5,9.48 119.5,10.21 119.7,10.4
  vias: v1(120.5,12.31) v2(118.56,12.07) v2(118.81,11.39) v2(119.2,12.61) v2(119.19,11.93) v2(119.84,12.59) v2(119.82,11.95)
PWR_CHG_VDDP: length 5.1
  BOTTOM w0.203: 147.74,16.68 148.27,16.68 148.42,16.53 148.48,16.53 149.09,15.93 PU4401.8
  BOTTOM w0.508: 147.74,16.68 147.51,16.68 v1(147.31,16.48) 146.87,16.05 PC4452.1 146.23,16.1 146.23,17.38 PR4405.1
PWR_CORE_PSYS: length 189.8
  TOP w0.203: PR4413.1 150.52,11.61 v2(150.26,11.35) ; v1(33.6,33.74) 33.47,33.87 v2(33.47,34.32)
  L3 w0.203: v2(33.47,34.32) 33.13,34.66 33.13,38.33 33.68,38.89 34.04,38.89 35.54,40.39 35.54,57.61 36.52,58.59 36.52,60.2 40.46,64.14 43.01,64.14 45.35,66.48 49.11,66.48 49.7,65.89 50.2,65.89 v2(50.69,66.38)
  L6 w0.203: v2(33.47,34.32) 33.81,33.98 33.81,26.38 34.46,25.73 34.46,24.39 33.58,23.52 33.58,19.24 36.23,16.59 36.89,16.59 37.35,17.05 39.77,17.05 40.29,16.52 52.46,16.52 56.38,12.6 69.68,12.6 69.89,12.81 82.61,12.81 82.99,13.18 87.31,13.18 87.97,12.53 90.29,12.53 90.36,12.6 96.63,12.6 96.9,12.34 97.74,11.49 100.06,9.18 121.59,9.18 122.84,7.92 129.46,7.92 130.44,8.9 138.4,8.9 138.4,8.89 143.65,8.89 144.29,9.53 148.92,9.53 149.8,10.4 149.8,10.89 v2(150.26,11.35)
  BOTTOM w0.203: v2(150.26,11.35) 150.26,11.54 150.36,11.64 150.36,11.66 150.45,11.75 PU4401.30 ; v2(50.69,66.38) 50.69,66.53 PR4614.1 49.85,67.06 49.47,66.68 PU4601.1
PWR_CORE_VCCST:
  vias: v1(48.84,68.03)
PWR_DCBATOUT_1D05V:
  vias: v1(132,84.51)
PWR_DCBATOUT_1D35V:
  vias: v1(183.56,36.33)
PWR_DCBATOUT_VCCGT: length 1.8
  BOTTOM w0.203: PC4801.1 40.86,56.09 R6611.1
  vias: v1(40.36,53.57) v2(40.05,52.63) v2(40.08,51.95) v4(39.79,55.22) v4(39.76,54.39)
PWR_DCBATOUT_VCCGT_R: length 120.7
  L3 w0.127: v2(62.42,85.48) 62.71,85.19 64.43,85.19 64.85,85.62 65.93,85.62 65.96,85.65 66.22,85.65 67.18,86.61 93.48,86.61 93.53,86.66 94.72,86.66 94.74,86.64 100.51,86.64 101.2,87.33 107.25,87.33 109.59,84.99 109.59,83.27 114.62,78.24 118.3,78.24 120.16,76.38 120.16,75.96 120.42,75.7 120.61,75.7 v2(120.75,75.56)
  L6 w0.127: v2(62.42,85.48) 62.26,85.32 61.48,85.32 61.2,85.05 61.2,85.01 61.18,84.99 61.18,83.13 57.09,79.04 42.27,79.04 39.73,76.5 39.73,69.78 39.74,69.77 39.74,69.74 40.96,68.52 40.96,60.14 39.9,59.08 39.9,59.08 39.41,58.58 39.41,57.94 39.89,57.46 40.47,57.46 41.03,58.02 41.03,58.34 41.04,58.52 v2(41.31,58.76)
  BOTTOM w0.127: v1(41.97,58.32) 41.75,58.32 v2(41.31,58.76) 40.86,58.3 R6611.2 ; v2(120.75,75.56) 120.57,75.56 120.33,75.8 120.33,76.04 120.35,76.07 120.35,76.08 120.48,76.21 121,76.21 121.35,75.86 121.91,75.86 122.17,76.12 122.17,76.28 122.25,76.35 CN1.3
PWR_DCBATOUT_VCCSA:
  vias: v1(98.12,84.82) v4(99.17,85.67) v4(99.2,84.72) v4(100.1,85.67) v4(100.11,84.73)
PWR_DCBATOUT_VCCSA_R: length 33.9
  BOTTOM w0.127: CN1.17 125.05,77.51 125.23,77.69 125.26,77.69 125.76,78.19 125.76,79.02 124.62,80.15 122.93,80.15 122.72,79.94 122.72,79.34 120.97,77.59 113.61,77.59 108.28,82.93 108.28,84.71 107.28,85.7 106.77,85.7 ; R6616.2 101.55,85.86 101.69,86 101.79,86 101.87,86 102.68,86 102.97,85.7 106.77,85.7 ; 106.77,85.7 v1(106.77,85.4)
PWR_DCBATOUT_VCOREA:
  vias: v1(94.07,86.59) v2(69.91,85.59) v2(69.91,84.96) v2(70.54,84.96) v2(71.31,84.97) v2(90.81,85.92) v2(90.81,85.29) v2(91.45,85.29) v2(92.21,85.3) v2(93.81,85.99) v2(94.45,85.98) v2(95.1,85.96) v4(73.97,85.25) v4(74.88,85.24) v4(75.79,85.25)
PWR_DCBATOUT_VCOREA_R: length 42.5
  L8 w0.127: v2(117.27,78.75) 117.27,78.02 118.75,76.54 118.75,73.14 120.14,71.75 123.44,71.75 123.72,72.03 123.72,72.32 124.11,72.71 v2(124.11,72.99)
  BOTTOM w0.127: v2(117.27,78.75) 117.27,79.01 117.09,79.19 116.42,79.19 116.21,78.98 116.09,78.98 115.89,78.77 113.9,78.77 109.12,83.56 109.12,85.2 106.63,87.7 ; R6622.1 94.85,87.93 95.11,88.18 95.29,88.37 105.95,88.37 106.63,87.7 ; 106.63,87.7 v1(106.77,87.84) ; CN1.14 124.25,73.13 v2(124.11,72.99)
PWR_DCBATOUT_VDDQ: length 8.1
  L5 w0.305: v2(27.66,42.23) 27.65,42.23 27.65,42.22 27.77,42.22 27.84,42.29 31.01,42.29 31.59,41.71 31.59,41.58 32.5,40.66 33.65,40.66 v2(34,40.31)
  BOTTOM w0.305: v2(27.66,42.23) 27.65,42.23 27.65,42.22 27.77,42.22 27.81,42.18 PR5108.1
  vias: v1(36.07,40.44) v2(34.79,40.31)
PWR_DCBATOUT_VDDQ_R: length 185.2
  TOP w0.127: R6614.2 36.38,39.65 v2(36.38,39.05) ; v2(16.51,45.43) 16.75,45.43 v1(17,45.69)
  L3 w0.127: v2(124.34,78.57) 124.78,78.13 125.34,78.13 125.6,78.39 125.6,78.49 126.42,79.32 128.19,79.32 128.49,79.61 128.49,85.55 127.22,86.81 110.24,86.81 108.77,88.28 93.16,88.28 93.15,88.27 87.54,88.27 87.45,88.18 66.43,88.18 65.24,86.99 61.46,86.99 61.41,87.04 59.93,87.04 58.59,85.7 58.59,82.85 57.04,81.3 56.5,81.3 56.29,81.09 53.32,81.09 51.38,79.14 37.74,79.14 35.95,77.35 32.49,77.35 32.27,77.14 30.89,77.14 30.4,77.14 28.28,75.02 28.28,72.28 27.53,71.53 27.53,71 27.01,70.48 25.37,70.48 23.44,68.55 23.44,67.89 22.23,66.67 21.06,66.67 18.49,64.1 18.49,61.11 18.54,61.06 18.54,58.09 17.62,57.16 17.62,54.97 18.06,54.52 18.06,53.47 17.01,52.41 17.01,51.33 16.43,50.75 16.43,50.2 16.44,50.19 16.44,49.82 15.7,49.08 15.7,46.24 v2(16.51,45.43)
  L5 w0.127: v2(16.51,45.43) 16.65,45.57 17.01,45.57 17.53,45.05 18.62,45.05 19.1,44.57 19.1,44.44 20.88,42.66 23.33,42.66 24.95,44.28 24.95,44.72 25.21,44.98 29.97,44.98 30.71,44.23 32.14,44.23 36.38,39.99 v2(36.38,39.05)
  BOTTOM w0.127: v2(124.34,78.57) 124.34,77.16 124.26,77.08 124.26,76.7 CN1.13
PWR_IMVP_PWRGD: length 4.4
  BOTTOM w0.203: TP4601.1 50.99,69.04 PR4609.2 50,68.65 49.24,67.89 48.19,67.89 47.97,67.67 PU4601.39
PWR_LEVEL: length 10.4
  BOTTOM w0.089: 160.08,50.02 160.08,50.81 158.99,51.9 158.99,52.3 159.07,52.39 159.07,52.86 158.86,53.06 158.86,53.68 GPU1.D7
  BOTTOM w0.203: D7902.A 159.05,45.43 v1(159.05,46.3) 159.21,46.46 159.93,46.46 R7905.2 159.88,46.83 159.88,47.41 160.08,47.61 160.08,50.02
PWR_VCCGT_BOOT: length 7.5
  TOP w0.356: PR4805.2 42.4,48.11 41.66,48.85 40.54,48.85 40.36,49.03 40.35,49.03 v1(39.6,49.78) 39.6,49.78 39.6,49.79 v2(38.06,51.33)
  BOTTOM w0.203: PU4801.5 v2(38.06,51.33)
PWR_VCCGT_BOOT_RC: length 2.4
  TOP w0.635: PR4805.1 PC4807.1 45.69,46.79 v1(45.77,46.72)
PWR_VCCGT_BOOTR: length 9.2
  TOP w0.356: PC4807.2 44.62,48.18 43.74,49.07 42.67,49.07 42.02,49.71 40.93,49.71 v1(39.65,51) 38.32,52.33 v2(38.04,52.33)
  BOTTOM w0.203: PU4801.7 v2(38.04,52.33)
PWR_VCCGT_COMP: length 3.8
  TOP w0.203: PR4656.1 46.75,62.41 PC4639.1 46.85,62.08 v2(46.22,61.45) 46.14,61.52 v1(45.47,61.52)
  BOTTOM w0.203: PU4601.16 46.37,61.6 v2(46.22,61.45)
PWR_VCCGT_COMP1: length 1.6
  TOP w0.203: PR4656.2 45.2,63.17 PC4640.1 44.48,63.2 v1(44.39,63.1)
PWR_VCCGT_FB: length 4
  BOTTOM w0.203: PU4601.17 45.97,61.89 45.55,61.47 v1(45.55,61.12) PR4660.1
  BOTTOM w0.254: PR4657.1 PR4658.1 PR4660.1
PWR_VCCGT_FB2: length 3.7
  TOP w0.203: v2(44.89,58.78) 44.89,58.52 45.14,58.27 45.14,58.23 45.17,58.21 v1(45.17,57.76) ; PC4644.1 PR4686.2 44.48,60.2 43.83,60.2 PR4695.2
  TOP w0.254: v2(44.89,58.78) 44.79,58.78 44.56,59.01 PC4644.1
PWR_VCCGT_FB_RC: length 0.8
  BOTTOM w0.254: PR4658.2 46.32,58.68 PC4643.1
PWR_VCCGT_FCCM#: length 25.2
  TOP w0.203: v1(40.17,45.62) 40.2,45.65 v2(40.73,45.65) PR4806.2
  L3 w0.203: v2(40.73,45.65) 39.19,45.65 36.6,48.24 36.6,55.63 40.9,59.93 40.9,60.84 42.58,62.53 v2(43.06,62.53)
  BOTTOM w0.203: PU4601.21 44.01,63.08 43.46,62.53 v2(43.06,62.53)
PWR_VCCGT_FCCM#_R: length 5
  TOP w0.203: PR4806.1 v1(39.56,47.32) 39.21,47.32 v2(38.65,47.88)
  BOTTOM w0.203: PU4801.2 38.43,49.83 38.21,49.61 38.21,48.32 v2(38.65,47.88)
PWR_VCCGT_IMON: length 3.8
  TOP w0.203: v2(47.23,61.5) 47.32,61.41 v1(48.01,61.41) 48.01,61.92 PR4661.1 48.43,62.39 47.69,62.39 PC4638.1
  BOTTOM w0.203: PU4601.14 47.17,61.56 v2(47.23,61.5)
PWR_VCCGT_ISUMN: length 34.3
  TOP w0.203: PR4801.2 v2(49.33,54.56) ; PR4649.2 40.07,60.2 PC4634.1 41.21,60.25 PR4652.2 ; PR4649.2 39.45,60.25 39.11,59.91 v1(39.11,59.69) 39.11,59.21 v2(39.26,59.06) ; PR4649.2 40.02,60.89 PC4631.1 39.47,61.9 PR4651.2 40.42,62.89 PR4648.2
  L3 w0.203: v2(49.33,54.56) 49.33,53.94 49.7,53.57 49.7,53.53 49.71,53.52 49.71,53.45 49.7,53.43 49.7,52.57 49.9,52.36 v2(49.9,43.42)
  L5 w0.203: v2(49.33,54.56) 47.71,54.56 47.34,54.94 47.34,57.28 45.04,59.58 39.78,59.58 v2(39.26,59.06)
  BOTTOM w0.203: PR4650.1 v2(49.9,43.42)
PWR_VCCGT_ISUMN_G: length 7
  TOP w0.203: v1(49.43,53.37) 49.11,53.69 48.55,53.69 PR4801.1 v2(48.54,52.76)
  BOTTOM w0.203: PG4808.1 49.36,48.29 48.86,48.8 48.86,51.74 48.48,52.13 48.48,52.69 v2(48.54,52.76)
PWR_VCCGT_ISUMN_P_1: length 4.2
  TOP w0.203: PC4652.1 41.6,58.36 41.33,58.09 v1(40.94,58.09) 40.38,58.09 40.02,58.45 PR4649.1 40.05,59.43 41.13,59.43 PC4635.1
PWR_VCCGT_ISUMN_P_2: length 22.7
  L3 w0.203: v2(44.66,58.07) 44.78,58.2 46.1,58.2 48.84,55.46 48.84,53.7 49.11,53.43 49.11,52.02 49.38,51.76 49.38,43.64 v2(49.04,43.3)
  BOTTOM w0.203: PR4653.2 42.63,57.93 43,57.56 v1(43.06,57.56) 43.79,57.56 43.81,57.54 44.21,57.54 44.5,57.82 44.5,57.91 v2(44.66,58.07) ; PR4650.2 v2(49.04,43.3)
PWR_VCCGT_ISUMN_RC: length 1.8
  TOP w0.203: PC4632.1 42,61.95 41.17,61.95 v1(41.16,61.96) 41.1,61.9 PR4651.1
PWR_VCCGT_ISUMNA: length 4.3
  TOP w0.203: PR4648.1 41.41,62.82 PC4632.2 42.94,61.93 v1(42.94,61.85) 43.07,61.85 43.68,62.46 v2(44.26,62.46)
  BOTTOM w0.203: PU4601.20 44.75,62.46 v2(44.26,62.46)
PWR_VCCGT_ISUMP: length 17.8
  TOP w0.203: PR4808.2 47.66,55.24 v2(47.84,55.43) ; PC4652.2 42.08,59.05 PC4635.2 PC4634.2 PR4652.1 42.23,61.22 42.76,61.22 v2(42.91,61.07)
  L5 w0.203: v2(47.84,55.43) 48.09,55.68 48.09,57.17 45.04,60.22 43.76,60.22 v2(42.91,61.07)
  BOTTOM w0.203: PR4653.1 42.68,60.33 42.68,60.56 42.91,60.79 v2(42.91,61.07) 42.91,61.3 43.28,61.67 v1(43.32,61.67) 43.32,61.7 43.57,61.96 44.51,61.96 44.57,61.89 45.04,61.89 45.17,62.03 PU4601.19
PWR_VCCGT_ISUMP_G: length 7.2
  TOP w0.203: PR4808.1 47.45,53.7 47.02,53.27 v1(47.02,52.96) 47.64,52.96 v2(47.84,52.76)
  BOTTOM w0.203: v2(47.84,52.76) 47.97,52.63 47.97,51.74 48.35,51.36 48.35,48.57 48.02,48.24 PG4807.1
PWR_VCCGT_NTC: length 3.2
  TOP w0.203: PR4662.1 46.19,60.41 v2(46.75,60.97) 46.75,60.86 v1(47.19,60.41)
  BOTTOM w0.203: v2(46.75,60.97) 46.75,61.7 46.77,61.72 PU4601.15
PWR_VCCGT_NTC1: length 22.9
  TOP w0.203: PR4662.2 46.19,58.86 PR4655.2 46.41,58.39 46.41,58.27 46.63,58.05 v1(46.63,57.74) 46.63,57.55 46.41,57.33 v2(46.41,57.21)
  L8 w0.203: v2(46.41,57.21) 46.59,57.21 47.34,56.46 47.34,55.24 45.65,53.55 44.47,53.55 44.41,53.6 37.63,53.6 37.09,53.06 37.09,46.97 v2(37.17,46.89)
  BOTTOM w0.203: PR4654.1 v2(37.17,46.89)
PWR_VCCGT_PWM: length 26.5
  TOP w0.203: PR4802.2 v2(41.6,45.62) 42.12,45.62 v1(42.16,45.58)
  L3 w0.203: v2(43.15,63.16) 43.55,62.76 43.55,62.33 43.03,61.82 42.98,61.82 42,60.83 42,58.76 40.95,57.71 39.82,57.71 37.31,55.21 37.31,48.54 38.45,47.4 40.5,47.4 41.6,46.3 v2(41.6,45.62)
  BOTTOM w0.203: v2(43.15,63.16) 43.42,63.16 43.73,63.48 PU4601.22
PWR_VCCGT_PWM_R: length 5
  TOP w0.203: v2(38.95,48.54) v1(39.66,48.54) 40.14,48.06 41.34,48.06 v2(41.47,47.93) 41.6,47.8 PR4802.1
  BOTTOM w0.203: v2(41.47,47.93) 41.47,47.62 PR4812.1 ; PU4801.1 38.86,48.64 v2(38.95,48.54)
PWR_VCCGT_RTN: length 7.2
  TOP w0.254: v1(44.12,61.54) 44.11,61.54 43.66,61.09 v2(43.57,61.09) 43.57,60.99 42.94,60.36 PR4694.2
  BOTTOM w0.203: 43.57,61.12 43.88,61.42 45.05,61.42 45.22,61.59 45.22,61.61 45.57,61.96 PU4601.18
  BOTTOM w0.254: 43.57,61.12 v2(43.57,61.09) 43.55,61.07 43.55,61.06 43.55,61.06 43.55,60.7 43.42,60.57 PC4637.1 PR4659.2 43.42,58.7 PC4642.1
PWR_VCCGT_SNB: length 2.9
  TOP w0.635: v1(45.2,51.68) 45.2,51.67 PR4803.2 46.76,51.99 PC4806.1
PWR_VCCGT_SW: length 1.8
  TOP w0.356: v2(46.06,50.47) 46.06,49.68 PR4803.1
  vias: v1(42.82,47.69)
PWR_VCCGT_VCC_R: length 6.3
  BOTTOM w0.254: v1(39.97,47.66) 39.64,47.33 PR4804.1
  BOTTOM w0.305: PU4801.3 37.99,50.33 37.63,49.97 37.63,48.11 37.98,47.77 PC4808.1 38.01,47.33 PR4804.1
PWR_VCCSA_BST: length 2.7
  TOP w0.305: PR5001.2 104.61,88.57 103.99,87.96 PU5002.2
PWR_VCCSA_BST_RC: length 2.4
  TOP w0.305: v1(107.06,85.52) 106.64,85.52 PC5005.1
  TOP w0.635: PC5005.1 PR5001.1
PWR_VCCSA_COMP: length 7.3
  BOTTOM w0.203: PU4601.24 43.28,64.28 43.27,64.27 43.16,64.27 42.96,64.06 42.67,63.78 42.67,62.82 42.29,62.44 42.29,60.85 PR4640.1 41.86,59.69 41.65,59.48 v1(41.59,59.48) PC4624.1
PWR_VCCSA_COMP_RC: length 2.1
  BOTTOM w0.203: PC4601.1 39.12,60.39 v1(40.13,60.39) 40.15,60.39 40.18,60.42 PR4640.2
PWR_VCCSA_DRVH: length 12.6
  TOP w0.305: PU5001.4 v2(100.75,79.29) ; v2(105.07,86.6) 104.96,86.7 104.96,87.21 104.66,87.52 PU5002.1
  TOP w0.356: v2(100.75,79.29) v1(101.31,79.29)
  L8 w0.635: v2(100.75,79.29) 102.79,81.33 103.39,81.33 105.42,83.37 105.42,85.04 105.07,85.4 v2(105.07,86.6)
PWR_VCCSA_DRVL: length 2.3
  TOP w0.305: PU5002.5 102.99,85.12 102.8,84.93 102.8,84.92 102.61,84.72 v1(102.61,84.45) PU5003.4
PWR_VCCSA_FB: length 6.6
  BOTTOM w0.203: PU4601.25 43.21,64.68 43.13,64.6 43.02,64.6 42.82,64.39 42.34,63.91 42.34,63.44 42.15,63.25 42,63.25 42,63.25 PR4632.2
  BOTTOM w0.254: PR4637.1 40.81,62.26 v1(41.79,62.26) ; PR4638.2 41.68,62.14 v1(41.79,62.26) ; v1(41.79,62.26) 41.84,62.3 PR4632.2
PWR_VCCSA_FB1: length 2
  BOTTOM w0.381: PR4638.1 40.23,61.24 v1(39.88,61.59) 39.83,61.59 39.63,61.4 PC4621.2
PWR_VCCSA_FB2: length 4.4
  BOTTOM w0.203: PC4617.2 39.23,62.43 PC4620.1 39.53,62.29 PR4637.2 ; PR4693.1 38.26,63.31 v1(37.48,63.31)
  BOTTOM w0.254: PR4693.1 39.18,63.2 PC4617.2 39.12,63.35 PC4616.2
PWR_VCCSA_FB_RC: length 0.8
  BOTTOM w0.254: PC4617.1 PR4632.1
PWR_VCCSA_FCCM: length 81.4
  TOP w0.203: PU5002.7 103.99,85.1 v2(104.28,84.82)
  L6 w0.203: v3(43.3,67.12) 43.19,67.12 42.66,67.64 42.66,68.66 41.62,69.7 41.62,72.66 42.06,73.1 43.12,73.1 43.42,72.8 47.77,72.8 51.98,77.01 52.89,77.01 53.7,77.82 57.32,77.82 63.91,84.41 63.91,86.21 66.45,88.75 88.53,88.75 88.56,88.79 100.3,88.79 v2(104.28,84.82)
  BOTTOM w0.203: v3(43.3,67.12) 43.37,67.05 43.37,66.65 43.75,66.28 PU4601.29 ; v2(104.28,84.82) v1(104.84,84.82)
