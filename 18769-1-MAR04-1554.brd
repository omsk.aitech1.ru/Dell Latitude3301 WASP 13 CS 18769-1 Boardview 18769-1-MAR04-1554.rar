# Allegro board 18769-1-MAR04-1554.brd (continued)
## Nets (continued)
GND: AFTP2507.1 AFTP2604.1 AFTP4306.1 AFTP4307.1 AFTP4308.1 AFTP6525.1 BATT1.8 BATT1.9 BATT1.10 BATT1.11 BATT1.12 BATT1.13 BATT1.14 BIOS1.4 C801.1 C802.1 C803.1 C804.2 C805.2 C806.2 C807.2 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1201.2 C1209.2 C1210.2 C1211.2 C1214.2 C1215.2 C1218.2 C1219.2 C1220.2 C1221.2 C1226.2 C1227.2 C1229.2 C1230.2 C1231.2 C1242.2 C1244.2 C1245.2 C1247.2 C1248.2 C1249.2 C1252.2 C1253.2 C1256.2 C1257.2 C1258.2 C1259.2 C1260.2 C1261.2 C1262.2 C1263.2 C1265.2 C1266.2 C1268.2 C1269.2 C1270.2 C1271.2 C1275.2 C1276.2 C1277.2 C1278.2 C1279.2 C1304.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1317.2 C1322.2 C1323.2 C1324.2 C1325.2 C1326.2 C1329.2 C1330.2 C1331.2 C1332.2 C1333.2 C1334.2 C1338.2 C1341.2 C1342.2 C1343.2 C1344.2 C1348.2 C1349.2 C1350.2 C1351.2 C1352.2 C1353.2 C1354.2 C1355.2 C1356.2 C1367.2 C1368.2 C1369.2 C1370.2 C1371.2 C1372.2 C1701.2 C1711.2 C1803.2 C1804.2 C1805.2 C1806.2 C1807.2 C1808.2 C2201.2 C2202.2 C2203.2 C2204.2 C2205.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.2 C2222.2 C2223.2 C2224.2 C2405.2 C2406.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2415.2 C2416.2 C2418.1 C2421.2 C2423.2 C2424.2 C2425.2 C2427.2 C2428.2 C2429.2 C2436.2 C2501.2 C2502.2 C2503.2 C2517.2 C2525.2 C2601.2 C2602.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2704.2 C2705.2 C2709.1 C2713.2 C2714.2 C2717.2 C2718.2 C2720.2 C2721.2 C2722.2 C2723.2 C2739.2 C2740.2 C2741.2 C3301.2 C3302.2 C3303.2 C3304.2 C3305.2 C3307.2 C3308.2 C3309.2 C3310.2 C3311.2 C3312.2 C3313.2 C4001.2 C4002.2 C4003.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4012.2 C4013.2 C4031.2 C4032.2 C4034.2 C4035.2 C4037.2 C4039.2 C4040.2 C4043.2 C4302.2 C4303.2 C4304.2 C4305.2 C4306.2 C4344.2 C5502.2 C5503.2 C5505.2 C5507.2 C5508.2 C5512.2 C5513.2 C5514.2 C5515.2 C5516.2 C5517.2 C5518.2 C5554.2 C5555.2 C5556.2 C5557.2 C5558.2 C5701.2 C5710.2 C6104.2 C6105.2 C6106.2 C6109.2 C6110.2 C6111.2 C6304.2 C6305.2 C6306.2 C6307.2 C6308.2 C6317.2 C6318.2 C6401.2 C6402.2 C6501.2 C6504.2 C6505.2 C6702.2 C6703.2 C6715.2 C7005.2 C7006.2 C7115.2 C7116.2 C7117.2 C7118.2 C7119.2 C7201.1 C7202.1 C7203.1 C7205.2 C7206.2 C7208.2 C7210.2 C7211.2 C7212.2 C7217.2 C7218.2 C7244.2 C7301.2 C7302.2 C7303.2 C7304.2 C7305.2 C7306.2 C7307.2 C7610.2 C7611.2 C7612.2 C7613.2 C7614.2 C7616.2 C7620.2 C7621.2 C7622.2 C7627.2 C7628.2 C7629.2 C7630.2 C7631.2 C7744.2 C7745.2 C7746.2 C7805.2 C7807.2 C7808.2 C7810.2 C7811.2 C7812.2 C7815.2 C7816.2 C7817.2 C7818.2 C7819.2 C7820.2 C7821.2 C7822.2 C7823.2 C7825.2 C7826.2 C7827.2 C7902.2 C7905.2 C7906.2 C7907.2 C7908.2 C7934.2 C7935.2 C8001.2 C8002.2 C8003.2 C8004.2 C8008.2 C8009.2 C8010.2 C8011.2 C8012.2 C8013.2 C8014.2 C8015.2 C8016.2 C8017.2 C8018.2 C8019.2 C8020.2 C8021.2 C8022.2 C8023.2 C8024.2 C8025.2 C8027.2 C8028.2 C8029.2 C8030.2 C8031.2 C8032.2 C8033.2 C8034.2 C8035.2 C8036.2 C8037.2 C8038.2 C8039.2 C8040.2 C8041.2 C8042.2 C8043.2 C8044.2 C8045.2 C8046.2 C8101.2 C8104.2 C8105.2 C8106.2 C8107.2 C8108.2 C8109.2 C8110.2 C8111.2 C8112.2 C8113.2 C8114.2 C8115.2 C8116.2 C8117.2 C8118.2 C8119.2 C8120.2 C8121.2 C8122.2 C8123.2 C8124.2 C8125.2 C8126.2 C8201.2 C8202.2 C8204.2 C8205.2 C8206.2 C8207.2 C8209.2 C8210.2 C8211.2 C8212.2 C8213.2 C8214.2 C8215.2 C8216.2 C8217.2 C8218.2 C8219.2 C8220.2 C8221.2 C8222.2 C8223.2 C8224.2 C8225.2 C8226.2 C8525.2 C8602.2 C8603.2 C8604.2 C8901.2 C8902.2 C8903.2 C9104.2 C9106.2 C9108.2 C9109.2 C9112.2 C9113.2 C9201.2 CARD1.6 CARD1.9 CARD1.10 CARD1.11 CARD1.13 CARD1.14 CN1.11 CPU1.A3 CPU1.A4 CPU1.A32 CPU1.A36 CPU1.AB3 CPU1.AB4 CPU1.AB7 CPU1.AB27 CPU1.AB30 CPU1.AB33 CPU1.AB36 CPU1.AC5 CPU1.AC10 CPU1.AC27 CPU1.AC30 CPU1.AD33 CPU1.AD35 CPU1.AE7 CPU1.AE24 CPU1.AE25 CPU1.AE26 CPU1.AE27 CPU1.AE30 CPU1.AF3 CPU1.AF4 CPU1.AF7 CPU1.AF25 CPU1.AF27 CPU1.AF30 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG10 CPU1.AG24 CPU1.AG26 CPU1.AH24 CPU1.AH25 CPU1.AH27 CPU1.AH28 CPU1.AH29 CPU1.AH30 CPU1.AH31 CPU1.AH33 CPU1.AH35 CPU1.AJ7 CPU1.AJ25 CPU1.AJ28 CPU1.AK3 CPU1.AK4 CPU1.AK33 CPU1.AK36 CPU1.AL7 CPU1.AL28 CPU1.AL29 CPU1.AL32 CPU1.AM5 CPU1.AM10 CPU1.AM28 CPU1.AM33 CPU1.AM35 CPU1.AN7 CPU1.AN8 CPU1.AN25 CPU1.AN28 CPU1.AN29 CPU1.AN30 CPU1.AN31 CPU1.AP3 CPU1.AP4 CPU1.AP33 CPU1.AP36 CPU1.AR4 CPU1.AR28 CPU1.AT4 CPU1.AT33 CPU1.AT35 CPU1.AT36 CPU1.AU4 CPU1.AU10 CPU1.AU28 CPU1.AU29 CPU1.AU32 CPU1.AV3 CPU1.AV4 CPU1.AV6 CPU1.AV8 CPU1.AV25 CPU1.AV28 CPU1.AV33 CPU1.AV36 CPU1.AW1 CPU1.AW3 CPU1.AW4 CPU1.AW28 CPU1.AW29 CPU1.AW30 CPU1.AW31 CPU1.AY4 CPU1.AY33 CPU1.AY35 CPU1.B2 CPU1.B5 CPU1.B7 CPU1.B9 CPU1.B12 CPU1.B15 CPU1.B18 CPU1.B21 CPU1.B23 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B34 CPU1.B36 CPU1.B37 CPU1.BA3 CPU1.BA4 CPU1.BA6 CPU1.BA10 CPU1.BA28 CPU1.BB3 CPU1.BB4 CPU1.BB33 CPU1.BB36 CPU1.BC4 CPU1.BC8 CPU1.BC25 CPU1.BC29 CPU1.BC32 CPU1.BD4 CPU1.BD6 CPU1.BD7 CPU1.BD28 CPU1.BD33 CPU1.BD35 CPU1.BD36 CPU1.BE3 CPU1.BE4 CPU1.BE8 CPU1.BE10 CPU1.BE28 CPU1.BE29 CPU1.BE30 CPU1.BE31 CPU1.BF3 CPU1.BF4 CPU1.BF33 CPU1.BF36 CPU1.BG4 CPU1.BG25 CPU1.BG28 CPU1.BH28 CPU1.BH29 CPU1.BH32 CPU1.BH33 CPU1.BH35 CPU1.BJ7 CPU1.BK2 CPU1.BK3 CPU1.BK4 CPU1.BK7 CPU1.BK10 CPU1.BK28 CPU1.BK33 CPU1.BL7 CPU1.BL25 CPU1.BL28 CPU1.BL29 CPU1.BL30 CPU1.BL31 CPU1.BL32 CPU1.BM9 CPU1.BM33 CPU1.BM35 CPU1.BM36 CPU1.BN7 CPU1.BN30 CPU1.BP3 CPU1.BP4 CPU1.BP7 CPU1.BP12 CPU1.BP15 CPU1.BP19 CPU1.BP25 CPU1.BP32 CPU1.BP33 CPU1.BP36 CPU1.BR16 CPU1.BR19 CPU1.BR22 CPU1.BR25 CPU1.BT5 CPU1.BT14 CPU1.BT15 CPU1.BT16 CPU1.BT25 CPU1.BT28 CPU1.BT33 CPU1.BT35 CPU1.BT36 CPU1.BU7 CPU1.BU11 CPU1.BU16 CPU1.BU20 CPU1.BU23 CPU1.BU24 CPU1.BU25 CPU1.BV3 CPU1.BV4 CPU1.BV11 CPU1.BV31 CPU1.BV33 CPU1.BW7 CPU1.BW11 CPU1.BW15 CPU1.BW24 CPU1.BY5 CPU1.BY11 CPU1.BY15 CPU1.BY18 CPU1.BY19 CPU1.BY22 CPU1.BY25 CPU1.BY28 CPU1.BY33 CPU1.BY35 CPU1.BY36 CPU1.C1 CPU1.C4 CPU1.C9 CPU1.C21 CPU1.C25 CPU1.C29 CPU1.C33 CPU1.C36 CPU1.C37 CPU1.CA11 CPU1.CA15 CPU1.CA22 CPU1.CA25 CPU1.CB2 CPU1.CB3 CPU1.CB4 CPU1.CB7 CPU1.CB11 CPU1.CB18 CPU1.CB19 CPU1.CB20 CPU1.CB24 CPU1.CB25 CPU1.CB33 CPU1.CC7 CPU1.CC11 CPU1.CC14 CPU1.CC16 CPU1.CC20 CPU1.CC24 CPU1.CC25 CPU1.CC28 CPU1.CC31 CPU1.CD11 CPU1.CD12 CPU1.CD14 CPU1.CD20 CPU1.CD24 CPU1.CD25 CPU1.CE7 CPU1.CE33 CPU1.CE35 CPU1.CE36 CPU1.CF2 CPU1.CF3 CPU1.CF4 CPU1.CF11 CPU1.CF14 CPU1.CF19 CPU1.CF23 CPU1.CF28 CPU1.CG7 CPU1.CG33 CPU1.CH31 CPU1.CJ2 CPU1.CJ3 CPU1.CJ4 CPU1.CJ11 CPU1.CJ14 CPU1.CJ19 CPU1.CJ23 CPU1.CJ28 CPU1.CJ33 CPU1.CJ35 CPU1.CJ36 CPU1.CK1 CPU1.CK4 CPU1.CK7 CPU1.CK37 CPU1.CL2 CPU1.CM1 CPU1.CM4 CPU1.CM5 CPU1.CM9 CPU1.CM13 CPU1.CM17 CPU1.CM21 CPU1.CM25 CPU1.CM29 CPU1.CM31 CPU1.CM33 CPU1.CM37 CPU1.CN1 CPU1.CN2 CPU1.CN5 CPU1.CN9 CPU1.CN13 CPU1.CN17 CPU1.CN21 CPU1.CN25 CPU1.CN29 CPU1.CN37 CPU1.CP1 CPU1.CP2 CPU1.CP9 CPU1.CP11 CPU1.CP13 CPU1.CP15 CPU1.CP19 CPU1.CP21 CPU1.CP27 CPU1.CP35 CPU1.CP37 CPU1.CR2 CPU1.CR6 CPU1.CR34 CPU1.CR36 CPU1.D1 CPU1.D5 CPU1.D6 CPU1.D8 CPU1.D9 CPU1.D21 CPU1.D25 CPU1.E9 CPU1.E23 CPU1.E27 CPU1.E29 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F12 CPU1.F15 CPU1.F18 CPU1.F21 CPU1.F24 CPU1.F33 CPU1.G9 CPU1.G21 CPU1.G27 CPU1.G33 CPU1.G35 CPU1.G36 CPU1.H9 CPU1.H21 CPU1.H27 CPU1.J5 CPU1.J6 CPU1.J12 CPU1.J15 CPU1.J18 CPU1.J21 CPU1.J24 CPU1.J33 CPU1.J36 CPU1.K3 CPU1.K4 CPU1.K9 CPU1.K21 CPU1.K22 CPU1.K24 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.L6 CPU1.L27 CPU1.L33 CPU1.L35 CPU1.L36 CPU1.N6 CPU1.N25 CPU1.N27 CPU1.P3 CPU1.P4 CPU1.P7 CPU1.P10 CPU1.P33 CPU1.P36 CPU1.R27 CPU1.R28 CPU1.R29 CPU1.R30 CPU1.R31 CPU1.T7 CPU1.T27 CPU1.T30 CPU1.T33 CPU1.T35 CPU1.T36 CPU1.U7 CPU1.U24 CPU1.U26 CPU1.V3 CPU1.V4 CPU1.V26 CPU1.V27 CPU1.V30 CPU1.V33 CPU1.V36 CPU1.W7 CPU1.W10 CPU1.W27 CPU1.W30 CPU1.Y7 CPU1.Y26 CPU1.Y27 CPU1.Y30 CPU1.Y33 CPU1.Y35 D4301.A D4302.1 D4303.3 D4304.A D7301.A DB1.3 DB1.15 DB1.16 DB3.4 DB3.7 DB3.8 DCIN1.9 DCIN1.10 EC1901.2 EC2201.2 EC2501.2 EC2601.2 EC2602.2 EC2701.2 EC2702.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2709.2 EC2710.2 EC2711.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC4303.2 EC4306.2 EC4307.2 EC4308.2 EC4309.2 EC4310.2 EC4401.2 EC4402.2 EC4403.2 EC4404.2 EC4405.2 EC4406.2 EC4407.2 EC4408.2 EC5503.2 EC5504.2 EC6401.2 EC6402.2 EC6501.2 EC6502.2 EC8901.2 EC8902.2 EC8903.2 EC8904.2 EC8905.2 EC8906.2 EC8907.2 EC8908.2 EC8909.2 EC8910.2 EC8911.2 EC8912.2 EC8913.2 EC8914.2 EC8915.2 EC8916.2 EC8917.2 EC8918.2 EC8919.2 EC8920.2 EC8921.2 EC8922.2 EC8923.2 EC8924.2 EC8925.2 EC8926.2 EC8927.2 EC8928.2 EC8929.2 EC8930.2 EC8931.2 EC8932.2 EC8933.2 EC8934.2 EC8937.2 EC8938.2 EC8939.2 EC8940.2 EC8941.2 EC8942.2 EC8943.2 EC8944.2 EC8945.2 EC8946.2 EC8947.2 EC8948.2 EC8949.2 EC8950.2 EC8951.2 EC8952.2 EC8953.2 EC8954.2 ED301.3 ED1701.2 ED1702.2 ED1703.2 ED1704.2 ED1706.2 ED1707.2 ED4304.1 ED4305.1 ED4306.1 ED5501.2 ED5502.3 ED5502.8 ED5503.2 ED5504.2 ED5701.3 ED5701.8 ED5702.3 ED5702.8 ED5703.3 ED5703.8 ED6701.2 ED7301.3 ED7301.8 ED7302.3 ED7302.8 ED7303.3 ED7303.8 ED7304.3 ED7304.8 ED9201.3 ED9201.8 EL4303.2 EL4304.2 FAN1.2 FAN1.5 FAN1.6 FC8901.2 FC8902.2 FC8903.2 FC8904.2 FC8905.2 FC8906.2 FC8907.2 FC8908.2 FC8909.2 FC8910.2 FC8911.2 FC8912.2 FC8913.2 FC8914.2 FC8915.2 FC8916.2 FC8917.2 FC8918.2 FC8919.2 FC8920.2 FC8921.2 FC8922.2 FC8923.2 FC8924.2 FC8925.2 FC8926.2 FC8927.2 FC8928.2 FC8929.2 FC8930.2 FC8931.2 FC8932.2 FC8933.2 FC8934.2 FC8935.2 FC8936.2 FC8937.2 FC8938.2 FC8939.2 FC8940.2 FC8941.2 FC8942.2 FC8943.2 FC8944.2 FC8945.2 FC8946.2 FC8947.2 FC8948.2 FC8949.2 FC8950.2 FC8951.2 FC8952.2 FC8953.2 FC8954.2 FC8955.2 FC8956.2 FC8957.2 FC8958.2 FC8959.2 FC8960.2 FC8961.2 FC8962.2 FC8963.2 FC8964.2 FC8965.2 FC8966.2 FC8967.2 FC8968.2 FC8969.2 FC8970.2 FC8971.2 FC8972.2 FC8973.2 FP1.5 FP1.8 FP1.9 FP1.10 FSW1.4 FSW1.5 FSW1.6 FSW1.7 G1801.1 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H5.1 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H15.1 H20.1 H22.1 HALL1.3 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HS1.1 HS2.1 IO1.6 IO1.9 IO1.12 IO1.31 IO1.32 IO1.33 IO1.34 IO2.1 IO2.7 IO2.13 IO2.19 IO2.25 IO2.31 IO2.41 IO2.42 IO2.43 IO2.44 KB1.1 KB1.31 KB1.32 KBBL1.5 KBBL1.6 LCD1.12 LCD1.13 LCD1.16 LCD1.19 LCD1.22 LCD1.23 LCD1.37 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LCD1.45 LCD1.46 LCD1.47 LCD1.48 LCD1.49 LCD1.50 LCD1.51 LCD1.52 LCD1.53 LCD1.54 LCD1.55 LCD1.56 LCD1.57 LCD1.58 LCD1.59 LCD1.60 LCD1.61 LCD1.62 LCD1.63 LCD1.64 LCD1.65 LCD1.66 LCD1.67 LCD1.68 LCD1.69 LCD1.70 LCD1.71 LCD1.72 LCD1.73 LCD1.74 LED1.3 PC44A1.2 PC44A9.2 PC44B1.2 PC44B2.2 PC44B3.2 PC44C1.2 PC44C2.2 PC44C3.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1034.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC4401.2 PC4402.2 PC4404.2 PC4405.2 PC4406.2 PC4416.2 PC4417.2 PC4419.2 PC4420.2 PC4422.2 PC4424.1 PC4429.2 PC4430.2 PC4431.2 PC4432.2 PC4433.2 PC4435.2 PC4439.2 PC4440.2 PC4441.2 PC4442.2 PC4443.2 PC4444.2 PC4449.2 PC4450.2 PC4451.1 PC4452.2 PC4461.2 PC4462.2 PC4465.2 PC4466.2 PC4501.2 PC4502.2 PC4503.2 PC4507.2 PC4508.1 PC4509.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4551.2 PC4552.2 PC4554.2 PC4555.2 PC4556.2 PC4557.2 PC4558.2 PC4559.2 PC4560.2 PC4561.2 PC4562.2 PC4564.1 PC4565.2 PC4601.2 PC4602.2 PC4603.1 PC4604.1 PC4606.2 PC4607.2 PC4610.1 PC4612.2 PC4613.2 PC4614.2 PC4615.1 PC4620.2 PC4621.1 PC4622.2 PC4624.2 PC4629.1 PC4631.2 PC4633.2 PC4637.2 PC4638.2 PC4639.2 PC4640.2 PC4641.2 PC4644.2 PC4651.2 PC4702.2 PC4703.2 PC4704.2 PC4705.2 PC4709.2 PC4710.2 PC4712.2 PC4713.2 PC4714.2 PC4715.2 PC4716.2 PC4717.2 PC4766.2 PC4777.2 PC4801.2 PC4802.2 PC4803.2 PC4804.2 PC4806.2 PC4808.2 PC4866.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5101.2 PC5102.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5108.2 PC5109.2 PC5111.2 PC5112.2 PC5113.2 PC5114.2 PC5115.2 PC5151.2 PC5153.2 PC5154.2 PC5155.2 PC5156.2 PC5201.2 PC5202.2 PC5203.2 PC5205.2 PC5206.2 PC5207.2 PC5208.2 PC5209.2 PC5210.2 PC5213.2 PC5214.2 PC5301.2 PC5302.2 PC5303.2 PC5307.2 PC8551.2 PC8552.2 PC8553.2 PC8554.2 PC8555.2 PC8557.2 PC8558.2 PC8559.2 PC8560.1 PC8561.2 PC8562.1 PC8564.2 PC8566.2 PC8568.2 PC8570.2 PC8571.2 PC8601.2 PC8607.2 PC8609.2 PC8610.2 PC8611.2 PC8612.2 PC8613.2 PC8614.2 PC8615.2 PC8616.2 PC8617.2 PC8618.2 PC8620.2 PC8621.2 PC8622.2 PC8623.2 PC8625.2 PC8626.2 PC8627.2 PC8628.2 PC8629.2 PC8630.2 PC8631.2 PD5101.A PQ44A1.1 PQ44A1.4 PQ44B1.1 PQ44B1.4 PQ4402.S PQ4405.1 PQ4405.4 PQ4415.1 PQ4415.4 PQ4416.1 PQ4416.4 PQ4417.S PQ4418.1 PQ4418.4 PQ4452.1 PQ4452.4 PR44A1.2 PR44A3.2 PR44B1.2 PR44B3.2 PR44C1.2 PR44C3.2 PR4406.2 PR4410.2 PR4413.2 PR4417.2 PR4426.2 PR4436.2 PR4438.2 PR4439.2 PR4461.2 PR4502.2 PR4508.2 PR4514.2 PR4556.2 PR4558.2 PR4608.1 PR4614.2 PR4617.2 PR4621.1 PR4627.1 PR4628.2 PR4629.2 PR4644.2 PR4654.2 PR4655.1 PR4659.1 PR4661.2 PR4685.2 PR4717.2 PR4718.2 PR4812.2 PR5106.2 PR5151.2 PR5155.2 PR5156.2 PR5203.2 PR5204.2 PR5304.2 PR8563.2 PR8564.2 PR8569.2 PR8571.2 PR8614.2 PR8620.2 PR8626.2 PR8632.2 PT4701.2 PT4703.2 PT4801.2 PT8553.2 PT8555.2 PU44A1.2 PU44B1.2 PU44C1.2 PU4401.33 PU4402.5 PU4402.6 PU4402.7 PU4403.5 PU4403.6 PU4403.7 PU4501.7 PU4501.8 PU4501.18 PU4501.21 PU4551.7 PU4551.8 PU4551.18 PU4551.21 PU4601.41 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.28 PU4701.32 PU4701.34 PU4702.12 PU4702.13 PU4702.14 PU4702.15 PU4702.28 PU4702.32 PU4702.34 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.28 PU4801.32 PU4801.34 PU5002.4 PU5002.9 PU5003.1 PU5003.2 PU5003.3 PU5101.4 PU5101.11 PU5101.12 PU5101.13 PU5101.14 PU5101.15 PU5101.16 PU5101.30 PU5101.32 PU5101.33 PU5151.1 PU5201.4 PU5201.12 PU5201.13 PU5201.14 PU5201.15 PU5201.19 PU5301.4 PU5301.8 PU5301.9 PU8551.21 PU8552.5 PU8552.6 PU8552.7 PU8553.5 PU8553.6 PU8553.7 PU8554.5 PU8554.6 PU8554.7 PU8555.5 PU8555.6 PU8555.7 PU8601.4 PU8601.8 PU8601.9 PU8602.7 PU8602.8 PU8602.18 PU8602.21 PU8603.4 PU8603.8 PU8603.9 Q401.1 Q401.4 Q501.S Q502.S Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q2408.S Q2505.S Q2510.S Q4001.S Q4302.E Q4304.E Q5508.E Q5510.E Q5703.S Q6501.S Q6701.1 Q6701.4 Q7404.1 Q7404.4 Q7405.4 Q7406.1 Q7406.4 Q7407.1 Q7407.4 Q7907.1 Q7907.4 Q8101.S Q8504.S Q8509.1 Q8509.4 Q8602.S Q8603.S Q8605.S Q8612.1 Q8612.4 Q8613.S Q8614.1 Q8614.4 Q8615.1 Q8615.4 Q8616.1 Q8616.4 Q9202.S R304.1 R305.1 R317.1 R403.1 R501.2 R502.2 R503.2 R601.1 R720.2 R808.2 R809.2 R1201.2 R1202.2 R1203.2 R1204.2 R1223.2 R1225.2 R1226.2 R1229.2 R1301.2 R1302.2 R1303.2 R1304.2 R1321.2 R1322.2 R1501.2 R1503.2 R1505.2 R1507.2 R1509.2 R1511.2 R1514.2 R1517.2 R1518.2 R1519.2 R1521.2 R1523.2 R1525.2 R1527.2 R1552.2 R1553.2 R1555.2 R1601.1 R1602.1 R1603.1 R1715.2 R1717.1 R1719.2 R1723.2 R1803.2 R1901.2 R1911.2 R2002.1 R2008.2 R2009.2 R2012.2 R2014.2 R2015.2 R2017.2 R2022.2 R2030.2 R2032.2 R2034.2 R2037.2 R2101.1 R2108.1 R2112.2 R2114.2 R2116.2 R2118.2 R2120.1 R2426.2 R2435.1 R2445.1 R2453.2 R2454.2 R2455.2 R2457.2 R2504.2 R2518.2 R2704.2 R2705.2 R2706.2 R2735.2 R3314.2 R3322.2 R3323.2 R3324.2 R3326.2 R3332.2 R3333.2 R4006.2 R4302.1 R4308.2 R4310.2 R4316.2 R4377.2 R5510.2 R5512.2 R5532.2 R5537.2 R5558.2 R5710.2 R5712.2 R5718.2 R6103.1 R6118.1 R6119.1 R6120.1 R6304.2 R6413.2 R6508.2 R6509.2 R7002.2 R7102.1 R7119.2 R7120.2 R7122.2 R7123.2 R7141.2 R7143.2 R7144.2 R7146.2 R7170.2 R7172.2 R7173.2 R7201.1 R7202.2 R7206.2 R7208.1 R7214.1 R7218.2 R7219.2 R7223.2 R7231.2 R7236.2 R7237.1 R7241.1 R7242.1 R7245.1 R7250.1 R7330.2 R7331.2 R7407.2 R7408.2 R7409.2 R7410.2 R7411.2 R7422.2 R7428.2 R7601.2 R7602.2 R7606.2 R7806.2 R7807.2 R7820.2 R7821.2 R7901.2 R7902.2 R7907.2 R7908.2 R7910.1 R7911.2 R7912.2 R7915.2 R7921.2 R7924.2 R7926.2 R7927.2 R7929.2 R7932.2 R7939.2 R8107.2 R8108.2 R8110.2 R8111.2 R8209.2 R8213.2 R8534.2 R8604.2 R9131.2 R9804.2 RAM1.B2 RAM1.B5 RAM1.B6 RAM1.B12 RAM1.C3 RAM1.C5 RAM1.C6 RAM1.D3 RAM1.D8 RAM1.D12 RAM1.E4 RAM1.E5 RAM1.E6 RAM1.F4 RAM1.F5 RAM1.F6 RAM1.F12 RAM1.G3 RAM1.G4 RAM1.G6 RAM1.G8 RAM1.G9 RAM1.H2 RAM1.H10 RAM1.J4 RAM1.J12 RAM1.K2 RAM1.K10 RAM1.L6 RAM1.L8 RAM1.L9 RAM1.M4 RAM1.M5 RAM1.M6 RAM1.M12 RAM1.N4 RAM1.N5 RAM1.N6 RAM1.P3 RAM1.P8 RAM1.P12 RAM1.R4 RAM1.R5 RAM1.R6 RAM1.T2 RAM1.T3 RAM1.T4 RAM1.T5 RAM1.T6 RAM1.T12 RAM2.B2 RAM2.B5 RAM2.B6 RAM2.B12 RAM2.C3 RAM2.C5 RAM2.C6 RAM2.D3 RAM2.D8 RAM2.D12 RAM2.E4 RAM2.E5 RAM2.E6 RAM2.F4 RAM2.F5 RAM2.F6 RAM2.F12 RAM2.G3 RAM2.G4 RAM2.G6 RAM2.G8 RAM2.G9 RAM2.H2 RAM2.H10 RAM2.J4 RAM2.J12 RAM2.K2 RAM2.K10 RAM2.L6 RAM2.L8 RAM2.L9 RAM2.M4 RAM2.M5 RAM2.M6 RAM2.M12 RAM2.N4 RAM2.N5 RAM2.N6 RAM2.P3 RAM2.P8 RAM2.P12 RAM2.R4 RAM2.R5 RAM2.R6 RAM2.T2 RAM2.T3 RAM2.T4 RAM2.T5 RAM2.T6 RAM2.T12 RAM3.B2 RAM3.B5 RAM3.B6 RAM3.B12 RAM3.C3 RAM3.C5 RAM3.C6 RAM3.D3 RAM3.D8 RAM3.D12 RAM3.E4 RAM3.E5 RAM3.E6 RAM3.F4 RAM3.F5 RAM3.F6 RAM3.F12 RAM3.G3 RAM3.G4 RAM3.G6 RAM3.G8 RAM3.G9 RAM3.H2 RAM3.H10 RAM3.J4 RAM3.J12 RAM3.K2 RAM3.K10 RAM3.L6 RAM3.L8 RAM3.L9 RAM3.M4 RAM3.M5 RAM3.M6 RAM3.M12 RAM3.N4 RAM3.N5 RAM3.N6 RAM3.P3 RAM3.P8 RAM3.P12 RAM3.R4 RAM3.R5 RAM3.R6 RAM3.T2 RAM3.T3 RAM3.T4 RAM3.T5 RAM3.T6 RAM3.T12 RAM4.B2 RAM4.B5 RAM4.B6 RAM4.B12 RAM4.C3 RAM4.C5 RAM4.C6 RAM4.D3 RAM4.D8 RAM4.D12 RAM4.E4 RAM4.E5 RAM4.E6 RAM4.F4 RAM4.F5 RAM4.F6 RAM4.F12 RAM4.G3 RAM4.G4 RAM4.G6 RAM4.G8 RAM4.G9 RAM4.H2 RAM4.H10 RAM4.J4 RAM4.J12 RAM4.K2 RAM4.K10 RAM4.L6 RAM4.L8 RAM4.L9 RAM4.M4 RAM4.M5 RAM4.M6 RAM4.M12 RAM4.N4 RAM4.N5 RAM4.N6 RAM4.P3 RAM4.P8 RAM4.P12 RAM4.R4 RAM4.R5 RAM4.R6 RAM4.T2 RAM4.T3 RAM4.T4 RAM4.T5 RAM4.T6 RAM4.T12 RN1703.1(A) RN1703.2(A) RN2009.1(A) RN2009.2(A) RN5502.1(A) RN5502.2(A) RN5502.3(A) RN5502.4(A) RN7202.3(B) RN7202.4(B) RN7203.1(A) RN7203.2(A) RN7203.3(A) RN7203.4(A) RTC1.2 RTC1.3 RTC1.4 SPK1.5 SPK1.6 SSD1.1 SSD1.3 SSD1.9 SSD1.15 SSD1.21 SSD1.27 SSD1.33 SSD1.39 SSD1.45 SSD1.51 SSD1.57 SSD1.71 SSD1.73 SSD1.75 SSD1.76 SSD1.77 TC4702.2 TC4805.2 TPAD1.5 TPAD1.9 TPAD1.10 U2401.17 U2401.51 U2401.64 U2401.84 U2401.100 U2401.124 U2502.2 U2601.5 U2701.41 U3301.33 U4001.11 U4001.15 U4002.5 U4003.5 U4006.5 U4008.3 U4302.3 U5501.2 U6402.3 U7002.5 U7002.6 U7002.7 U7002.8 U7101.41 U7201.A1 U7201.A6 U7201.A7 U7201.A8 U7201.B7 U7201.B8 U7201.D8 U7201.E5 U7201.E6 U7201.E7 U7201.E8 U7201.F5 U7201.F6 U7201.F7 U7201.F8 U7201.G5 U7201.G6 U7201.G7 U7201.G8 U7201.H4 U7201.H5 U7201.H8 U7201.L1 U7202.4 U7419.B3 U7419.C3 U7419.D3 U7419.E3 U7601.3 U8502.3 U8604.3 U8605.3 U9101.16 U9101.23 U9101.33 USB1.13 USB1.14 USB1.15 USB1.16 USB1.17 USB1.18 USB1.19 USB1.20 USB1.21 USB1.22 USB1.A1 USB1.A12 USB1.B1 USB1.B12 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM4.A1 VRAM4.A3 VRAM4.A12 VRAM4.A14 VRAM4.B5 VRAM4.B10 VRAM4.C1 VRAM4.C3 VRAM4.C4 VRAM4.C11 VRAM4.C12 VRAM4.C14 VRAM4.D10 VRAM4.E1 VRAM4.E3 VRAM4.E12 VRAM4.E14 VRAM4.F5 VRAM4.F10 VRAM4.G5 VRAM4.G10 VRAM4.H1 VRAM4.H2 VRAM4.H13 VRAM4.H14 VRAM4.K1 VRAM4.K2 VRAM4.K13 VRAM4.K14 VRAM4.L5 VRAM4.L10 VRAM4.M5 VRAM4.M10 VRAM4.N1 VRAM4.N3 VRAM4.N12 VRAM4.N14 VRAM4.P10 VRAM4.R1 VRAM4.R3 VRAM4.R4 VRAM4.R11 VRAM4.R12 VRAM4.R14 VRAM4.T5 VRAM4.T10 VRAM4.U1 VRAM4.U3 VRAM4.U12 VRAM4.U14 WLAN1.1 WLAN1.7 WLAN1.13 WLAN1.18 WLAN1.19 WLAN1.33 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 X1801.2 X1801.4 X7901.2 X7901.4
V0.85A_VID0: CPU1.CB36 TP2201.1
V0.85A_VID1: CPU1.CB35 TP2202.1
V3D3_STB: R2708.2 U2701.16
VBUS_P_CTRL: Q7404.2 U7201.D7
VBUS_P_CTRL_R: Q7404.5 Q7404.6 R7409.1 R7423.2
VCCCORE_SENSE: CPU1.AN6 PR4665.1 R719.2
VCCDSW_EN: C2525.1 D2503.2 R2520.2 U2401.88
VCCGT_SENSE: CPU1.E3 PR4695.1 R807.2
VCCPD_VBUS_ACK: PR4494.1 R7424.2 U7419.A2
VCCRTCEXT: C2201.1 CPU1.BP24
VCCSA_SENSE: CPU1.BG7 PR4693.2 R810.2
VCCST_PWRGD: PU4601.40 R1716.1 R2482.1 R4005.2 R4011.2
VCCST_PWRGD_R: C1711.1 CPU1.BJ2 ED1707.1 R1716.2 R1718.2 R1719.1
VCCSTG_EN_L1: R4039.1 U4008.4
VCCSTG_EN_R1: C4040.1 R4039.2 U4002.4 U4003.4
VCCSTU_EN_R: C4034.1 R4024.2 U4006.4
VDD: PC4422.1 PR44A4.1 PR44B5.2 PR44C6.1 PR4405.2 PR4429.1 PR4442.1 PU4401.18
VSSCORE_SENSE: CPU1.AN5 PR4666.1 R720.1
VSSGT_SENSE: CPU1.D2 PR4694.1 R808.1
VSSSA_SENSE: CPU1.BE7 PR4692.2 R809.1
0D6V_VREF_S0: C1265.1 C1266.1 C1268.1 C1269.1 C1270.1 C1271.1 C1367.1 C1368.1 C1369.1 C1370.1 C1371.1 C1372.1 PG5111.1 PG5113.1 R1205.1 R1206.1 R1207.1 R1208.1 R1214.1 R1215.1 R1216.1 R1217.1 R1218.1 R1219.1 R1220.1 R1221.1 R1246.1 R1249.1 R1252.1 R1305.1 R1306.1 R1307.1 R1308.1 R1310.1 R1311.1 R1312.1 R1313.1 R1314.1 R1315.1 R1316.1 R1317.1 R1318.1 R1319.1 R1341.1 RN1201.1(A) RN1201.2(A) RN1201.3(A) RN1201.4(A) RN1202.1(A) RN1202.2(A) RN1203.1(A) RN1203.2(A) RN1205.1(A) RN1205.2(A) RN1205.3(A) RN1205.4(A) RN1206.1(A) RN1206.2(A) RN1207.1(A) RN1207.2(A) RN1301.1(A) RN1301.2(A) RN1301.3(A) RN1301.4(A) RN1302.1(A) RN1302.2(A) RN1303.1(A) RN1303.2(A) RN1304.1(A) RN1304.2(A) RN1306.1(A) RN1306.2(A) RN1307.1(A) RN1307.2(A) RN1308.1(A) RN1308.2(A)
1D0V_S5: C1112.1 C1114.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1128.1 C1129.1 C2212.1 C2214.1 C2215.1 C2216.1 C2217.1 C2223.1 C4008.1 C4013.1 CPU1.BP14 CPU1.BP20 CPU1.BP22 CPU1.BR12 CPU1.BR14 CPU1.BR15 CPU1.BR20 CPU1.BT12 CPU1.BT18 CPU1.BT19 CPU1.BT22 CPU1.BU12 CPU1.BU14 CPU1.BU15 CPU1.BU18 CPU1.BU19 CPU1.BU22 CPU1.BV15 CPU1.BV16 CPU1.BV18 CPU1.BV19 CPU1.BV20 CPU1.BV22 CPU1.BW16 CPU1.BW18 CPU1.BW19 CPU1.BW20 CPU1.BW22 CPU1.BY16 CPU1.BY20 CPU1.CA12 CPU1.CA14 CPU1.CA16 CPU1.CA18 CPU1.CA19 CPU1.CA20 CPU1.CB12 CPU1.CB14 CPU1.CB15 CPU1.CC12 EC2201.1 FC8921.1 FC8958.1 PC5201.1 PC5203.1 PC5205.1 PC5206.1 PC5207.1 PG5210.1 PL5201.2 R2202.1 R2203.1 R2205.1 R2402.1 U4003.1 U4003.2 U4003.9 U4006.1 U4006.2 U4006.9
1D0V_VCCA_XTAL: C2219.1 CPU1.CP5 R2202.2
1D0V_VCCAMPHYPLL: C2208.1 C2209.1 CPU1.BV2 R2205.2
1D0V_VCCDSW: C2213.1 CPU1.BT24
1D0V_VCCPRIM_MPHY: C2220.1 CPU1.BV12 CPU1.BV14 CPU1.BW12 CPU1.BW14 CPU1.BY12 CPU1.BY14 R2203.2
1D2V_S3: C804.1 C1130.1 C1131.1 C1132.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1209.1 C1210.1 C1211.1 C1218.1 C1219.1 C1220.1 C1221.1 C1226.1 C1227.1 C1231.1 C1242.1 C1244.1 C1245.1 C1247.1 C1248.1 C1249.1 C1256.1 C1257.1 C1258.1 C1259.1 C1260.1 C1261.1 C1262.1 C1263.1 C1275.1 C1310.1 C1311.1 C1312.1 C1313.1 C1322.1 C1323.1 C1324.1 C1325.1 C1326.1 C1331.1 C1332.1 C1333.1 C1334.1 C1341.1 C1342.1 C1343.1 C1344.1 C1350.1 C1351.1 C1352.1 C1353.1 C1354.1 C1355.1 C4006.1 C4035.1 CPU1.AD36 CPU1.AH32 CPU1.AH36 CPU1.AM36 CPU1.AN32 CPU1.AW32 CPU1.AY36 CPU1.BE32 CPU1.BH36 CPU1.R32 CPU1.Y36 EC8930.1 EC8931.1 EC8932.1 EC8933.1 EC8934.1 EC8939.1 EC8940.1 EC8941.1 EC8942.1 FC8934.1 FC8935.1 FC8936.1 FC8937.1 FC8938.1 FC8969.1 FC8970.1 FC8971.1 FC8972.1 FC8973.1 PG5105.2 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5110.2 PG5112.2 PG5114.2 PG5115.1 PG5116.1 R1222.1 R1227.1 R1320.1 RAM1.A8 RAM1.A9 RAM1.A11 RAM1.C12 RAM1.D4 RAM1.D5 RAM1.D6 RAM1.E8 RAM1.E12 RAM1.F2 RAM1.G2 RAM1.G5 RAM1.G12 RAM1.H3 RAM1.H5 RAM1.H6 RAM1.H8 RAM1.H9 RAM1.H11 RAM1.H12 RAM1.J5 RAM1.J6 RAM1.J9 RAM1.J10 RAM1.K5 RAM1.K6 RAM1.K8 RAM1.K11 RAM1.K12 RAM1.L2 RAM1.L5 RAM1.L12 RAM1.M2 RAM1.N8 RAM1.N12 RAM1.P4 RAM1.P5 RAM1.P6 RAM1.R12 RAM1.U8 RAM1.U9 RAM1.U11 RAM2.A8 RAM2.A9 RAM2.A11 RAM2.C12 RAM2.D4 RAM2.D5 RAM2.D6 RAM2.E8 RAM2.E12 RAM2.F2 RAM2.G2 RAM2.G5 RAM2.G12 RAM2.H3 RAM2.H5 RAM2.H6 RAM2.H8 RAM2.H9 RAM2.H11 RAM2.H12 RAM2.J5 RAM2.J6 RAM2.J9 RAM2.J10 RAM2.K5 RAM2.K6 RAM2.K8 RAM2.K11 RAM2.K12 RAM2.L2 RAM2.L5 RAM2.L12 RAM2.M2 RAM2.N8 RAM2.N12 RAM2.P4 RAM2.P5 RAM2.P6 RAM2.R12 RAM2.U8 RAM2.U9 RAM2.U11 RAM3.A8 RAM3.A9 RAM3.A11 RAM3.C12 RAM3.D4 RAM3.D5 RAM3.D6 RAM3.E8 RAM3.E12 RAM3.F2 RAM3.G2 RAM3.G5 RAM3.G12 RAM3.H3 RAM3.H5 RAM3.H6 RAM3.H8 RAM3.H9 RAM3.H11 RAM3.H12 RAM3.J5 RAM3.J6 RAM3.J9 RAM3.J10 RAM3.K5 RAM3.K6 RAM3.K8 RAM3.K11 RAM3.K12 RAM3.L2 RAM3.L5 RAM3.L12 RAM3.M2 RAM3.N8 RAM3.N12 RAM3.P4 RAM3.P5 RAM3.P6 RAM3.R12 RAM3.U8 RAM3.U9 RAM3.U11 RAM4.A8 RAM4.A9 RAM4.A11 RAM4.C12 RAM4.D4 RAM4.D5 RAM4.D6 RAM4.E8 RAM4.E12 RAM4.F2 RAM4.G2 RAM4.G5 RAM4.G12 RAM4.H3 RAM4.H5 RAM4.H6 RAM4.H8 RAM4.H9 RAM4.H11 RAM4.H12 RAM4.J5 RAM4.J6 RAM4.J9 RAM4.J10 RAM4.K5 RAM4.K6 RAM4.K8 RAM4.K11 RAM4.K12 RAM4.L2 RAM4.L5 RAM4.L12 RAM4.M2 RAM4.N8 RAM4.N12 RAM4.P4 RAM4.P5 RAM4.P6 RAM4.R12 RAM4.U8 RAM4.U9 RAM4.U11 U4002.1 U4002.2 U4002.9
1D2V_VCCSFR_OC: C803.2 C4007.1 CPU1.BL27 CPU1.BM26 U4002.6 U4002.7 U4002.8
1D8V_AON_S0: C8004.1 C8035.1 C8036.1 C8044.1 C8601.1 C8604.1 GPU1.G10 GPU1.G12 PG8603.1 PG8604.1 PR8650.1 Q7906.G Q8601.G Q8611.S R7603.1 R7701.1 R7905.1 R7909.1 R7914.1 R7917.1 R7918.1 R7919.1 R7920.1 R7925.1 R7928.1 R7933.1 R7935.1 R7938.1 R7949.1 R8625.1 R8637.1 RN7901.1(A) RN7901.2(A) RN7904.3(B) RN7904.4(B) RN7905.3(B) RN7905.4(B) RN7910.1(A) RN7910.2(A) U7601.5
1D8V_AON_S0_DISCHG: Q8614.3 R8625.2
1D8V_CPVDD: C2704.1 C2705.1 R2709.2 U2701.29
1D8V_EN#: Q4001.D R4034.2 R4035.1
1D8V_EN_R#: C4038.2 Q4002.G R4035.2
1D8V_FBA_PLL_AVDD: C7805.1 C7808.1 C7818.1 C7827.1 GPU1.F16 GPU1.H22 GPU1.P22 L7801.1
1D8V_S0: C4039.1 Q4002.D R2709.1 R2719.1 R6406.1
1D8V_S3: C1201.1 C1252.1 C1253.1 C1276.1 C1277.1 C1278.1 C1279.1 C1304.1 C1317.1 C1338.1 C1348.1 C1349.1 C1356.1 PG5152.1 RAM1.A3 RAM1.A4 RAM1.A5 RAM1.A6 RAM1.A10 RAM1.U3 RAM1.U4 RAM1.U5 RAM1.U6 RAM1.U10 RAM2.A3 RAM2.A4 RAM2.A5 RAM2.A6 RAM2.A10 RAM2.U3 RAM2.U4 RAM2.U5 RAM2.U6 RAM2.U10 RAM3.A3 RAM3.A4 RAM3.A5 RAM3.A6 RAM3.A10 RAM3.U3 RAM3.U4 RAM3.U5 RAM3.U6 RAM3.U10 RAM4.A3 RAM4.A4 RAM4.A5 RAM4.A6 RAM4.A10 RAM4.U3 RAM4.U4 RAM4.U5 RAM4.U6 RAM4.U10
1D8V_S5: C4037.1 C4038.1 C6401.1 PR5307.2 Q4002.S R1104.1 R1515.1 R2011.1 R2013.1 R2016.1 R2018.1 R2029.1 R2031.1 R2033.1 R2401.1 R2456.1 R4034.1 R6121.1 R6122.1 R6123.1 U6402.5
1D8V_S5_KBC: C2423.1 R2401.2 U2401.54
1D8V_VCCPRIM: C1122.1 C2210.1 C2211.1 CPU1.CC15 CPU1.CC18 CPU1.CC19 CPU1.CD15 CPU1.CD16 CPU1.CD18 CPU1.CD19 CPU1.CP17 CPU1.CP23 R1104.2 R1512.1 R1738.1 R1821.1 R2111.1 R2113.1 R2115.1 R2117.1
1D8V_VGA_EN: PC8612.1 Q8613.G R8621.2
1D8V_VGA_EN#: PR8650.2 Q8613.D R8620.1
1D8V_VGA_EN_OR: Q8602.D R8621.1 R8637.2
1D8V_VGA_EN_OR#: Q8602.G Q8603.G Q8612.3 Q8612.6 R8634.2
1D8V_VGA_EN_R: PC8607.1 PR8621.2 PU8601.7
1D8V_VGA_EN_R#: C8601.2 Q8611.G R8620.2
1D8V_VGA_PLL: C7902.1 C7905.1 C7906.1 C7934.1 C7935.1 C8037.1 GPU1.F11 GPU1.L6 GPU1.M6 GPU1.N6 L7901.2
1D8V_VGA_S0: C7614.1 C7616.1 C7620.1 C7621.1 C7622.1 C7627.1 C7628.1 C7629.1 C7630.1 C7631.1 C8003.1 C8028.1 C8029.1 C8034.1 C8602.1 GPU1.AA8 GPU1.AA9 GPU1.AA10 GPU1.AA12 GPU1.AA13 GPU1.AA16 GPU1.AA18 GPU1.AA19 GPU1.AA20 GPU1.AA21 GPU1.AB22 GPU1.AC23 GPU1.AD24 GPU1.AE25 GPU1.AF26 GPU1.AF27 GPU1.G8 GPU1.G9 L7801.2 L7901.1 Q7601.G Q8611.D R7957.1 R8529.1 R8623.1
1D8V_VGA_S0_DISCHG: Q8603.D R8623.2
1D8V_VGA_S0_PG: PR8624.2 PU8601.2
1D24V_VCCDPHY: CPU1.BY23 CPU1.BY24 CPU1.CA23 CPU1.CA24
1D24V_VCCDPHY_EC: C2218.1 CPU1.CP25
1D35V_PGOOD: PR8630.1 R8530.1
1D35V_PGOOD_L: R8530.2 U8502.2
1D35V_PWR: PC8611.1 PC8613.1 PC8614.1 PC8620.1 PC8621.1 PG8609.1 PG8610.1 PG8611.1 PG8612.1 PG8613.1 PG8618.1 PG8619.1 PG8620.1 PG8621.1 PL8603.2
1D35V_VGA_EN: D8601.3 PR8631.1 Q8616.2 R8604.1
1D35V_VGA_EN#: Q8616.5 Q8616.6 R8616.2
1D35V_VGA_S0: C7807.1 C7810.1 C7811.1 C7812.1 C7815.1 C7816.1 C7817.1 C7819.1 C7820.1 C7821.1 C7822.1 C7823.1 C7825.1 C7826.1 C8104.1 C8105.1 C8106.1 C8107.1 C8108.1 C8109.1 C8110.1 C8111.1 C8112.1 C8113.1 C8114.1 C8115.1 C8116.1 C8117.1 C8118.1 C8119.1 C8120.1 C8121.1 C8122.1 C8123.1 C8124.1 C8125.1 C8204.1 C8205.1 C8206.1 C8207.1 C8209.1 C8210.1 C8211.1 C8212.1 C8213.1 C8214.1 C8215.1 C8216.1 C8217.1 C8218.1 C8219.1 C8220.1 C8221.1 C8222.1 C8223.1 C8224.1 C8225.1 C8226.1 FC8917.1 FC8918.1 FC8919.1 FC8920.1 FC8954.1 FC8955.1 FC8956.1 FC8957.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PG8609.2 PG8610.2 PG8611.2 PG8612.2 PG8618.2 PG8619.2 PG8620.2 PG8621.2 R7805.1 R7808.2 R7809.2 R7816.1 R7824.1 R8106.1 R8210.1 R8622.1 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM4.B1 VRAM4.B3 VRAM4.B12 VRAM4.B14 VRAM4.C5 VRAM4.C10 VRAM4.D1 VRAM4.D3 VRAM4.D11 VRAM4.D12 VRAM4.D14 VRAM4.E5 VRAM4.E10 VRAM4.F1 VRAM4.F3 VRAM4.F12 VRAM4.F14 VRAM4.G1 VRAM4.G2 VRAM4.G4 VRAM4.G11 VRAM4.G13 VRAM4.G14 VRAM4.H3 VRAM4.H12 VRAM4.K3 VRAM4.K12 VRAM4.L1 VRAM4.L2 VRAM4.L4 VRAM4.L11 VRAM4.L13 VRAM4.L14 VRAM4.M1 VRAM4.M3 VRAM4.M12 VRAM4.M14 VRAM4.N5 VRAM4.N10 VRAM4.P1 VRAM4.P3 VRAM4.P11 VRAM4.P12 VRAM4.P14 VRAM4.R5 VRAM4.R10 VRAM4.T1 VRAM4.T3 VRAM4.T12 VRAM4.T14
1D35V_VGA_S0_DISCHG: Q8616.3 R8622.2
2ND_M2_SSD_PEDET#: CPU1.CM10 R1605.1
3D3V_AUX_S5: PG4532.1 PR4505.1 R1726.1 R1727.1 R1737.1 R2463.1 R2505.1 R6702.1 R6743.1 R6744.1 R7952.1 R8612.1 R8613.2 R8616.1
3D3V_CAMERA_S0: C5503.1 LCD1.33 R5501.2
3D3V_CARD: C3303.1 C3312.1 CARD1.4 U3301.10
3D3V_CARD_S5: C3302.1 C3309.1 R3301.2 U3301.11 U3301.26
3D3V_ECVBAT: C2428.1 R2451.1 R2473.2 R2497.1 U2401.122
3D3V_FLASH: C7211.1 C7244.1 R7204.1 R7222.1 R7225.2 R7226.2 R7228.2 R7230.2 U7201.G1 U7202.8
3D3V_FPR_VDD: C9201.1 FP1.1 R9201.1 R9213.2
3D3V_GSEN2: C7005.1 C7006.1 R7001.2 R7008.1 R7016.2 U7002.9 U7002.10
3D3V_HINGE_S0: F5502.2 R5501.1 R5508.1 R5511.1
3D3V_LCDVDD_R: C5505.1 R5546.1 R6620.2 U5501.1
3D3V_LCDVDD_R_SEN: CN1.6 R6620.1
3D3V_LCDVDD_S0: C5507.1 C5508.1 C5554.1 D5505.A LCD1.5 LCD1.6 R5546.2 R6621.2
3D3V_LCDVDD_S0_R: CN1.8 R6621.1
3D3V_MIC_VCC: C5515.1 LCD1.32 R5511.2
3D3V_MUX: C7115.1 C7116.1 C7117.1 C7118.1 C7119.1 R7101.1 R7118.1 R7121.1 R7124.2 R7140.1 R7142.1 R7145.1 R7147.1 R7152.1 R7171.1 R7174.1 U7101.1 U7101.6 U7101.20 U7101.28
3D3V_RTC: C2503.1 D2501.3 Q2507.S R2473.1 R2708.1
3D3V_RTC_SYS: D2501.1 R2505.2
3D3V_S0: C2601.1 C2602.1 C4005.1 CN1.12 DB1.10 EC8943.1 EC8944.1 EC8945.1 EC8946.1 EC8947.1 EC8948.1 F5502.1 FC8932.1 PG8601.1 PG8602.1 PG8605.1 PG8606.1 PR4609.1 PR8611.1 PR8624.1 PR8625.1 PR8634.1 Q2414.G Q2601.2 Q2601.5 Q5701.C Q5702.2 Q5702.5 R402.1 R507.1 R1606.1 R1608.1 R1718.1 R1820.1 R2010.1 R2035.1 R2038.1 R2043.1 R2044.1 R2045.1 R2046.1 R2048.1 R2049.1 R2053.1 R2110.1 R2430.1 R2449.1 R2489.1 R2603.1 R2715.1 R2716.1 R4005.1 R4041.1 R5504.1 R5517.1 R5518.1 R5540.1 R6302.1 R6405.1 R6502.1 R6612.1 R7001.1 R7948.1 R7953.1 R8541.1 R8634.1 R8635.1 R9102.1 RN401.1(A) RN401.2(A) RN403.1(A) RN403.2(A) RN1813.1(A) RN1813.2(A) RN1813.3(A) RN1813.4(A) RN2007.3(B) RN2007.4(B) RN2602.1(A) RN2602.2(A) U2601.1 U4001.13 U4001.14 U8502.5 U8604.5 U8605.5
3D3V_S0_SSD_SEN: CN1.5 R6612.2
3D3V_S5: AFTP6607.1 C2416.1 C2421.1 C5502.1 C7208.1 C9106.1 C9108.1 D4302.2 EC8921.1 EC8922.1 EC8923.1 EC8924.1 EC8925.1 EC8926.1 FC8929.1 FC8930.1 FC8931.1 FC8966.1 FC8967.1 IO1.4 IO2.35 IO2.36 IO2.37 IO2.38 IO2.39 IO2.40 PC4509.1 PC4510.1 PC4511.1 PC4512.1 PC4513.1 PC5155.1 PG4530.2 PG5302.2 PG5303.2 PL4501.2 PR4435.1 PR4443.1 PR4460.1 PR4462.1 PR4472.1 PR5104.1 PR5152.1 PR5208.1 PR5306.1 PR8557.1 PU5151.5 PU5151.9 Q2416.2 Q2416.5 Q9201.S R506.1 R1721.1 R1910.1 R2408.1 R2434.1 R2442.1 R2446.1 R2514.1 R2520.1 R2604.1 R3301.1 R3325.1 R3331.1 R4304.1 R4378.1 R5535.1 R6114.1 R6404.1 R6742.1 R6745.1 R7124.1 R7215.1 R7224.1 R7243.1 R7247.1 R7424.1 R7427.1 R9101.1 R9212.1 RN2405.1(A) RN2405.2(A) RN2405.3(A) RN2405.4(A) RN7206.1(A) RN7206.2(A) U2502.5 U4001.1 U4001.2 U4008.5 U4302.2 U5501.5 U7201.B1 U7201.H1 U9101.1
3D3V_S5_KBC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2415.1 C2422.1 C2429.1 DB3.1 ED4304.2 ED4305.2 ED4306.2 R2403.1 R2404.1 R2414.1 R2415.1 R2443.1 R2446.2 R2452.1 R2460.1 R2480.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2411.3(A) RN2411.4(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2413.1(A) RN2413.2(A) U2401.5 U2401.19 U2401.22 U2401.43 U2401.65 U2401.82 U2401.103 U2401.115
3D3V_S5_PCH: BIOS1.8 C2501.1 C2502.1 R303.1 R1103.1 R1502.1 R1504.1 R1506.1 R1508.1 R1510.1 R1513.1 R1522.1 R1551.1 R1554.1 R1837.1 R2041.1 R2042.1 R2516.2 R2519.1 R9148.1 R9805.1 RN405.1(A) RN405.2(A) RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_SSD: AFTP6304.1 C6304.1 C6305.1 C6306.1 C6307.1 C6308.1 C6317.1 C6318.1 R6302.2 R6303.1 R6305.1 R6613.1 SSD1.2 SSD1.4 SSD1.12 SSD1.14 SSD1.16 SSD1.18 SSD1.70 SSD1.72 SSD1.74
3D3V_SSD_R: CN1.7 R6613.2
3D3V_TBT: C7210.1 U7201.H2
3D3V_TP_VDD: AFTP6531.1 C6505.1 R6502.2 R6511.1 RN6501.1(A) RN6501.2(A) RN6503.1(A) RN6503.2(A) TPAD1.8
3D3V_TPAN_VDD: C5516.1 C5517.1 C5518.1 LCD1.30 LCD1.31 R5508.2
3D3V_TPM: C9104.1 C9109.1 C9112.1 C9113.1 R9101.2 R9102.2 R9151.1 U9101.8 U9101.22
3D3V_VCCDSW: C2224.1 CPU1.BR24 CPU1.BT23 R1520.1 R1524.1 R1707.1 R1722.1 R1819.1 R2516.1 RN1704.1(A) RN1704.2(A) U2502.1
3D3V_VCCPRIM: C1113.1 C1123.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 CPU1.BP23 CPU1.BT20 CPU1.BV23 CPU1.BW23 CPU1.CB16 CPU1.CB22 CPU1.CB23 CPU1.CC22 CPU1.CC23 CPU1.CD22 CPU1.CD23 CPU1.CP29 R1103.2 R1701.1 R1731.1
3D3V_VCCPRTC: C2221.1 C2222.1 CPU1.BR23 R2204.2
3D3V_WLAN: AFTP6113.1 C6104.1 C6105.1 C6106.1 C6109.1 C6110.1 C6111.1 R6113.1 R6114.2 R6115.1 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
27MHZ_IN: C7907.1 GPU1.C11 R7903.1 X7901.1
27MHZ_OUT: GPU1.B10 R7903.2 R7904.1
65982D_BUSPWR: R7204.2 R7236.1 U7201.F10
65982D_DBG_CTL1: RN7202.2(A) U7201.E4
65982D_DBG_CTL2: RN7202.1(A) U7201.D5
65982D_DEBUG1: R7220.2 U7201.L2
65982D_DEBUG2: R7221.2 U7201.K2
65982D_DIG_AUD_N: R7241.2 U7201.K3
65982D_DIG_AUD_P: R7242.2 U7201.L3
65982D_GND: C7212.1 U7201.H7
65982D_GPIO1: R7245.2 U7201.C2
65982D_GPIO2: R7231.1 R7247.2 U7201.D10
65982D_GPIO3: R7208.2 U7201.G11
65982D_GPIO8: R7222.2 R7223.1 U7201.H6
65982D_HPD_CON: R7227.2 U7201.C10
65982D_HRESET: R7202.1 U7201.D6
65982D_I2C_ADDR: R7201.2 U7201.F1
65982D_LDO_1V8A: C7203.2 U7201.K1
65982D_LDO_1V8D: C7202.2 U7201.A2
65982D_LDO_BMC: C7201.2 U7201.E1
65982D_LSRX: TP7202.1 U7201.K4
65982D_LSTX: R7237.2 U7201.L4
65982D_MRESET: R7214.2 U7201.E11
65982D_RESET_N: R7229.1 U7201.F11
65982D_ROSC: R7206.1 U7201.G2
65982D_SBU1_R: TP7203.1 U7201.K8
65982D_SBU2_R: TP7204.1 U7201.L8
65982D_UART_RX: RN7203.6(B) U7201.E2 U7201.F2
+3D3V_VDD_+SDC_IN: PC44C2.1 PR44B4.1 PR44C2.1 PR44C5.1 PU44C1.5
+DC_IN_C: AFTP4303.1 AFTP4305.1 AFTP4316.1 D4301.K DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC4312.1 EL4301.1 EL4302.1
+RTC_VCC: AFTP2508.1 D2501.2 Q2505.G R2504.1 R2510.1
+V_VREF_PATH1: C1250.2 R1225.1
+V_VREF_PATH2: C1339.2 R1322.1
+V_VREF_PATH3: C1251.2 R1229.1
AC_DIS: PR4440.1 Q4304.B R4310.1 U2401.69
AC_DIS_R: PQ4452.5 PR4440.2 PR4441.2
AC_IN#: D1701.K PR4491.1
AC_IN#_G: R4376.2 R4377.1 U4302.5
AC_PRESENT: CPU1.BU35 D1701.A Q1702.6 RN1704.4(B)
ACAV_IN: PG4408.1 PQ4415.2 PR44B6.1 PR4441.1 PR4490.2
ACOK#: PQ4415.5 PQ4415.6 PR4442.2
AD_IA: PC4432.1 PR2455.1 PR4492.2 R2421.2 R2423.1
AD_OFF_L: Q4304.C Q4305.B
AD_OFF_R: C4301.2 PU4301.4 Q4305.C R4307.2 R4308.1
ALERT#: R2603.2 U2601.6
ALWON: R4009.2 U2401.121
AMBER_LED_BAT: EC6402.1 Q6402.C R6401.1
AUD_AGND: C2702.1 C2703.2 C2706.2 C2707.2 C2710.2 C2711.1 C2715.2 C2909.2 EC2701.1 EC2702.1 EC2703.1 EC2704.1 EC2705.1 IO1.18 IO1.30 R2702.2 R2704.1 R2705.1 R2706.1 U2701.19 U2701.31
AUD_HP1_JACK_L: C2907.2 IO1.25 RN2902.4(B) U2701.25
AUD_HP1_JACK_R: C2908.2 IO1.23 RN2902.3(B) U2701.26
AUD_HPJD_N: R2710.2 R2711.2 U2701.12
AUD_PC_BEEP: C2735.2 U2701.11
AUD_PC_BEEP_C: C2735.1 C2739.1 D2703.3 R2735.1
AUD_RING: IO1.19 IO1.20 IO1.21 IO1.22 RN2901.3(B) U2701.13
AUD_SENSE: C2909.1 IO1.24 R2711.1
AUD_SLEEVE: IO1.26 IO1.27 IO1.28 IO1.29 RN2901.4(B) U2701.14
AUD_SPK_L+: ER2903.1 U2701.35
AUD_SPK_L+_C: AFTP2902.1 EC2901.1 ER2903.2 SPK1.3
AUD_SPK_L-: ER2904.1 U2701.36
AUD_SPK_L-_C: AFTP2901.1 EC2902.1 ER2904.2 SPK1.4
AUD_SPK_R+: ER2901.1 U2701.38
AUD_SPK_R+_C: AFTP2904.1 EC2904.1 ER2901.2 SPK1.1
AUD_SPK_R-: ER2902.1 U2701.37
AUD_SPK_R-_C: AFTP2903.1 EC2903.1 ER2902.2 SPK1.2
AUD_VREF: C2702.2 U2701.22
AUX_EN_WOWL: CPU1.BT30 TP1715.1
BAT1_LED#: Q2416.4 RN2405.6(B) U2401.106
BAT2_LED#: Q2416.1 RN2405.5(B) U2401.1
BAT_AMBER: LED1.1 R6401.2
BAT_WHITE: LED1.2 R6402.2
BATT_WHITE_LED#: Q2416.6 Q6403.D Q6404.4 R6422.2
BATT_WHITE_LED_R#: Q6401.B Q6404.3 R6422.1
BEEP: R2734.1 U2401.45
BKLT_CTRL: D5502.3 R5502.1 RN5502.5(B) RN5505.4(B)
BKLT_IN_EC: R2440.1 U2401.67
BL_PWR_MONITOR: Q5508.B R5534.2
BL_PWR_MONITOR_BJT_B: Q5512.B R5533.2
BL_PWR_MONITOR_BJT_C: Q5512.C R5534.1
BL_PWR_MONITOR_R: C5557.1 D5504.K R5532.1 R5533.1
BLON_OUT_C: LCD1.8 RN5501.2(A) RN5502.6(B)
BLUETOOTH_EN: AFTP6112.1 CPU1.CP14 R6110.1
BLUETOOTH_EN_R: R6110.2 R6115.2 WLAN1.54
BOARD_ID: C2408.1 R2443.2 R2444.1 U2401.111
BOARD_ID1: CPU1.CG12 R2009.1 R2010.2
BOARD_ID2: CPU1.CM14 R2008.1
BPM_CPU_N2: CPU1.U3 TP302.1
BPM_CPU_N3: CPU1.U4 TP303.1
BPM_N0: CPU1.U1 TP307.1
BPM_N1: CPU1.U2 TP308.1
BT+: AFTP4312.1 AFTP4313.1 AFTP4314.1 BATT1.1 BATT1.2 BATT1.3 BATT1.4 D4304.K EC4307.1 EC4308.1 PR4483.2 PU4412.5 PU4412.6 PU4412.7 PU4412.8
BT_PCMFRM_RSTN: R1913.1 R6120.2 WLAN1.10
BT_PCMOUT_CLKREQ0: R1912.1 R6119.2 WLAN1.14
BT_USB20_CON_N: AFTP6111.1 R6104.1 WLAN1.5
BT_USB20_CON_P: AFTP6114.1 R6105.1 WLAN1.3
BT_USB20_N: CPU1.CC3 R6104.2
BT_USB20_P: CPU1.CC4 R6105.2
C_SD_CLK: R3309.1 U3301.19
C_SD_CMD: R3308.1 U3301.21
C_SD_D0: R3310.1 U3301.18
C_SD_D1: R3311.1 U3301.17
C_SD_D2: R3306.1 U3301.23
C_SD_D3: R3307.1 U3301.22
C_SD_WP: R3333.1 U3301.25
CA_VREF: C1214.1 C1229.1 C1314.1 C1329.1 R1226.1 R1227.2 R1228.1 RAM1.H4 RAM2.H4 RAM3.H4 RAM4.H4
CAD_SNK: R7118.2 U7101.29
CAP_LED: AFTP6538.1 KB1.4 R6513.2
CAP_LED#: Q2414.S R2489.2 U2401.93
CAP_LED#_R: Q2414.D Q6505.B
CAP_LED_Q: Q6505.C R6513.1
CARD_CD_N: CARD1.12 U3301.24
CARD_CLK: C3301.1 CARD1.5 R3309.2
CARD_CMD: CARD1.3 R3308.2
CARD_SDATA0: CARD1.7 R3310.2
CARD_SDATA1: CARD1.8 R3311.2
CARD_SDATA2: CARD1.1 R3306.2
CARD_SDATA3: CARD1.2 R3307.2
CBN: C2708.2 U2701.28
CBP: C2708.1 U2701.30
CCD_USB20_CON_N: ED5501.6 EL5501.2 LCD1.35
CCD_USB20_CON_P: ED5501.3 EL5501.3 LCD1.34
CCD_USB20_N: CPU1.CC1 EL5501.1
CCD_USB20_P: CPU1.CC2 EL5501.4
CD_WP_REV#: R3324.1 U3301.12
CFG3: CPU1.R3 R1517.1
CFG4: CPU1.J4 R1518.1
CFG_RCOMP: CPU1.AB5 R601.2
CHG_AMBER_LED#: Q2416.3 Q6404.1 Q6407.E R6421.1 R6426.2
CHG_AMBER_LED_R#: Q6402.B Q6404.6 R6421.2
CLK_ITE8010: IO2.4 R6602.2
CLK_PCIE_PEG_REQ#: CPU1.CF32 Q7601.D RN1813.5(B)
CLK_TP_SIO: R2407.1 R2408.2 U2401.78
CLK_TP_SIO_I2C_DAT: EC6502.1 RN6501.3(B) RN6502.2(A) U2401.96
CLKIN_XTAL_LCP: R6118.2 R6124.2 WLAN1.64
CLKIN_XTAL_LCP_R: CPU1.CM3 R6124.1
CNV_BRI_DT: CPU1.CJ20 R6111.1 R6123.2
CNV_BRI_DT_R: R6111.2 WLAN1.36
CNV_BRI_RSP: CPU1.CK20 R6102.1 R6121.2
CNV_BRI_RSP_R: R6102.2 WLAN1.22
CNV_COEX3: IO2.10 R6109.1
CNV_MFUART2_RXD: IO2.12 R6107.1
CNV_MFUART2_TXD: IO2.14 R6108.1
CNV_RGI_DT: CPU1.CG19 R1515.2 R6112.1
CNV_RGI_DT_R: R6112.2 WLAN1.32
CNV_RGI_RSP: CPU1.CH19 R6101.1 R6122.2
CNV_RGI_RSP_R: R6101.2 WLAN1.34
CNV_WR_CLK_DN: CPU1.CN31 WLAN1.21
CNV_WR_CLK_DP: CPU1.CP31 WLAN1.23
CNV_WR_DN0: CPU1.CR30 WLAN1.15
CNV_WR_DN1: CPU1.CM30 WLAN1.9
CNV_WR_DP0: CPU1.CP30 WLAN1.17
CNV_WR_DP1: CPU1.CN30 WLAN1.11
CNV_WT_CLK_DN: CPU1.CP34 WLAN1.71
CNV_WT_CLK_DP: CPU1.CN34 WLAN1.73
CNV_WT_DN0: CPU1.CN32 WLAN1.65
CNV_WT_DN1: CPU1.CP33 WLAN1.59
CNV_WT_DP0: CPU1.CM32 WLAN1.67
CNV_WT_DP1: CPU1.CN33 WLAN1.61
CNV_WT_RCOMP: CPU1.CP32 CPU1.CR32 R2101.2
CPU_DP1_CTRL_CLK: CPU1.CC8 Q5702.1 RN401.3(B)
CPU_DP1_CTRL_DATA: CPU1.CC9 Q5702.4 RN401.4(B)
CPU_DP2_CTRL_CLK: CPU1.CH4 RN403.3(B)
CPU_DP2_CTRL_DATA: CPU1.CH3 RN403.4(B)
CPU_DP_HPD_P: Q401.2 Q401.3 RN405.3(B)
CPU_I2C_SCL_ISH0: CPU1.CH20 RN2007.2(A) U7002.1
CPU_I2C_SCL_P0: CN1.9 CPU1.CN11 Q6504.1 R6505.1
CPU_I2C_SCL_P1: CPU1.CJ12 ED5504.1 R5517.2 R5521.2
CPU_I2C_SCL_TP: AFTP6534.1 Q6504.6 R6505.2 RN6502.4(B) RN6503.3(B) TPAD1.6
CPU_I2C_SCL_TS: LCD1.29 R5521.1
CPU_I2C_SDA_ISH0: CPU1.CK22 RN2007.1(A) U7002.4
CPU_I2C_SDA_P0: CN1.10 CPU1.CM11 Q6504.4 R6506.1
CPU_I2C_SDA_P1: CPU1.CK12 ED5503.1 R5518.2 R5522.2
CPU_I2C_SDA_TP: AFTP6535.1 Q6504.3 R6506.2 RN6502.3(B) RN6503.4(B) TPAD1.7
CPU_I2C_SDA_TS: LCD1.28 R5522.1
CPU_POPIRCOMP: CPU1.BP27 R304.2
CPU_SMB_ALERT#: CPU1.CJ15 R1551.2 R1552.1
CPU_SMB_ALERT#_P0: CPU1.CG15 R1504.2 R1505.1 R1806.1
CPU_SMB_ALERT#_P1: CPU1.CC34 R1555.1 R1837.2
CPU_SMB_SCL: CPU1.CK14 RN1807.7(B)
CPU_SMB_SCL_P0: CPU1.CH14 RN1807.5(B)
CPU_SMB_SCL_P1: CPU1.CN15 Q2601.3 Q7901.3 R2406.2 RN1811.4(B)
CPU_SMB_SCL_THM: C2608.1 Q2601.4 RN2602.3(B) U2601.8
CPU_SMB_SDA: CPU1.CH15 RN1807.8(B)
CPU_SMB_SDA_P0: CPU1.CF15 RN1807.6(B)
CPU_SMB_SDA_P1: CPU1.CM15 Q2601.6 Q7901.6 R2405.2 RN1811.3(B)
CPU_SMB_SDA_THM: C2609.1 Q2601.1 RN2602.4(B) U2601.7
CPVEE: C2709.2 U2701.27
DAT_ITE8010: IO2.6 R6601.2
DAT_TP_SIO: AFTP2402.1 U2401.79
DAT_TP_SIO_I2C_CLK: EC6501.1 RN6501.4(B) RN6502.1(A) U2401.97
DBC_PANEL_EN: CPU1.CA31 LCD1.7 R2043.2
DC_IN_OFF: PQ4452.3 PR4464.2 PR4470.2
DCBATOUT_LCD_R_SEN: CN1.4 R6619.1
DCBATOUT_VCCGT_SEN: CN1.1 R6610.2
DCBATOUT_VCCSA_SEN: CN1.19 R6617.2
DCBATOUT_VCORE_SEN: CN1.16 R6623.1
DCBATOUT_VDDQ_SEN: CN1.15 R6615.2
DDC_CLK_HDMI: ED5703.4 ED5703.7 HDMI1.15 Q5702.6 RN5701.2(A)
DDC_CLK_PH1: D5701.1 RN5701.3(B)
DDC_DATA_HDMI: ED5703.1 ED5703.10 HDMI1.16 Q5702.3 RN5701.1(A)
DDC_DATA_PH2: D5701.2 RN5701.4(B)
DDR_CA_VREF: C1251.1 CPU1.F36 R1228.2
DGPU_HOLD_RST#: CPU1.CR22 R7604.1 RN2009.4(B) U7601.1
DGPU_PWR_1V: R8611.2 U8605.1
DGPU_PWR_EN: CPU1.CM24 PR8621.1 Q8614.2 R8611.1 RN2009.3(B)
DGPU_PWR_EN#: Q8614.5 Q8614.6 R8613.1
DGPU_PWROK: CPU1.CJ25 R2471.1 R8533.2 R8534.1 U8502.4
DGPU_PWROK_L: R8531.2 R8532.2 R8533.1 U8502.1
DGPUHOT#: D7902.K PQ4402.D R2477.1
DIAGLOOP: LCD1.36 R5510.1
DMIC_SCL_CODEC: EC2706.1 RN5503.4(B) U2701.3
DMIC_SCL_CON: EC5504.1 LCD1.39 RN5503.1(A) RN5504.2(A)
DMIC_SCL_CPU: CPU1.CP24 RN5504.3(B)
DMIC_SDA_CODEC: EC2711.1 RN5503.3(B) U2701.2
DMIC_SDA_CON: EC5503.1 LCD1.40 RN5503.2(A) RN5504.1(A)
DMIC_SDA_CPU: CPU1.CN24 RN5504.4(B)
DP1_HPD_CPU: Q401.5 R7149.2 R7227.1
DP1_HPD_CPU_R: CPU1.CM6 Q401.6 R403.2 RN405.4(B)
DP2_AUX_C2_N: RN7203.7(B) U7201.J2
DP2_AUX_C2_P: RN7203.8(B) U7201.J1
DP2_AUX_C_N: C7102.1 R7101.2 U7101.25
DP2_AUX_C_P: C7101.1 R7102.2 U7101.24
DP2_AUX_CPU_N: C7102.2 CPU1.AD4
DP2_AUX_CPU_P: C7101.2 CPU1.AD3
DP2_DDI_TX_C_N0: C7113.2 U7101.10
DP2_DDI_TX_C_N1: C7107.2 U7101.13
DP2_DDI_TX_C_N2: C7108.2 U7101.16
DP2_DDI_TX_C_N3: C7110.2 U7101.19
DP2_DDI_TX_C_P0: C7112.2 U7101.9
DP2_DDI_TX_C_P1: C7114.2 U7101.12
DP2_DDI_TX_C_P2: C7109.2 U7101.15
DP2_DDI_TX_C_P3: C7111.2 U7101.18
DP2_DDI_TX_N0: C7113.1 CPU1.AC4
DP2_DDI_TX_N1: C7107.1 CPU1.AC1
DP2_DDI_TX_N2: C7108.1 CPU1.AE4
DP2_DDI_TX_N3: C7110.1 CPU1.AE1
DP2_DDI_TX_P0: C7112.1 CPU1.AC3
DP2_DDI_TX_P1: C7114.1 CPU1.AC2
DP2_DDI_TX_P2: C7109.1 CPU1.AE3
DP2_DDI_TX_P3: C7111.1 CPU1.AE2
DPEQ0_A1: R7171.2 R7172.1 U7101.14
DPEQ1: R7147.2 R7170.1 U7101.2
EC_AGND: C2407.2 C2408.2 C2422.2 C2435.2 C2441.2 R2441.2 R2444.2 R2445.2 U2401.112
EC_D_INHIB: C6402.1 D6402.A Q6406.B R6404.2 R6425.2 U2401.25
EDP_AUX_CON_N: C5511.1 LCD1.15
EDP_AUX_CON_P: C5510.1 LCD1.14
EDP_AUX_CPU_N: C5511.2 CPU1.AH4
EDP_AUX_CPU_P: C5510.2 CPU1.AH3
EDP_HPD_CON: LCD1.11 RN5502.8(B) RN5505.2(A)
EDP_HPD_CPU: CPU1.CM7 RN5505.3(B)
EDP_RCOMP_CPU: CPU1.AM6 R401.2
EDP_TX_CON_N0: C5506.1 LCD1.17
EDP_TX_CON_N1: C5501.1 LCD1.20
EDP_TX_CON_P0: C5509.1 LCD1.18
EDP_TX_CON_P1: C5504.1 LCD1.21
EDP_TX_CPU_N0: C5506.2 CPU1.AG4
EDP_TX_CPU_N1: C5501.2 CPU1.AG2
EDP_TX_CPU_P0: C5509.2 CPU1.AG3
EDP_TX_CPU_P1: C5504.2 CPU1.AG1
EDP_VDD_EN: CPU1.CG11 D5501.1
EMMC_RCOMP: CPU1.CK15 R2108.2
EQ0: R7142.2 R7143.1 U7101.38
EQ1: R7140.2 R7141.1 U7101.35
ESPI_ALERT#: CPU1.BV28 R1821.2
ESPI_CLK: DB1.2 R1805.2 U2401.57
ESPI_CPU_CLK_R: CPU1.BV32 R1805.1
ESPI_CPU_IO0_R: CPU1.CA29 RN1806.1(A)
ESPI_CPU_IO1_R: CPU1.BY29 RN1806.3(A)
ESPI_CPU_IO2_R: CPU1.BY27 RN1806.2(A)
ESPI_CPU_IO3_R: CPU1.BV27 RN1806.4(A)
ESPI_CS#: CPU1.CA28 DB1.5 U2401.58
ESPI_IO0: DB1.9 RN1806.8(B) U2401.59
ESPI_IO1: DB1.8 RN1806.6(B) U2401.60
ESPI_IO2: DB1.7 RN1806.7(B) U2401.61
ESPI_IO3: DB1.6 RN1806.5(B) U2401.62
ESPI_RESET#: CPU1.CA27 DB1.4 U2401.53
EXT_PWR_GATE#: CPU1.CC37 R1731.2
FAN1_PWM: AFTP2602.1 EC2602.1 FAN1.4 U2401.47
FAN1_TACH: D2403.A R2430.2 U2401.40
FAN_TACH1: AFTP2601.1 D2403.K EC2601.1 FAN1.3
FB_CAL_PD_VDDQ: GPU1.D22 R7805.2
FB_CAL_PU_GND: GPU1.C24 R7807.1
FB_CAL_TERM_GND: GPU1.B25 R7806.1
FBA_CLK0_MIDPT: C8101.1 R8101.2 R8102.2
FBA_CLK0N: GPU1.D25 R8102.1 VRAM1.J11
FBA_CLK0P: GPU1.D24 R8101.1 VRAM1.J12
FBA_CLK1_MIDPT: C8201.1 R8206.1 R8208.1
FBA_CLK1N: GPU1.M22 R8206.2 VRAM4.J11
FBA_CLK1P: GPU1.N22 R8208.2 VRAM4.J12
FBA_CMD0: GPU1.C27 VRAM1.G12
FBA_CMD1: GPU1.C26 VRAM1.H10
FBA_CMD2: GPU1.E24 VRAM1.H11
FBA_CMD3: GPU1.F24 VRAM1.K11
FBA_CMD4: GPU1.D27 VRAM1.K10
FBA_CMD5: GPU1.D26 VRAM1.L12
FBA_CMD6: GPU1.F25 VRAM1.K4
FBA_CMD7: GPU1.F26 VRAM1.K5
FBA_CMD8: GPU1.F23 VRAM1.J4
FBA_CMD9: GPU1.G22 VRAM1.J5
FBA_CMD10: GPU1.G23 VRAM1.H4
FBA_CMD11: GPU1.G24 VRAM1.H5
FBA_CMD12: GPU1.F27 VRAM1.G3
FBA_CMD13: GPU1.G25 R7820.1 VRAM1.J2
FBA_CMD14: GPU1.G27 R7816.2 VRAM1.J3
FBA_CMD15: GPU1.G26 VRAM1.L3
FBA_CMD16: GPU1.M24 VRAM4.L12
FBA_CMD17: GPU1.M23 VRAM4.K10
FBA_CMD18: GPU1.K24 VRAM4.K11
FBA_CMD19: GPU1.K23 VRAM4.H11
FBA_CMD20: GPU1.M27 VRAM4.H10
FBA_CMD21: GPU1.M26 VRAM4.G12
FBA_CMD22: GPU1.M25 VRAM4.H4
FBA_CMD23: GPU1.K26 VRAM4.H5
FBA_CMD24: GPU1.K22 VRAM4.J4
FBA_CMD25: GPU1.J23 VRAM4.J5
FBA_CMD26: GPU1.J25 VRAM4.K4
FBA_CMD27: GPU1.J24 VRAM4.K5
FBA_CMD28: GPU1.K27 VRAM4.L3
FBA_CMD29: GPU1.K25 R7821.1 VRAM4.J2
FBA_CMD30: GPU1.J27 R7824.2 VRAM4.J3
FBA_CMD31: GPU1.J26 VRAM4.G3
FBA_D0: GPU1.E18 VRAM1.A4
FBA_D1: GPU1.F18 VRAM1.A2
FBA_D2: GPU1.E16 VRAM1.B4
FBA_D3: GPU1.F17 VRAM1.B2
FBA_D4: GPU1.D20 VRAM1.E4
FBA_D5: GPU1.D21 VRAM1.E2
FBA_D6: GPU1.F20 VRAM1.F4
FBA_D7: GPU1.E21 VRAM1.F2
FBA_D8: GPU1.E15 VRAM1.A11
FBA_D9: GPU1.D15 VRAM1.A13
FBA_D10: GPU1.F15 VRAM1.B11
FBA_D11: GPU1.F13 VRAM1.B13
FBA_D12: GPU1.C13 VRAM1.E11
FBA_D13: GPU1.B13 VRAM1.E13
FBA_D14: GPU1.E13 VRAM1.F11
FBA_D15: GPU1.D13 VRAM1.F13
FBA_D16: GPU1.B15 VRAM1.U11
FBA_D17: GPU1.C16 VRAM1.U13
FBA_D18: GPU1.A13 VRAM1.T11
FBA_D19: GPU1.A15 VRAM1.T13
FBA_D20: GPU1.B18 VRAM1.N11
FBA_D21: GPU1.A18 VRAM1.N13
FBA_D22: GPU1.A19 VRAM1.M11
FBA_D23: GPU1.C19 VRAM1.M13
FBA_D24: GPU1.B24 VRAM1.U4
FBA_D25: GPU1.C23 VRAM1.U2
FBA_D26: GPU1.A25 VRAM1.T4
FBA_D27: GPU1.A24 VRAM1.T2
FBA_D28: GPU1.A21 VRAM1.N4
FBA_D29: GPU1.B21 VRAM1.N2
FBA_D30: GPU1.C20 VRAM1.M4
FBA_D31: GPU1.C21 VRAM1.M2
FBA_D32: GPU1.R22 VRAM4.U4
FBA_D33: GPU1.R24 VRAM4.U2
FBA_D34: GPU1.T22 VRAM4.T4
FBA_D35: GPU1.R23 VRAM4.T2
FBA_D36: GPU1.N25 VRAM4.N4
FBA_D37: GPU1.N26 VRAM4.N2
FBA_D38: GPU1.N23 VRAM4.M4
FBA_D39: GPU1.N24 VRAM4.M2
FBA_D40: GPU1.V23 VRAM4.U11
FBA_D41: GPU1.V22 VRAM4.U13
FBA_D42: GPU1.T23 VRAM4.T11
FBA_D43: GPU1.U22 VRAM4.T13
FBA_D44: GPU1.Y24 VRAM4.N11
FBA_D45: GPU1.AA24 VRAM4.N13
FBA_D46: GPU1.Y22 VRAM4.M11
FBA_D47: GPU1.AA23 VRAM4.M13
FBA_D48: GPU1.AD27 VRAM4.A11
FBA_D49: GPU1.AB25 VRAM4.A13
FBA_D50: GPU1.AD26 VRAM4.B11
FBA_D51: GPU1.AC25 VRAM4.B13
FBA_D52: GPU1.AA27 VRAM4.E11
FBA_D53: GPU1.AA26 VRAM4.E13
FBA_D54: GPU1.W26 VRAM4.F11
FBA_D55: GPU1.Y25 VRAM4.F13
FBA_D56: GPU1.R26 VRAM4.A4
FBA_D57: GPU1.T25 VRAM4.A2
FBA_D58: GPU1.N27 VRAM4.B4
FBA_D59: GPU1.R27 VRAM4.B2
FBA_D60: GPU1.V26 VRAM4.E4
FBA_D61: GPU1.V27 VRAM4.E2
FBA_D62: GPU1.W27 VRAM4.F4
FBA_D63: GPU1.W25 VRAM4.F2
FBA_DQM0: GPU1.D19 VRAM1.D2
FBA_DQM1: GPU1.D14 VRAM1.D13
FBA_DQM2: GPU1.C17 VRAM1.P13
FBA_DQM3: GPU1.C22 VRAM1.P2
FBA_DQM4: GPU1.P24 VRAM4.P2
FBA_DQM5: GPU1.W24 VRAM4.P13
FBA_DQM6: GPU1.AA25 VRAM4.D13
FBA_DQM7: GPU1.U25 VRAM4.D2
FBA_EDC0: GPU1.E19 VRAM1.C2
FBA_EDC1: GPU1.C15 VRAM1.C13
FBA_EDC2: GPU1.B16 VRAM1.R13
FBA_EDC3: GPU1.B22 VRAM1.R2
FBA_EDC4: GPU1.R25 VRAM4.R2
FBA_EDC5: GPU1.W23 VRAM4.R13
FBA_EDC6: GPU1.AB26 VRAM4.C13
FBA_EDC7: GPU1.T26 VRAM4.C2
FBA_MF1: R8111.1 VRAM1.J1
FBA_MF4: R8210.2 VRAM4.J1
FBA_SEN0: R8110.1 VRAM1.J10
FBA_SEN2: R8209.1 VRAM4.J10
FBA_VREF_FET_L: Q8101.D R8104.2
FBA_VREFC0: C8126.1 C8202.1 R8104.1 R8106.2 R8107.1 VRAM1.J14 VRAM4.J14
FBA_WCK01: GPU1.D18 VRAM1.D4
FBA_WCK01#: GPU1.C18 VRAM1.D5
FBA_WCK23: GPU1.D17 VRAM1.P4
FBA_WCK23#: GPU1.D16 VRAM1.P5
FBA_WCK45: GPU1.T24 VRAM4.P4
FBA_WCK45#: GPU1.U24 VRAM4.P5
FBA_WCK67: GPU1.V24 VRAM4.D4
FBA_WCK67#: GPU1.V25 VRAM4.D5
FBA_ZQ0: R8108.1 VRAM1.J13
FBA_ZQ3: R8213.1 VRAM4.J13
FFS_INT1: CPU1.CG22 R7005.2
