# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_CA_VREF: length 16.1
  TOP w0.508: v2(66.91,38.31) 66.67,38.07 66.45,38.07 66.4,38.03 66.29,38.14 65.45,38.14 65.38,38.07 64.87,38.58 62.92,38.58 61.46,37.12 61.46,35.77 61.71,35.52 R1228.2 61.66,35.3 C1251.1
  BOTTOM w0.203: CPU1.F36 70.69,43.29 70.32,42.92 70.32,42.76 69.1,41.54 69.1,41.27
  BOTTOM w0.508: v2(66.91,38.31) 66.91,39.32 67.42,39.83 67.66,39.83 69.1,41.27
DGPU_HOLD_RST#: length 52.1
  TOP w0.102: v3(125.17,53.26) 125.17,52.22 125.39,52.01 RN2009.4
  L5 w0.102: v3(125.17,53.26) 125.17,55.59 124.28,56.49 124.28,58.83 124.74,59.28 124.74,61.82 126.32,63.4 126.32,64.65 125.69,65.28 125.69,70.75 v2(127.55,72.62)
  L6 w0.102: v3(125.17,53.26) 124.84,53.59 120.64,53.59 119.97,54.26 115.54,54.26 v2(114.72,53.43)
  BOTTOM w0.076: v2(114.72,53.43) 114.72,53.42 113.61,52.32 112.61,52.32 112.6,52.3 112.5,52.3 CPU1.CR22
  BOTTOM w0.102: v1(136.38,75.18) 135.83,75.73 R7604.1 135.41,76.07 134.98,76.5 134.38,76.5 134.29,76.41 133.84,76.41 133.45,76.01 U7601.1 133.45,75.65 133.09,75.29 132.09,75.29 131.76,75.62 131.76,76.24 131.66,76.34 130.78,76.34 130.67,76.23 130.67,75.67 130.39,75.39 129.97,75.39 129.57,75.8 128.75,75.8 128.75,75.8 128.58,75.8 127.29,74.51 127.29,72.88 v2(127.55,72.62)
DGPU_PWR_1V: length 2.8
  BOTTOM w0.356: U8605.1 141.07,76.19 141.49,75.77 R8611.2
  BOTTOM w0.508: R8611.2 141.69,75.42 141.69,75.21 142.25,74.65 v1(142.46,74.65)
DGPU_PWR_EN: length 92.9
  TOP w0.102: RN2009.3 126.06,51.96 125.75,52.26 v3(125.75,52.36) ; PR8621.1 153.43,81.44 v2(154.94,79.93)
  L3 w0.102: v2(135.14,54.71) 135.14,54.71 135.14,54.71 134.58,54.14 134.58,49.51 v2(134.88,49.2)
  L6 w0.102: v3(110.15,51.81) 112.08,51.81 112.9,50.98 115.67,50.98 116.01,50.64 118.15,50.64 119.54,49.25 122.51,49.25 123.37,50.12 124.06,50.12 124.11,50.07 126.76,50.07 127.92,48.91 129.92,48.91 130.21,49.2 v2(134.88,49.2)
  L8 w0.102: v2(135.14,54.71) 135.14,55.74 134.76,56.12 134.76,58.46 132.96,60.26 132.96,62.55 134.06,63.65 134.06,70.47 137.22,73.64 140.63,73.64 142.37,75.38 142.37,76.3 142.39,76.31 ; 142.39,76.31 148.26,76.31 148.37,76.21 150.11,76.21 153.14,79.23 153.2,79.23 153.9,79.93 v2(154.94,79.93) ; 142.39,76.31 v2(142.37,76.31)
  BOTTOM w0.102: v2(135.14,54.71) 133.84,54.71 133.44,55.11 128.58,55.11 127.11,53.63 127.11,53.52 v1(126.73,53.15) 125.94,52.36 v3(125.75,52.36) ; v3(110.15,51.81) 110.15,51.85 110.17,51.85 110.52,51.5 CPU1.CM24 ; v2(142.37,76.31) 142.39,76.31 142.35,76.28 R8611.1 ; Q8614.2 154.03,80.84 v2(154.94,79.93)
DGPU_PWR_EN#: length 5.8
  TOP w0.102: v2(151.87,82.3) 151.87,82.15 151.23,81.51 150.38,81.51 v1(149.84,80.97) 149.1,80.24 R8613.1
  BOTTOM w0.102: v2(151.87,82.3) 152.51,82.3 152.81,82.01 Q8614.5 Q8614.6
DGPU_PWROK: length 178.3
  TOP w0.102: v1(134.06,74.41) 133.81,74.67 v2(133.81,74.97) ; v2(146.09,84.71) 146.09,84.06 146.17,83.99 R8533.2
  L3 w0.102: v2(133.81,74.97) 135.08,73.7 135.08,66.63 135.43,66.28 135.43,60.83 135.16,60.56 135.16,56.48 136.02,55.62 136.02,55.23 136.43,54.82 136.43,53.21 136.08,52.86 136.08,50.56 135.51,49.98 v2(135.51,49.09) ; v2(29.35,35.23) 29.35,34.65 26.93,32.23 26.89,32.23 v2(26.19,31.53)
  L5 w0.102: v2(29.35,35.23) 29.4,35.23 29.48,35.16 32.04,35.16 32.22,35.33 38.08,35.33 38.1,35.31 43.03,35.31 45.29,37.57 49.36,37.57 52.06,40.27 52.06,42.7 58.04,48.68 62.35,48.68 65.66,51.99 69.9,51.99 70.06,52.16 71.61,52.16 71.8,52.35 73.11,52.35 75.11,50.34 98.51,50.34 98.89,50.73 100.55,50.73 100.72,50.89 101.08,50.89 101.93,50.05 105.75,50.05 107.02,51.32 108.29,51.32 108.39,51.43 108.4,51.43 108.65,51.68 108.65,51.68 v2(108.88,51.91)
  L6 w0.102: v2(135.51,49.09) 135.51,49.06 135.22,48.76 132.89,48.76 132.85,48.72 132.49,48.72 132.47,48.71 127.84,48.71 126.92,49.62 125.05,49.62 124.45,49.02 123.13,49.02 123.1,48.99 122.75,48.99 122.1,48.34 120.14,48.34 118.2,50.28 115.83,50.28 115.37,50.74 112.85,50.74 112.2,51.4 109.36,51.4 108.88,51.88 v2(108.88,51.91)
  L8 w0.102: v2(146.09,84.71) 145.5,84.12 140.01,84.12 137.74,81.85 136.3,81.85 133.7,79.26 133.7,75.08 v2(133.81,74.97)
  BOTTOM w0.102: R2471.1 26.19,30.84 v2(26.19,31.53) ; R8534.1 148.04,84.15 U8502.4 146.58,84.15 146.09,84.64 v2(146.09,84.71) ; CPU1.CJ25 109.06,50.42 109.06,50.84 108.89,51.02 108.89,51.91 v2(108.88,51.91)
DGPU_PWROK_L: length 4.7
  TOP w0.102: R8532.2 146.98,83 R8533.1 146.14,83.03 R8531.2 144.98,83.03 144.49,82.54 v1(144.49,82.5) 144.5,82.5 144.63,82.36 145.51,82.36 v2(145.6,82.27)
  BOTTOM w0.102: U8502.1 145.6,82.77 v2(145.6,82.27)
DGPUHOT#: length 177.4
  TOP w0.102: v2(28.34,26.6) 28.34,26.96 27.55,27.74 25.05,27.74 24.58,28.22 23.34,28.22 R2477.1
  L3 w0.102: v2(164.05,32.5) 164.05,30.98 162.49,29.42 160.63,29.42 159.42,30.63 158.61,30.63 158.32,30.35 158.32,30.05 155.66,27.39 155.53,27.39 153.46,25.32 151.3,25.32 149.77,23.79 v2(149.77,23.78)
  L5 w0.102: v2(149.77,23.78) 149.77,23.35 148.24,21.82 145.68,21.82 145.68,21.82 144.15,21.82 144.15,21.82 139.41,21.82 138.8,22.43 137.89,22.43 136.03,24.29 129.59,24.29 127.19,21.89 127.19,17.71 123.94,14.46 122.59,14.46 122.37,14.24 122.35,14.15 122.13,14 121.18,13.05 118.82,13.05 117.83,12.06 108.55,12.06 108.28,12.33 93.3,12.33 91.31,14.33 90.4,14.33 90.15,14.33 88.92,15.56 56.14,15.56 55.9,15.33 46.74,15.33 45.2,16.87 45.03,16.87 44.74,16.87 43.77,17.84 42.57,17.84 41.71,18.7 41.71,19.1 40.02,20.79 37.29,20.79 33.64,24.44 33.53,24.44 30.88,27.09 28.83,27.09 v2(28.34,26.6)
  BOTTOM w0.102: PQ4402.D 149.44,23.98 149.64,23.78 149.81,23.78 149.81,23.78 v2(149.77,23.78) ; v2(164.05,32.5) 163.89,32.66 v1(163.89,36.79) 163.89,40.57 160.86,43.59 D7902.K
DIAGLOOP: length 4.2
  BOTTOM w0.102: R5510.1 55.17,76.43 54.44,76.43 v1(54.18,76.7) 53.54,76.7 53.05,77.19 53.05,78.28 52.8,78.53 LCD1.36
DMIC_SCL_CODEC: length 279.6
  TOP w0.127: U2701.3 179.75,16.16 179.68,16.23 179.33,16.23 178.4,17.17 177.23,17.17 177.07,17 v2(176.98,17) 176.67,17.31 EC2706.1 ; RN5503.4 56.31,77.29 v2(56.4,77.2) ; v2(38.6,19.73) 38.6,20.21 v1(38.85,20.46)
  L3 w0.127: v2(17.43,29.93) 17.42,29.93 17.29,30.05 17.29,30.29 16.67,30.91 16.67,39.53 16.64,39.53 16.15,40.01 16.15,41.26 15.38,42.04 15.38,44.23 15.35,44.26 15.32,44.26 14.74,44.84 13.51,44.84 13.38,44.96 13.38,47.06 13.74,47.42 13.74,49.12 13.93,49.31 v2(14.11,49.31)
  L5 w0.127: v2(38.6,19.73) 38.8,19.53 38.8,18.87 39.67,18 39.67,16.8 41.38,15.09 44.29,15.09 45.87,13.52 56.61,13.52 56.87,13.78 88.18,13.78 91.41,10.56 107.54,10.56 107.95,10.15 116.21,10.15 116.97,9.39 121.85,9.39 123.19,10.73 123.56,10.73 123.66,10.64 139.59,10.64 139.69,10.55 141.2,10.55 141.5,10.85 146.65,10.85 148.35,12.55 152.82,12.55 153.45,13.18 155.21,13.18 155.74,12.65 158.41,12.65 159.97,14.22 165.09,14.22 165.54,13.78 170.5,13.78 171.64,14.92 176.15,14.92 176.56,15.33 176.56,16.87 176.68,17 v2(176.98,17) ; v2(27.77,19.21) 27.77,19.23 27.23,19.78 26.68,19.78 25.02,21.45 25.02,23.06 24.52,23.55 24.52,26.71 22.71,28.53 22.71,29.95 22.29,30.36 19.26,30.36 19.26,30.36 19.24,30.36 18.81,29.93 v2(17.43,29.93)
  L8 w0.127: v2(14.11,49.31) 13.67,49.75 13.67,50.31 13.72,50.36 13.72,52.6 13.59,52.73 13.59,53.41 13.04,53.95 13.04,57.06 15.96,59.98 15.96,61.02 18.2,63.26 18.2,64.35 18.02,64.53 18.02,65.49 19.04,66.5 19.04,68.36 20.23,69.55 20.23,70.87 19.62,71.48 18.4,71.48 18.13,71.76 18.13,72.6 19.99,74.47 20.89,74.47 21.02,74.59 21.02,74.97 21.91,75.85 22.48,75.85 22.5,75.84 39.22,75.84 41.61,78.23 55.87,78.23 56.4,77.7 v2(56.4,77.2) ; v2(38.6,19.73) 38.79,19.92 38.79,20.23 38.42,20.59 35.12,20.59 34.47,19.94 32.88,19.94 31.35,18.41 30.04,18.41 29.03,19.42 27.97,19.42 27.79,19.25 27.79,19.23 v2(27.77,19.21)
DMIC_SCL_CON: length 17.8
  TOP w0.127: EC5504.1 56.31,78.91 RN5503.1 56.31,79.26 56.07,79.5 56.03,79.5 55.46,80.07 v2(55.46,80.14) ; RN5504.2 v2(64.81,81.49)
  L3 w0.127: v2(64.81,81.49) 64.81,81.95 64.31,82.45 62.17,82.45 59.69,79.96 55.64,79.96 v2(55.46,80.14)
  BOTTOM w0.127: v2(55.46,80.14) 55.28,80.32 54.8,80.32 54,79.52 LCD1.39 ; v2(64.81,81.49) 64.81,81.11 64.68,80.98 v1(64.38,80.98)
DMIC_SCL_CPU: length 135.7
  TOP w0.127: v2(64.81,84.38) RN5504.3 ; v2(135.12,50.39) 135.49,50.01 v1(135.49,49.98)
  L6 w0.127: v2(135.12,50.39) 135.09,50.42 134.88,50.42 134.87,50.41 134.75,50.41 134.22,50.41 133.93,50.69 132.31,50.69 132.23,50.77 124.4,50.77 124.09,51.08 122.5,51.08 121.75,50.33 120.37,50.33 118.96,51.74 117.36,51.74 116.96,51.34 116.53,51.34 v2(116.09,51.79)
  L8 w0.127: v2(135.12,50.39) 134.44,50.39 133.31,51.52 133.31,54.55 132.93,54.92 132.21,54.92 129.9,57.23 129.9,57.56 128.5,58.96 128.5,60.49 129.89,61.87 129.89,63.67 129.22,64.34 129.22,72.02 130.56,73.36 130.56,78.69 127.62,81.64 127.62,84.73 125.08,87.26 122.4,87.27 122.34,87.33 121.29,87.33 120.62,87.33 119.15,88.8 75.82,88.8 75.55,88.54 66.63,88.54 64.62,86.53 64.62,84.57 v2(64.81,84.38)
  BOTTOM w0.076: v2(116.09,51.79) 116.09,51.76 116.02,51.83 116,51.83 115.78,52.05 115.75,52.05 115.59,52.21 114.58,52.21 113.53,51.15 112.75,51.15 112.61,51.29 112.36,51.29 CPU1.CP24
DMIC_SDA_CODEC: length 280.7
  TOP w0.127: U2701.2 179.75,16.56 179.68,16.49 179.44,16.49 178.51,17.42 177.24,17.42 v2(176.99,17.66) 176.9,17.66 176.65,17.91 174.93,17.91 EC2711.1 ; v1(16.83,30.4) 16.83,29.73 v2(16.83,29.73) ; RN5503.3 55.66,77.59 55.82,77.43 55.82,77.25 v2(55.77,77.2)
  L3 w0.127: v2(14.11,50.13) 14.11,50.05 13.49,49.42 13.49,47.52 13.13,47.17 13.13,44.86 13.41,44.58 14.64,44.58 15.13,44.1 15.13,41.93 15.9,41.16 15.9,39.91 16.42,39.39 16.42,30.8 16.86,30.37 16.86,29.75 v2(16.83,29.73)
  L5 w0.127: v2(39.24,19.71) 39.06,19.53 39.06,18.98 39.93,18.11 39.93,16.91 41.49,15.35 44.39,15.35 45.97,13.77 56.5,13.77 56.77,14.04 88.29,14.04 91.51,10.81 107.65,10.81 108.05,10.4 116.32,10.4 117.08,9.65 121.75,9.65 123.09,10.99 123.67,10.99 123.76,10.89 139.7,10.89 139.79,10.8 141.1,10.8 141.4,11.1 146.54,11.1 148.24,12.8 152.72,12.8 153.35,13.43 155.32,13.43 155.84,12.91 158.3,12.91 159.87,14.47 165.2,14.47 165.64,14.03 170.39,14.03 171.54,15.17 176.04,15.17 176.3,15.43 176.3,16.98 176.58,17.25 176.61,17.25 176.98,17.63 176.98,17.66 v2(176.99,17.66) ; v2(16.83,29.73) 17,29.73 17.25,29.48 17.98,29.48 18.17,29.67 18.91,29.67 19.35,30.11 19.37,30.11 22.18,30.11 22.45,29.84 22.45,28.42 24.26,26.61 24.26,23.45 24.76,22.95 24.76,21.34 26.91,19.19 v2(27.11,19.19)
  L8 w0.127: v2(39.24,19.71) 39.04,19.9 39.04,20.33 38.53,20.85 35.02,20.85 34.36,20.19 32.77,20.19 31.25,18.67 30.15,18.67 29.14,19.68 27.59,19.68 27.11,19.19 v2(27.11,19.19) ; v2(55.77,77.2) 55.77,77.64 55.43,77.97 41.72,77.97 39.33,75.58 22.4,75.58 22.38,75.6 22.01,75.6 21.27,74.86 21.27,74.49 21,74.21 20.09,74.21 18.38,72.5 18.38,71.86 18.51,71.73 19.73,71.73 20.49,70.98 20.49,69.44 19.29,68.25 19.29,66.4 18.28,65.38 18.28,64.64 18.46,64.46 18.46,63.15 16.22,60.91 16.22,59.87 13.3,56.95 13.3,54.06 13.85,53.51 13.85,52.83 13.97,52.71 13.97,50.26 v2(14.11,50.13)
DMIC_SDA_CON: length 16.3
  TOP w0.127: v1(64.17,80.81) 64.17,81.38 v2(64.06,81.49) 64.16,81.58 RN5504.1 ; v2(54.91,79.77) 55.12,79.77 55.66,79.24 RN5503.2 54.95,78.91 EC5503.1
  L3 w0.127: v2(54.91,79.77) 55.2,79.77 55.28,79.7 55.65,79.7 55.66,79.71 59.79,79.71 62.28,82.2 64.2,82.2 64.34,82.05 64.34,81.77 v2(64.06,81.49)
  BOTTOM w0.127: LCD1.40 54.4,79.47 54.73,79.8 54.97,79.8 54.97,79.77 v2(54.91,79.77)
DMIC_SDA_CPU: length 137
  TOP w0.127: RN5504.4 64.27,83.3 64.27,83.63 64.28,83.63 v2(64.28,83.97) ; v1(134.53,50.72) 134.83,51.03 v2(135.08,51.03)
  L6 w0.127: v2(135.08,51.03) 135.08,50.98 134.94,50.84 134.93,50.84 134.76,50.66 134.32,50.66 134.03,50.95 132.41,50.95 132.34,51.02 124.51,51.02 124.19,51.34 122.39,51.34 121.64,50.59 120.47,50.59 119.07,52 117.26,52 117.05,51.79 v2(116.78,51.79)
  L8 w0.127: v2(135.08,51.03) 135.08,50.98 134.74,50.65 134.55,50.65 133.56,51.63 133.56,54.65 133.04,55.18 132.32,55.18 130.15,57.34 130.15,57.67 128.75,59.07 128.75,60.38 130.14,61.77 130.14,63.78 129.47,64.45 129.47,71.91 130.82,73.26 130.82,78.8 127.87,81.74 127.87,84.83 125.19,87.52 122.51,87.52 122.45,87.58 121.29,87.58 120.72,87.59 119.25,89.06 75.71,89.06 75.45,88.79 66.52,88.79 64.36,86.63 64.36,84.06 v2(64.28,83.97)
  BOTTOM w0.076: v2(116.78,51.79) 116.78,51.76 116.31,52.23 115.82,52.23 115.66,52.39 114.51,52.39 113.44,51.32 112.84,51.32 112.68,51.46 112.34,51.46 111.7,51.28 CPU1.CN24
DP1_HPD_CPU: length 187.7
  TOP w0.127: v2(20.65,43.84) 20.65,43.84 20.65,43.77 20.15,43.27 R7149.2 ; v3(25.07,62.86) v1(24.31,62.1) 24.02,61.81 R7227.1
  L3 w0.127: v2(126.6,78.86) 128.36,78.86 131.59,82.09 131.59,82.99 127.31,87.27 119.38,87.27 118.49,88.15 v2(118.39,88.15)
  L5 w0.127: v3(29.23,47.76) 27.84,47.76 26.85,46.77 26.85,46.12 26.33,45.6 25.2,45.6 25.19,45.59 24.96,45.59 24.34,44.97 24.34,44.74 23.39,43.79 20.71,43.79 v2(20.65,43.84)
  L6 w0.127: v2(59.44,84.57) 59.02,84.16 59.02,83.28 57.91,82.18 30.83,82.18 27.96,79.31 27.93,79.31 27.46,78.84 27.46,78.18 29.01,76.63 29.01,70.81 27.76,69.56 27.6,69.56 27.19,69.16 27.19,63.8 26.24,62.86 v3(25.07,62.86) 26.02,61.9 26.23,61.9 27.55,60.59 27.55,59.78 28.28,59.05 28.28,57.97 30.59,55.66 30.59,49.1 29.24,47.76 v3(29.23,47.76)
  L8 w0.127: v2(125.88,63.58) 125.88,74.24 126.1,74.45 126.1,77.6 126.35,77.85 126.35,78.61 v2(126.6,78.86)
  BOTTOM w0.127: v2(118.39,88.15) 117.62,88.92 72.43,88.92 72.07,88.56 63.47,88.56 63.33,88.71 61.74,88.71 59.27,86.23 59.27,84.74 v2(59.44,84.57) ; Q401.5 v2(125.88,63.58)
DP1_HPD_CPU_R: length 27.1
  TOP w0.127: R403.2 108.57,63.72 108.57,62.91 v2(109.08,62.4)
  L5 w0.127: v2(109.08,62.4) 109.52,61.96 120.15,61.96 120.22,62.03 121.22,62.03 124.69,65.5 125.12,65.5 125.55,65.08 125.55,64.24 v2(125.42,64.11)
  BOTTOM w0.127: CPU1.CM6 110.52,62.22 110.18,61.87 109.42,61.87 109.08,62.22 109.08,62.4 v2(109.08,62.4) ; RN405.4 128.46,65.33 127.37,64.23 Q401.6 126.07,64.23 v1(125.93,64.36) 125.68,64.11 v2(125.42,64.11)
DP2_AUX_C2_N: length 3.3
  BOTTOM w0.102: RN7203.7 30.94,59.88 30.89,59.93 29.93,59.93 29.45,60.42 28.8,60.42 U7201.J2
DP2_AUX_C2_P: length 2.8
  BOTTOM w0.102: U7201.J1 29.54,60.64 30.03,60.16 30.98,60.16 31.3,60.47 RN7203.8
DP2_AUX_C_N: length 5.9
  TOP w0.102: U7101.25 19.77,39.39 19.86,39.48 19.86,39.92 19.66,40.12 19.66,40.45 v2(19.42,40.7) 19.67,40.95 19.67,41.18 19.57,41.28 19.02,41.28 18.78,41.52 18.78,41.86 C7102.1
  BOTTOM w0.102: v2(19.42,40.7) 19.65,40.44 19.65,39.93 19.47,39.75 R7101.2
DP2_AUX_C_P: length 6
  TOP w0.102: 20.15,40.67 19.89,40.41 19.89,40.22 20.09,40.02 20.09,39.48 20.17,39.39 U7101.24 ; 20.15,40.67 19.9,40.92 19.9,41.27 19.67,41.51 19.11,41.51 19.01,41.61 19.01,41.89 C7101.1 ; 20.15,40.67 v2(20.14,40.67)
  BOTTOM w0.102: v2(20.14,40.67) 19.88,40.43 19.88,39.97 20.26,39.59 R7102.2
DP2_AUX_CPU_N: length 103.8
  TOP w0.102: C7102.2 18.77,43.32 18.77,44.96 19.25,45.45 v2(19.25,45.76)
  L3 w0.089: v2(19.25,45.76) 19.47,45.97 19.47,47.26 19.49,47.28 19.49,52.92 20.26,53.69 20.26,55.97 20.84,56.55 20.84,58.86 19.54,60.16 19.54,61.66 20.16,62.28 20.16,62.91 20.8,63.56 21.21,63.56 21.75,64.1 22.21,64.1 27.62,69.51 28.44,69.51 29.28,70.34 29.28,74.66 30.76,76.14 32.63,76.14 32.89,76.39 36.48,76.39 38.24,78.15 57.96,78.15 63.02,73.09 81.08,73.09 81.94,72.23 v2(81.94,71.31)
  BOTTOM w0.076: 81.48,68.29 81.48,68.27 81.45,68.24 81.45,67.66 81.68,67.43 81.68,65.04 81.68,64.97 81.68,64.89 81.87,64.7 81.87,64.44 CPU1.AD4
  BOTTOM w0.102: 81.48,68.29 81.48,68.43 81.48,68.71 81.11,69.08 81.11,69.9 81.74,70.53 81.74,71.11 v2(81.94,71.31)
DP2_AUX_CPU_P: length 103.7
  TOP w0.102: C7101.2 19,43.33 19,44.87 v2(19.89,45.76)
  L3 w0.089: v2(19.89,45.76) 19.66,45.99 19.66,47.18 19.68,47.2 19.68,52.84 20.45,53.61 20.45,55.89 21.03,56.47 21.03,58.94 19.73,60.24 19.73,61.58 20.35,62.2 20.35,62.83 20.88,63.37 21.29,63.37 21.83,63.91 22.29,63.91 27.7,69.32 28.52,69.32 29.47,70.26 29.47,74.58 30.84,75.95 32.71,75.95 32.97,76.2 36.56,76.2 38.32,77.96 57.88,77.96 62.94,72.9 81,72.9 81.75,72.15 81.75,71.83 81.66,71.74 81.19,71.74 81.1,71.65 v2(81.1,71.31)
  BOTTOM w0.076: CPU1.AD3 81.54,64.48 81.43,64.48 81.35,64.55 81.35,64.83 81.51,64.99 81.51,65.04 81.51,67.35 81.27,67.58 81.27,68.18 81.25,68.2 81.25,68.29
  BOTTOM w0.102: 81.25,68.29 81.25,68.52 81.25,68.52 81.25,68.62 80.89,68.99 80.89,70 81.51,70.62 81.51,71.22 81.42,71.31 v2(81.1,71.31)
DP2_DDI_TX_C_N0: length 3.4
  TOP w0.102: U7101.10 22.15,34.18 22.24,34.09 22.56,34.09 22.8,33.85 22.8,32.36 22.97,32.19 23.3,32.19 C7113.2
DP2_DDI_TX_C_N1: length 2.4
  TOP w0.102: C7107.2 23.77,35.58 23.42,35.58 23.08,35.24 22.53,35.24 22.39,35.38 U7101.13
DP2_DDI_TX_C_N2: length 2.4
  TOP w0.102: C7108.2 23.7,37.03 23.51,37.03 23.05,36.58 U7101.16
DP2_DDI_TX_C_N3: length 2.8
  TOP w0.102: C7110.2 23.72,38.58 23.38,38.58 23.15,38.34 23.15,38.04 22.8,37.69 22.48,37.69 22.39,37.78 U7101.19
DP2_DDI_TX_C_P0: length 3.4
  TOP w0.102: U7101.9 22.23,33.78 22.31,33.86 22.47,33.86 22.57,33.76 22.57,32.27 22.88,31.96 23.23,31.96 C7112.2
DP2_DDI_TX_C_P1: length 2.4
  TOP w0.102: U7101.12 22.42,34.98 22.46,35.01 23.17,35.01 23.52,35.36 23.72,35.36 C7114.2
DP2_DDI_TX_C_P2: length 2.5
  TOP w0.102: C7109.2 23.79,36.81 23.61,36.81 23.15,36.35 22.38,36.35 22.21,36.18 U7101.15
DP2_DDI_TX_C_P3: length 2.8
  TOP w0.102: C7111.2 23.77,38.35 23.48,38.35 23.37,38.25 23.37,37.94 22.89,37.46 22.48,37.46 22.39,37.38 U7101.18
DP2_DDI_TX_N0: length 113.7
  TOP w0.102: v2(24.98,32.33) 24.53,32.33 C7113.1
  L3 w0.089: v2(79.36,68.22) 79.1,68.22 78.97,68.35 78.36,68.35 77.26,69.45 69.11,69.45 68.49,70.07 63.45,70.07 60.09,73.44 49.95,73.44 47.97,75.42 43.77,75.42 42.85,74.5 36.77,74.5 34.78,72.51 32.26,72.51 31.38,71.63 31.38,69.46 28.6,66.69 27.5,66.69 26.59,65.78 26.59,64.78 25.89,64.08 25.13,64.08 24.65,63.61 24.65,62.84 24.28,62.47 24.28,60.94 22.67,59.32 22.67,55.79 22.09,55.21 22.09,52.84 21.4,52.15 21.4,48.23 21.79,47.83 22.15,47.83 24.42,45.56 24.42,40.22 26.42,38.22 26.72,38.22 28.2,36.74 28.2,34.97 27.64,34.41 26.26,34.41 25.93,34.74 24.94,34.74 23.73,33.53 23.73,31.95 23.9,31.79 24.15,31.79 24.24,31.87 24.24,32.71 24.33,32.8 24.51,32.8 24.61,32.69 24.61,32.42 24.7,32.33 v2(24.98,32.33)
  BOTTOM w0.076: CPU1.AC4 80.92,63.87 80.76,64.02 80.76,64.4 80.74,64.47 80.72,64.5 80.62,64.74 80.62,64.99 80.65,65.09 80.65,65.31 80.64,65.33 80.62,65.41 80.62,65.78 80.81,65.97 80.81,66.56 80.3,67.06 80.26,67.06 80.24,67.08
  BOTTOM w0.102: v2(79.36,68.22) 79.59,68.45 79.73,68.45 79.75,68.44 79.95,68.24 79.95,67.37 80.17,67.15 80.24,67.08
DP2_DDI_TX_N1: length 110.4
  TOP w0.102: v2(26.75,35.88) 26.46,35.59 25.87,35.59 25.79,35.51 25.23,35.51 C7107.1
  L3 w0.089: v2(26.75,35.88) 26.63,35.63 26.5,35.5 26.36,35.5 26.27,35.58 26.27,37.6 25.89,37.98 25.74,37.98 23.87,39.85 23.87,45.34 21.92,47.29 21.57,47.29 20.85,48 20.85,52.47 21.54,53.15 21.54,55.44 22.12,56.02 22.12,60.09 21.41,60.81 21.41,61.21 22.1,61.9 22.1,62.27 22.65,62.81 23.72,62.81 24.09,63.17 24.09,64.05 27.77,67.73 28.74,67.73 30.76,69.75 30.76,74.15 31.36,74.74 33.05,74.74 33.42,75.11 39.09,75.11 39.98,76.01 52.79,76.01 54.81,73.98 60.31,73.98 62.59,71.71 67.62,71.71 68.92,70.41 76.1,70.41 77.26,71.58 78.47,71.58 78.69,71.35 78.69,71.11 78.57,70.99 77.8,70.99 77.63,70.82 77.63,70.62 77.8,70.46 v2(78.25,70.46)
  BOTTOM w0.076: CPU1.AC1 81.14,65.62 81.14,66.93 80.64,67.44 80.64,68.09 80.6,68.13 80.6,68.15
  BOTTOM w0.102: v2(78.25,70.46) 78.52,70.19 78.52,70.18 78.52,70.17 78.52,69.73 78.89,69.37 79.72,69.37 80.6,68.49 80.6,68.15
DP2_DDI_TX_N2: length 112.7
  TOP w0.102: C7108.1 25.19,37.08 25.33,37.08 v2(25.61,37.36)
  L3 w0.089: v2(83.16,70.24) 82.72,70.69 82.33,70.69 82.17,70.52 80.57,70.52 78.8,72.29 74.79,72.29 73.49,71 69.15,71 67.86,72.29 62.77,72.29 60.54,74.53 55.38,74.53 53.36,76.55 39.76,76.55 38.86,75.66 33.19,75.66 32.88,75.34 31.04,75.34 30.11,74.41 30.11,69.87 28.51,68.27 27.46,68.27 22.55,63.36 22.42,63.36 20.36,61.3 20.36,60.59 21.58,59.37 21.58,56.25 20.99,55.66 20.99,53.38 20.3,52.69 20.3,46.87 22.35,44.82 22.35,42.79 23.32,41.82 23.32,39.62 24.21,38.74 24.21,36.88 24.3,36.79 25.1,36.79 25.19,36.88 25.19,37.27 25.28,37.36 v2(25.61,37.36)
  BOTTOM w0.076: CPU1.AE4 82.41,64.05 82.45,64.09 82.45,64.4 82.47,64.44 82.49,64.48 82.6,64.74 82.6,65 82.56,65.09 82.56,65.31 82.6,65.4 82.6,65.76 82.41,65.94 82.41,66.32 82.87,66.78 82.87,67.73 82.9,67.77 82.9,67.79
  BOTTOM w0.102: v2(83.16,70.24) 82.9,69.98 82.9,67.79
DP2_DDI_TX_N3: length 100.7
  TOP w0.102: v2(25.74,40.85) 25.46,40.57 25.27,40.57 25.03,40.33 25.03,39.84 25.74,39.13 25.74,38.71 25.64,38.6 25.49,38.6 25.23,38.87 C7110.1
  L3 w0.089: v2(25.74,40.85) 25.95,40.64 26.56,40.64 26.82,40.91 26.82,44.24 23.36,47.71 23.36,57.18 26.19,60.02 27.03,60.02 27.32,60.31 27.32,64.66 30.95,68.29 33.76,68.29 33.9,68.43 33.9,69.18 33.41,69.67 33.41,70.29 36.39,73.28 43,73.28 43.29,72.99 60,72.99 63.72,69.27 64.45,69.27 65.42,68.31 72.13,68.31 72.95,67.49 79.72,67.49 80.28,68.05 80.28,69.05 80.79,69.57 81.41,69.57 v2(81.62,69.78)
  BOTTOM w0.076: CPU1.AE1 82.03,65.67 82.03,66.52 82.28,66.78 82.28,67.79 82.31,67.82 82.31,67.91
  BOTTOM w0.102: 82.31,67.91 82.31,68.78 82.17,68.92 82.17,69.23 v2(81.62,69.78)
DP2_DDI_TX_P0: length 113.7
  TOP w0.102: C7112.1 24.51,31.6 v2(24.98,31.6)
  L3 w0.089: v2(79.36,68.85) 79.05,68.54 78.44,68.54 77.34,69.64 69.19,69.64 68.57,70.26 63.53,70.26 60.17,73.63 50.03,73.63 48.05,75.61 43.69,75.61 42.77,74.69 36.69,74.69 34.71,72.7 32.18,72.7 31.19,71.71 31.19,69.54 28.52,66.88 27.42,66.88 26.4,65.86 26.4,64.86 25.81,64.27 25.05,64.27 24.46,63.68 24.46,62.92 24.09,62.55 24.09,61.02 22.48,59.4 22.48,55.87 21.89,55.29 21.89,52.92 21.21,52.23 21.21,48.15 21.71,47.64 22.07,47.64 24.23,45.48 24.23,40.14 26.34,38.03 26.64,38.03 28.01,36.66 28.01,35.05 27.56,34.6 26.34,34.6 26.01,34.93 24.86,34.93 23.54,33.61 23.54,31.87 23.82,31.6 v2(24.98,31.6)
  BOTTOM w0.076: 80.4,67.24 80.42,67.23 80.42,67.18 80.97,66.62 80.97,65.9 80.78,65.71 80.78,65.43 80.82,65.34 80.82,65.06 80.78,64.97 80.78,64.78 80.86,64.6 80.96,64.57 81.11,64.57 81.32,64.36 81.32,64.03 81.23,63.94 81.12,63.94 81.04,64.02 CPU1.AC3
  BOTTOM w0.102: v2(79.36,68.85) 79.88,68.64 80.18,68.33 80.18,67.46 80.4,67.24
DP2_DDI_TX_P1: length 110.4
  TOP w0.102: C7114.1 25.15,35.29 25.89,35.29 25.96,35.36 26.46,35.36 26.49,35.36 26.52,35.33 v2(26.75,35.1)
  L3 w0.089: v2(26.75,35.1) 26.55,35.31 26.28,35.31 26.08,35.51 26.08,37.52 25.81,37.79 25.66,37.79 23.68,39.77 23.68,45.26 21.84,47.09 21.49,47.09 20.66,47.92 20.66,52.54 21.35,53.23 21.35,55.52 21.93,56.1 21.93,60.01 21.22,60.73 21.22,61.28 21.91,61.98 21.91,62.35 22.57,63 23.65,63 23.89,63.25 23.89,64.12 27.69,67.92 28.66,67.92 30.57,69.83 30.57,74.23 31.28,74.93 32.97,74.93 33.34,75.3 39.01,75.3 39.9,76.2 52.87,76.2 54.89,74.17 60.39,74.17 62.66,71.9 67.7,71.9 69,70.6 76.02,70.6 77.18,71.77 78.55,71.77 78.88,71.43 v2(78.88,70.45)
  BOTTOM w0.076: CPU1.AC2 81.06,64.88 81.31,65.45 81.31,67 80.8,67.5 80.8,68.09 80.83,68.13 80.83,68.15
  BOTTOM w0.102: v2(78.88,70.45) 78.88,70.27 78.75,70.14 78.75,69.83 78.99,69.6 79.82,69.6 80.83,68.58 80.83,68.15
DP2_DDI_TX_P2: length 112.7
  TOP w0.102: v2(25.61,36.6) 25.61,36.57 25.33,36.85 25.19,36.85 C7109.1
  L3 w0.089: v2(83.16,70.88) 82.25,70.88 82.09,70.71 80.65,70.71 78.88,72.48 74.71,72.48 73.42,71.19 69.23,71.19 67.94,72.48 62.85,72.48 60.62,74.72 55.46,74.72 53.44,76.74 39.68,76.74 38.78,75.85 33.11,75.85 32.8,75.53 30.96,75.53 29.92,74.49 29.92,69.95 28.43,68.46 27.39,68.46 22.47,63.55 22.34,63.55 20.17,61.38 20.17,60.51 21.39,59.29 21.39,56.33 20.8,55.74 20.8,53.46 20.11,52.77 20.11,46.79 22.16,44.74 22.16,42.71 23.13,41.74 23.13,39.54 24.02,38.66 24.02,36.8 24.22,36.6 v2(25.61,36.6)
  BOTTOM w0.076: CPU1.AE3 82.34,64.55 82.43,64.78 82.43,64.97 82.4,65.06 82.4,65.34 82.43,65.43 82.43,65.69 82.24,65.87 82.24,66.39 82.7,66.84 82.7,67.73 82.67,67.77
  BOTTOM w0.102: v2(83.16,70.88) 82.67,70.38 82.67,67.77
DP2_DDI_TX_P3: length 100.7
  TOP w0.102: v2(25.74,40.06) 25.46,40.34 25.36,40.34 25.26,40.24 25.26,39.93 25.97,39.22 25.97,38.61 25.73,38.38 25.49,38.38 25.23,38.11 C7111.1
  L3 w0.089: v2(25.74,40.06) 26.13,40.45 26.63,40.45 27.01,40.83 27.01,44.32 23.55,47.79 23.55,57.1 26.27,59.83 27.11,59.83 27.51,60.23 27.51,64.58 31.03,68.1 33.84,68.1 34.09,68.35 34.09,69.26 33.6,69.75 33.6,70.22 36.47,73.09 42.92,73.09 43.21,72.8 59.92,72.8 63.64,69.08 64.37,69.08 65.34,68.12 72.05,68.12 72.87,67.3 79.8,67.3 80.47,67.97 80.47,68.97 80.87,69.38 81.39,69.38 v2(81.62,69.15)
  BOTTOM w0.076: CPU1.AE2 81.85,65.46 81.85,66.6 82.1,66.85 82.1,67.87 82.09,67.89 82.09,67.91
  BOTTOM w0.102: 82.09,67.91 82.09,68.68 82.01,68.76 v2(81.62,69.15)
DPEQ0_A1: length 4.2
  TOP w0.127: U7101.14 22.74,35.78 22.9,35.62 v2(22.9,35.67)
  BOTTOM w0.127: R7171.2 22.16,35.59 R7172.1 ; v1(21.78,34.55) 22.16,34.92 R7172.1 ; v2(22.9,35.67) 22.67,35.44 R7172.1
DPEQ1: length 4.4
  TOP w0.127: R7147.2 18.31,31.34 18.31,31.75 v2(18.33,31.77) 18.33,31.83 18.37,31.88 18.37,31.9 18.83,32.36 18.83,32.38 18.97,32.52 U7101.2
  BOTTOM w0.127: R7170.1 18.67,33.12 v1(18.38,32.83) 18.35,32.8 18.35,32.65 18.37,32.62 18.37,32.26 18.35,32.23 18.35,31.87 18.33,31.85 v2(18.33,31.77)
EC_AGND: length 3
  BOTTOM w0.203: U2401.112 16.44,19.87 v2(16.01,20.3)
  BOTTOM w0.508: v2(16.01,20.3) 15.54,20.77 C2408.2 14.59,20.77 R2444.2
  vias: v1(16.45,17.52)
EC_D_INHIB: length 65.6
  TOP w0.102: C6402.1 17.08,66.51 R6404.2 16.83,65.97 v2(16.27,65.97) ; v1(16.54,28.66) v2(17.16,28.04)
  L3 w0.102: v2(17.16,28.04) 15.79,29.41 15.63,29.41 15.23,29.81 15.23,38.33 15.21,38.36 15.21,38.71 15.23,38.73 15.23,39.83 14.69,40.37 14.69,40.4 13.82,41.27 13.79,41.27 13.55,41.51 13.55,42.97 12.38,44.14 12.38,47.48 12.74,47.83 12.74,49.73 13.96,50.96 13.96,51.87 13.96,52.66 14.59,53.29 14.59,58.7 14.76,58.88 14.78,58.88 15.03,59.13 15.03,59.14 15.77,59.88 15.77,60 15.83,60.06 15.83,63.95 16.27,64.39 v2(16.27,65.97)
  L8 w0.102: v2(17.16,28.04) 17.87,28.04 18.85,27.06 23.79,27.06 25.09,25.76 26.1,25.76 26.49,25.38 v2(26.58,25.38)
  BOTTOM w0.102: R6425.2 18.24,64.3 Q6406.B ; Q6406.B 17.56,64.68 v2(16.27,65.97) ; Q6406.B 18.24,65.4 18.57,65.73 19.06,65.73 19.83,64.96 19.83,64.04 D6402.A ; v2(26.58,25.38) 26.6,25.38 26.6,25.39 26.66,25.39 27.91,26.64 27.91,26.77 27.98,26.84 27.98,26.9 28.17,27.09 U2401.25
EDP_AUX_CON_N: length 4.6
  TOP w0.102: C5511.1 43.95,76.81 43.95,78.41 44.36,78.82 44.36,79.56 v2(44.59,79.79)
  BOTTOM w0.102: v2(44.59,79.79) 44.4,79.6 LCD1.15
EDP_AUX_CON_P: length 4.8
  TOP w0.102: C5510.1 43.73,76.89 43.73,78.51 44.13,78.92 44.13,79.51 v2(43.85,79.79)
  BOTTOM w0.102: v2(43.85,79.79) 44.17,79.47 44.17,79.27 44,79.09 LCD1.14
EDP_AUX_CPU_N: length 51
  TOP w0.102: v2(44.17,74.43) 44.02,74.57 44.02,75.51 C5511.2
  L8 w0.089: v2(44.17,74.43) 44.17,73.69 44.91,72.95 47.27,72.95 47.52,73.2 53.26,73.2 53.78,72.68 59.14,72.68 59.45,72.98 60.6,72.98 61.63,71.95 67.4,71.95 68.19,71.16 75.68,71.16 79.06,67.78 83.44,67.78 83.87,68.13 v2(84.97,68.13)
  BOTTOM w0.076: 84.98,67.03 84.14,66.18 84.14,65.04 84.14,64.97 84.14,64.88 84.31,64.7 84.31,64.4 84.05,64.13 CPU1.AH4
  BOTTOM w0.102: 84.98,67.03 85.08,67.03 85.33,67.28 85.33,67.74 84.98,68.1 84.98,68.12 v2(84.97,68.13)
EDP_AUX_CPU_P: length 51
  TOP w0.102: v2(43.38,74.43) 43.53,74.57 43.69,74.57 43.8,74.67 43.8,75.3 C5510.2
  L8 w0.089: v2(84.9,67.48) 84.79,67.38 84.5,67.38 84.41,67.46 84.41,67.85 84.32,67.94 83.94,67.94 83.51,67.59 78.98,67.59 75.6,70.97 68.11,70.97 67.32,71.76 61.55,71.76 60.52,72.79 59.53,72.79 59.22,72.49 53.7,72.49 53.18,73 47.6,73 47.35,72.76 44.99,72.76 44.99,72.76 44.83,72.76 43.98,73.61 43.98,73.92 43.48,74.43 v2(43.38,74.43)
  BOTTOM w0.076: CPU1.AH3 83.98,64.48 83.87,64.48 83.79,64.55 83.79,64.73 83.96,64.9 83.96,64.97 83.96,65.04 83.96,66.31 84.17,66.52
  BOTTOM w0.102: v2(84.9,67.48) 84.9,67.25 84.17,66.52
EDP_HPD_CON: length 27.9
  TOP w0.102: RN5505.2 61.01,85.63 61.01,87.29 RN5502.8 61.13,87.43 v2(61.79,87.43) ; v1(43.36,79.53) 43.26,79.63 v2(43.26,80.26)
  L5 w0.102: v2(61.79,87.43) 60.67,87.43 57.42,84.19 57.42,83.15 57.42,82.95 56.29,81.81 43.6,81.81 43.26,81.47 v2(43.26,80.26)
  BOTTOM w0.102: v2(43.26,80.26) 43.26,79.56 42.8,79.1 LCD1.11
EDP_HPD_CPU: length 86.4
  TOP w0.102: v2(60.24,85.1) 60.62,84.71 RN5505.3 ; v2(64.6,75.39) 64.2,74.99 v1(64.2,73.83) 64.2,71.1 64.96,70.34 65.48,70.34 65.8,70.02 v2(65.8,69.46)
  L5 w0.102: v2(65.8,69.46) 65.96,69.46 66.01,69.51 67.62,69.51 69.09,68.04 72.56,68.04 73.41,67.18 83.27,67.18 83.4,67.05 86.28,67.05 86.7,67.47 88.7,67.47 88.96,67.73 90.88,67.73 91.84,66.77 92,66.77 92.65,66.12 94.16,66.12 94.75,66.7 97.31,66.7 97.51,66.7 99.51,64.71 109.75,64.71 111.9,66.86 113.5,66.86 115.35,65.01 v2(115.35,62.64)
  BOTTOM w0.083: CPU1.CM7 111.39,61.52 112.22,61.52 112.48,61.58
  BOTTOM w0.102: v2(60.24,85.1) 60.67,85.1 61.15,84.61 61.15,82.89 60.62,82.35 60.62,77.83 60.29,77.5 60.29,76.54 60.46,76.36 60.46,75.44 62.31,73.6 63.44,73.6 63.75,73.91 63.76,73.91 64.38,74.52 64.38,75.16 64.6,75.38 64.6,75.39 v2(64.6,75.39) ; v2(115.35,62.64) 115.12,62.64 114.88,62.39 114.8,62.39 113.99,61.58 112.48,61.58
EDP_RCOMP_CPU: length 2.8
  TOP w0.127: v3(86.89,61.84) 87.07,61.84 R401.2 88.28,60.63 v1(88.61,60.63)
  BOTTOM w0.127: CPU1.AM6 86.79,61.84 v3(86.89,61.84)
EDP_TX_CON_N0: length 4.7
  TOP w0.102: C5506.1 45.22,76.86 45.22,78.02 45.56,78.36 45.56,79.52 v2(45.22,79.86)
  BOTTOM w0.102: LCD1.17 45.2,79.83 v2(45.22,79.86)
EDP_TX_CON_N1: length 7
  TOP w0.102: v2(45.99,80.87) 45.99,80.64 46.49,80.15 46.49,77.21 46.74,76.96 46.74,76.79 C5501.1
  BOTTOM w0.102: v2(45.99,80.87) 45.99,80.67 46.22,80.45 46.47,80.19 46.47,80.19 46.49,80.18 46.49,79.39 46.4,79.3 LCD1.20
EDP_TX_CON_P0: length 4.8
  TOP w0.102: v2(45.98,79.86) 45.79,79.67 45.79,78.27 45.44,77.92 45.44,76.95 45.71,76.69 C5509.1
  BOTTOM w0.102: v2(45.98,79.86) 45.6,79.48 LCD1.18
EDP_TX_CON_P1: length 6.2
  TOP w0.102: C5504.1 46.97,76.93 46.97,77.05 46.71,77.31 46.71,80.56 v2(46.65,80.62)
  BOTTOM w0.102: LCD1.21 46.8,79.3 46.71,79.39 46.71,80.56 v2(46.65,80.62)
EDP_TX_CPU_N0: length 57.5
  TOP w0.102: C5506.2 45.09,75.53 v2(45.09,74.38)
  L8 w0.089: v2(45.09,74.38) 45.34,74.63 45.34,74.91 45.55,75.12 51.64,75.12 52.41,74.35 53.77,74.35 54.36,73.77 58.66,73.77 58.97,74.07 61.18,74.07 62.17,73.08 79.77,73.08 80.59,72.26 85.08,72.26 85.76,71.57 v2(87.47,71.57)
  BOTTOM w0.076: 83.44,68.09 83.44,68.08 83.48,68.05 83.48,68.01 83.49,68 83.49,67.8 83.38,67.69 83.38,67.59 83.22,67.43 83.22,65.94 83.06,65.78 83.06,65.37 83.08,65.34 83.09,65.31 83.09,65.31 83.09,65.28 83.1,65.27 83.1,65.13 83.07,65.02 83.07,64.98 83.06,64.95 83.06,64.78 83.06,64.77 83.06,64.74 83.21,64.4 83.21,64.15 83.23,64.1 83.23,64.1 83.23,64.08 83.3,64 CPU1.AG4
  BOTTOM w0.102: 83.44,68.09 83.44,69.25 83.45,69.26 83.45,69.84 83.66,70.05 83.66,70.4 84.6,71.34 87.24,71.34 v2(87.47,71.57)
EDP_TX_CPU_N1: length 55.4
  TOP w0.102: C5501.2 46.63,75.56 46.64,75.46 46.64,75.16 46.64,75.14 46.64,75 46.64,74.68 46.64,74.68 v2(46.47,74.51)
  L8 w0.089: v2(87.43,69.02) 87.39,69.07 87.2,69.08 83.96,69.08 83.02,68.14 81.36,68.14 80.34,69.16 80.34,70.16 78.19,72.31 61.85,72.31 60.82,73.34 59.3,73.34 59,73.03 53.94,73.03 53.43,73.55 47.17,73.55 46.76,73.96 46.76,74.22 v2(46.47,74.51)
  BOTTOM w0.076: CPU1.AG2 83.7,65.33 83.75,65.45 83.75,66.89 84.37,67.51 84.37,68.08 84.38,68.09 84.38,69.46 84.58,69.66 84.58,69.99
  BOTTOM w0.102: 84.58,69.99 85.07,70.48 85.55,70.48 86.81,69.22 87.23,69.22 v2(87.43,69.02)
EDP_TX_CPU_P0: length 57.5
  TOP w0.102: v2(45.72,74.38) 45.31,74.78 45.31,75.28 C5509.2
  L8 w0.089: v2(45.72,74.38) 45.68,74.38 45.53,74.53 45.53,74.84 45.63,74.93 51.56,74.93 52.33,74.16 53.7,74.16 54.28,73.58 58.74,73.58 59.05,73.88 61.1,73.88 62.09,72.89 79.69,72.89 80.52,72.06 85,72.06 85.68,71.38 86.77,71.38 86.86,71.29 86.86,70.78 86.98,70.66 87.24,70.66 87.44,70.86 v2(87.44,70.94)
  BOTTOM w0.076: CPU1.AG3 83.38,64.43 83.38,64.44 83.28,64.68 83.26,64.7 83.23,64.76 83.23,64.79 83.22,64.81 83.22,64.92 83.23,64.95 83.23,64.99 83.25,65.04 83.27,65.06 83.27,65.34 83.25,65.35 83.24,65.4 83.23,65.41 83.23,65.45 83.23,65.45 83.23,65.7 83.39,65.86 83.4,65.92 83.4,67.35 83.56,67.51 83.56,67.62 83.67,67.73 83.67,68.09
  BOTTOM w0.102: 83.67,68.09 83.67,69.16 83.68,69.17 83.68,69.75 83.88,69.95 83.88,70.31 84.69,71.12 86.66,71.12 86.76,71.01 86.76,70.7 86.87,70.58 87.09,70.58 v2(87.44,70.94)
EDP_TX_CPU_P1: length 56.3
  TOP w0.102: v2(47.26,74.51) 47.1,74.67 46.97,74.67 46.87,74.77 46.87,75 46.87,75.14 46.87,75.32 46.88,75.34 47.21,75.67 C5504.2
  L8 w0.089: v2(87.47,69.67) 87.47,69.72 87.05,70.13 86.92,70.13 86.83,70.05 86.83,69.36 86.74,69.27 83.88,69.27 82.94,68.33 81.43,68.33 80.53,69.24 80.53,70.24 78.27,72.5 61.93,72.5 60.9,73.53 59.22,73.53 58.92,73.22 54.02,73.22 53.51,73.74 47.25,73.74 46.95,74.04 46.95,74.27 47.19,74.51 v2(47.26,74.51)
  BOTTOM w0.076: 84.42,70.15 84.41,70.15 84.41,70.09 84.39,70.07 84.39,69.91 84.41,69.9 84.41,69.74 84.2,69.53 84.2,68.17 84.19,68.15 84.19,67.58 83.57,66.97 83.57,65.93 CPU1.AG1
  BOTTOM w0.102: 84.42,70.15 84.98,70.71 85.65,70.71 86.91,69.45 87.25,69.45 v2(87.47,69.67)
EDP_VDD_EN: length 87.8
  TOP w0.102: v1(107.83,58.59) 107.51,58.91 v2(107.51,59.11)
  L5 w0.102: v2(51.31,74.2) 52.07,73.44 59.71,73.44 66.45,66.7 70.88,66.7 72.55,65.02 85.82,65.02 86.32,65.53 88.55,65.53 89.49,66.46 90.33,66.46 91.29,65.5 91.45,65.5 92.14,64.81 96.53,64.81 97.55,63.79 103.47,63.79 103.99,63.27 103.99,59.89 104.59,59.29 106.29,59.29 106.47,59.11 v2(107.51,59.11)
  L6 w0.102: v2(51.31,74.2) 52.12,75.01 53.42,75.01 54.28,75.87 57.72,75.87 60.9,79.05 v2(61.67,79.05)
  BOTTOM w0.102: CPU1.CG11 107.87,59.58 107.51,59.21 v2(107.51,59.11) ; D5501.1 65.66,84.44 63.84,82.62 62.94,82.62 61.67,81.35 v2(61.67,79.05)
EMMC_RCOMP: length 0.6
  BOTTOM w0.254: v2(110.33,56.74) 110.33,56.74 110.1,56.74 CPU1.CK15
EQ0: length 4.3
  TOP w0.102: U7101.38 17.26,34.58 v2(17.16,34.47)
  BOTTOM w0.102: R7142.2 15.34,34.07 16.33,34.07 v1(16.5,34.24) 16.92,34.24 v2(17.16,34.47) 17.16,35.13 R7143.1
EQ1: length 4.5
  TOP w0.102: U7101.35 17.17,35.78 16.75,35.36 16.22,35.36 v1(15.9,35.04) 15.1,35.04 14.99,34.94 R7141.1 R7140.2
ESPI_ALERT#: length 21.4
  TOP w0.089: R1821.2 113.07,36.8 v1(113.08,36.8) 113.07,36.8 113.07,36.97 112.34,37.71 111.74,37.71 109.98,39.47 109.05,39.47 107.5,37.92 107.17,37.92 106.91,38.18 106.91,40.07 102.92,44.06 102.92,47.79 v2(103.34,48.21)
  BOTTOM w0.089: v2(103.34,48.21) 103.34,48.26 103.11,48.49 CPU1.BV28
ESPI_CLK: length 127.9
  TOP w0.089: DB1.2 28.61,13.67 28,13.06 27.17,13.06 26.82,13.4 26.82,15.06 26.99,15.22 27.5,15.22 27.72,15.45 27.72,15.64 27.52,15.85 26.57,15.85 26.43,15.99 26.43,16.23 26.52,16.32 27,16.32 27.09,16.41 27.09,16.7 27,16.79 26.31,16.79 26.22,16.88 26.22,17.17 26.31,17.26 27,17.26 27.09,17.35 27.09,17.63 26.96,17.76 26.69,17.76 26.56,17.89 v2(26.56,18.23) ; R1805.2 113.88,34.03 v1(113.58,34.03) 113.34,34.03 v2(112.97,33.65)
  L8 w0.076: v2(26.56,18.23) 27,18.68 29.09,18.68 29.84,17.93 31.55,17.93 32.55,18.93 36.64,18.93 36.65,18.92 41.23,18.92 41.31,19 41.31,19.27 41.44,19.4 41.63,19.4 41.7,19.32 41.7,19 41.78,18.92 42.08,18.92 42.91,19.75 44.08,19.75 44.17,19.66 63.34,19.66 63.87,19.13 70.53,19.13 71.09,18.57 73.53,18.57 74.29,17.81 74.63,17.81 74.71,17.89 74.71,18.53 74.79,18.61 74.98,18.61 75.05,18.53 75.05,17.89 75.13,17.81 110.41,17.81 112.77,20.17 112.77,30.89 113.02,31.14 113.02,32.5 112.97,32.55 v2(112.97,33.65)
  BOTTOM w0.089: U2401.57 32.38,16.66 31.45,16.66 31.39,16.72 30.41,16.72 30.32,16.81 30.32,17.42 30.23,17.51 29.94,17.51 29.85,17.42 29.85,16.81 29.76,16.72 29.47,16.72 29.38,16.81 29.38,17.42 29.29,17.51 29,17.51 28.91,17.42 28.91,16.81 28.82,16.72 28.07,16.72 v2(26.56,18.23)
ESPI_CPU_CLK_R: length 19.1
  TOP w0.089: R1805.1 114.49,34.28 114.49,34.85 114.43,34.9 114.43,36.21 112.56,38.08 111.89,38.08 109.83,40.14 108.61,40.14 107.47,41.29 107.47,41.81 106.42,42.85 105.11,42.85 103.59,44.37 103.59,44.71 103.75,44.87 v1(103.75,45.77) v2(103.32,46.2)
  BOTTOM w0.089: v2(103.32,46.2) 103.22,46.2 CPU1.BV32
ESPI_CPU_IO0_R: length 23.5
  TOP w0.089: RN1806.1 v2(118.37,33.6) 118.74,33.96 v1(118.95,33.96)
  L5 w0.089: v2(105.23,47.48) 105.66,47.05 105.66,46.1 105.93,45.83 106.18,45.83 107,45.01 108.68,45.01 108.75,45.07 109.1,45.07 111.52,42.65 111.52,40.75 113.93,38.34 113.93,37.61 114.5,36.32 116.85,33.96 116.89,33.96 116.99,33.86 118.11,33.86 v2(118.37,33.6)
  BOTTOM w0.089: v2(105.23,47.48) 104.87,47.84 CPU1.CA29
ESPI_CPU_IO1_R: length 24.9
  TOP w0.089: RN1806.3 v2(118.23,31.86) 118.23,31.89 117.75,32.36 v1(117.75,32.47)
  L5 w0.089: v2(118.23,31.86) 118.22,31.86 118.02,32.06 118.02,32.1 117.77,32.35 117.58,32.35 116.39,32.76 116.21,32.93 113.81,35.87 113.81,35.9 112.98,37.35 112.98,37.36 112.84,37.6 112.57,37.86 112.06,38.28 110.72,39.62 110.72,41.01 110.58,41.15 110.58,41.65 110.58,41.65 110.58,42 109.96,42.62 107.12,43.47 106.52,43.75 105.02,45.25 105.02,45.53 104.63,45.92 104.63,46.4 104.27,46.76 v2(104.27,47.59)
  BOTTOM w0.089: CPU1.BY29 104.01,47.84 v2(104.27,47.59)
ESPI_CPU_IO2_R: length 25.5
  TOP w0.089: v1(104.74,48.53) 104.37,48.89 v2(104.28,48.89) ; RN1806.2 118.5,32.57 118.47,32.6 v2(118.25,32.72)
  L5 w0.089: v2(118.25,32.72) 117.46,33.51 116.84,33.51 116.74,33.61 116.71,33.61 116.55,33.76 116.24,33.76 114.88,35.12 114.18,35.98 113.57,37.48 113.57,38.19 111.29,40.47 111.29,42.22 110.53,42.98 106.77,44.73 106.35,45.15 105.7,45.15 104.83,46.02 104.83,46.63 104.77,46.69 104.77,48.41 v2(104.28,48.89)
  BOTTOM w0.089: v2(104.28,48.89) 104.03,49.14 CPU1.BY27
ESPI_CPU_IO3_R: length 26.2
  TOP w0.089: v1(118.95,30.51) RN1806.4 118.4,31.43 118.05,31.43 117.8,31.68 v2(117.59,31.92)
  L5 w0.089: v2(117.59,31.92) 116.21,32.41 115.78,32.85 113.56,35.55 113.43,35.85 112.55,37.38 112.34,37.6 108.58,40.6 108.4,40.78 108.33,40.93 108.33,41.5 108.22,41.71 106.83,43.1 106.56,43.26 104.39,44.99 104.23,45.15 103.83,46.08 103.79,46.43 103.79,48.29 103.63,48.61 v2(103.39,48.84)
  BOTTOM w0.089: v2(103.39,48.84) 103.09,49.14 CPU1.BV27
ESPI_CS#: length 123
  TOP w0.089: v1(31.32,15.86) 30.9,16.28 v3(30.83,16.28) 30.44,16.67 DB1.5
  L8 w0.076: v3(30.83,16.28) 32.82,18.28 36.38,18.28 36.38,18.28 43.87,18.28 44.49,18.9 59.9,18.9 61.02,17.78 73.36,17.78 73.98,17.16 110.68,17.16 113.5,19.98 113.5,24.53 113.86,24.9 113.86,25.48 113.57,25.76 113.57,30.77 114.24,31.44 114.24,33.58 110.94,36.88 110.94,37.49 110.94,38 109.64,39.3 109.47,39.3 107.45,41.31 107.45,42.83 105.65,44.63 105.65,47.73 v2(105.19,48.18)
  BOTTOM w0.089: CPU1.CA28 104.89,48.49 v2(105.19,48.18) ; U2401.58 32.37,16.25 30.87,16.25 v3(30.83,16.28)
ESPI_IO0: length 125.4
  TOP w0.089: DB1.9 29.83,20.67 30.48,20.03 31.48,20.03 31.77,19.73 31.77,18.4 32.89,17.29 32.89,16.56 v2(33.63,15.81) ; v2(123.75,17.13) 123.7,17.13 123.14,17.69 123.14,19.29 123.16,19.31 123.16,21.41 123.14,21.43 123.14,22.38 122.88,22.64 v1(122.88,28.99) 122.88,31.08 120.91,33.05 RN1806.8
  L8 w0.076: v2(33.63,15.81) 34.57,15.81 35.47,14.91 35.47,13.86 36.31,13.02 43.81,13.02 43.99,13.2 52.08,13.2 53.23,14.34 71.73,14.34 72.62,13.45 84.99,13.45 86.18,12.26 87.29,12.26 87.35,12.32 90.75,12.32 91.41,11.66 107.93,11.66 108.26,11.33 117.53,11.33 118.23,10.63 119.68,10.63 120.9,11.85 120.9,13.76 122.37,15.23 122.37,15.75 v2(123.75,17.13)
  BOTTOM w0.089: U2401.59 33.58,15.87 v2(33.63,15.81)
ESPI_IO1: length 127.5
  TOP w0.089: RN1806.6 120.86,31.96 121.97,30.85 v1(121.97,25.55) 121.97,22.54 122.43,22.08 122.43,16.45 123.04,15.84 v2(123.94,15.84) ; v2(34.54,14.82) 33.97,15.39 33.46,15.39 32.53,16.31 32.53,17.14 31.42,18.26 31.42,19.58 31.33,19.67 DB1.8
  L8 w0.076: v2(123.94,15.84) 123.75,15.84 123.22,15.32 123.22,15.15 121.51,13.44 121.51,11.6 119.94,10.03 117.98,10.03 117.28,10.72 108,10.72 107.67,11.05 91.15,11.05 90.5,11.71 87.61,11.71 87.55,11.65 84.97,11.65 84.4,12.22 82.07,12.22 81.44,12.84 72.37,12.84 71.48,13.73 53.71,13.73 52.57,12.59 44.24,12.59 44.06,12.41 39.87,12.41 39.08,11.63 36.62,11.63 35.08,13.17 35.08,13.21 34.54,13.74 v2(34.54,14.82)
  BOTTOM w0.089: U2401.60 33.38,15.47 33.46,15.39 33.97,15.39 v2(34.54,14.82)
ESPI_IO2: length 124.9
  TOP w0.089: v2(123.72,16.47) 123.52,16.47 122.78,17.21 122.78,22.23 122.37,22.65 v1(122.37,27.43) 122.37,30.96 120.86,32.47 RN1806.7 ; DB1.7 30.5,18.67 32.18,17 32.18,16.17 33.41,14.93 v2(33.69,14.93)
  L8 w0.076: v2(123.72,16.47) 122.67,15.42 122.67,15.04 121.2,13.57 121.2,11.72 119.81,10.33 118.11,10.33 117.41,11.03 108.13,11.03 107.8,11.36 91.28,11.36 90.62,12.01 87.48,12.01 87.42,11.95 85.09,11.95 83.9,13.15 72.49,13.15 71.6,14.04 53.36,14.04 52.21,12.89 44.11,12.89 43.94,12.72 39.74,12.72 38.95,11.93 36.74,11.93 35.38,13.29 35.38,13.33 35.17,13.55 35.17,14.78 34.72,15.23 33.99,15.23 v2(33.69,14.93)
  BOTTOM w0.089: U2401.61 33.37,15.07 33.5,14.93 v2(33.69,14.93)
ESPI_IO3: length 122.6
  TOP w0.089: v2(33.65,14.19) 33.26,14.59 33.16,14.59 31.25,16.5 31.25,17.31 30.89,17.67 DB1.6 ; RN1806.5 120.86,31.38 121.39,30.85 v1(121.39,24.37) 121.39,22.62 122.07,21.94 122.07,16.3 123.24,15.14 123.66,15.14 123.66,15.15 v2(123.65,15.15)
  L8 w0.076: v2(33.65,14.19) 33.66,14.19 34.77,13.08 34.77,13.04 36.49,11.32 39.21,11.32 39.99,12.11 44.19,12.11 44.37,12.28 81.57,12.28 81.94,11.91 84.27,11.91 84.84,11.34 87.48,11.34 88.1,10.72 107.57,10.72 107.88,10.42 117.16,10.42 117.85,9.72 120.06,9.72 121.81,11.47 121.81,11.72 121.81,13.32 v2(123.65,15.15)
  BOTTOM w0.089: v2(33.65,14.19) 33.18,14.67 U2401.62
ESPI_RESET#: length 134.5
  TOP w0.089: v1(31.24,14.65) 30.22,15.67 DB1.4 28.22,15.67 27.44,16.45 27.44,18.13 27.48,18.17 v2(27.48,18.19)
  L8 w0.076: v2(27.48,18.19) 27.49,18.19 27.55,18.13 28.51,18.13 29.1,17.54 31.65,17.54 32.69,18.58 36.5,18.58 36.51,18.58 43.74,18.58 44.36,19.2 63.32,19.2 63.76,18.76 70.37,18.76 71.04,18.08 73.49,18.08 74.1,17.47 110.27,17.47 110.56,17.47 113.11,20.02 113.11,24.58 113.56,25.02 113.56,25.35 113.22,25.69 113.22,30.85 113.36,31 113.36,32.2 113.93,32.77 113.93,33.45 110.63,36.76 110.63,36.95 110.63,37.37 110.17,37.83 109.29,37.83 107.94,39.17 107.94,40.28 107.41,40.82 106.69,40.82 106.04,41.47 106.04,42.47 105.07,43.45 105.07,45.7 104.77,46 104.77,48.45 v2(105.17,48.84)
  BOTTOM w0.089: CPU1.CA27 104.87,49.14 v2(105.17,48.84) ; v2(27.48,18.19) 27.49,18.19 27.57,18.27 U2401.53
EXT_PWR_GATE#: length 10.6
  BOTTOM w0.127: CPU1.CC37 105.84,42.83 105.84,38.97 105.42,38.55 105.42,38.25 105.41,38.24 105.41,37.95 105.42,37.94 105.42,37.9 105.85,37.47 107.07,37.47 107.11,37.43 v1(109.63,37.43) 110.07,37.88 R1731.2
FAN1_PWM: length 221.4
  TOP w0.254: v2(190.89,35) 190.3,35 AFTP2602.1 189.98,34.84 EC2602.1
  L3 w0.254: v2(194.98,12.43) 194.98,12.18 194.78,11.98 194.78,11.44 194.89,11.32 194.89,8.59 193.33,7.03 193.33,5.95 192.53,5.15 168.38,5.15 v2(168.02,5.51)
  L5 w0.254: v2(194.98,12.43) 194.94,12.47 194.94,12.58 194.39,13.13 194.39,16.43 195.72,17.76 195.72,23.73 192.7,26.75 191.8,26.75 190.56,27.99 190.56,33.89 190.89,34.22 v2(190.89,35)
  L8 w0.254: v2(168.02,5.51) 166.79,6.74 156.77,6.74 154.54,4.51 150.75,4.51 150.43,4.82 149.84,4.82 149.4,5.26 138.16,5.26 137.39,6.04 131.72,6.04 130.73,5.05 125.3,5.05 124.97,5.38 124.95,5.38 124.91,5.42 121.88,5.42 120.9,6.39 119.81,6.39 118.43,7.77 102.72,7.77 101.42,9.07 86.81,9.07 86.66,9.23 76.62,9.23 76.25,9.6 70.38,9.6 70.07,9.91 59.78,9.91 56.59,6.72 v2(38,6.72)
  BOTTOM w0.203: 33.57,20.67 U2401.47
  BOTTOM w0.254: v2(38,6.72) 36.93,7.79 36.93,11.57 37.2,11.84 37.8,11.84 v1(39.1,13.14) 39.1,13.15 39.24,13.29 39.24,15.8 38.64,16.4 38.64,17.38 36.66,19.36 36.66,20.25 36.24,20.67 33.57,20.67 ; FAN1.4 v2(190.89,35)
FAN1_TACH: length 17.7
  TOP w0.254: D2403.A 22.3,18.35 22.3,19.02 21.88,19.44 21.88,21.1 22.03,21.25 22.03,22.64 23.98,24.59 24.16,24.59 24.19,24.62 v1(24.47,24.62) 24.99,24.62 25.89,23.72 v2(25.89,23.68) 25.77,23.68 25.21,23.12 R2430.2
  BOTTOM w0.203: 30.98,23.29 31.32,23.29 31.5,23.47 U2401.40
  BOTTOM w0.254: v2(25.89,23.68) 26.62,22.94 28.3,22.94 28.65,23.29 30.98,23.29
FAN_TACH1: length 224.4
  TOP w0.254: EC2601.1 189.36,35.68 AFTP2601.1 190.94,36.07 v2(191.07,36.07) ; D2403.K 24.57,15.63 v2(24.6,15.59)
  L3 w0.254: v2(167.02,4.37) 191.19,4.37 191.37,4.55 192.75,4.55 193.84,5.64 193.84,6.82 195.4,8.38 195.4,11.53 195.29,11.65 v2(195.29,11.77)
  L5 w0.254: v2(35.01,6.31) 35.02,6.31 35.02,6.3 34.87,6.3 34.53,6.63 33.15,6.63 31.03,8.75 31.03,9.3 30.47,9.85 28.64,9.85 27.35,11.14 27.35,11.91 24.6,14.66 v2(24.6,15.59) ; v2(195.29,11.77) 196.52,12.99 196.52,23.79 192.67,27.64 192.35,27.64 191.07,28.92 191.07,31.79 191.66,32.37 191.66,35.49 v2(191.07,36.07)
  L8 w0.254: v2(167.02,4.37) 165.16,6.24 156.98,6.24 154.75,4 150.54,4 150.22,4.32 149.63,4.32 149.19,4.75 137.95,4.75 137.18,5.53 131.93,5.53 130.94,4.54 125.09,4.54 124.76,4.87 124.74,4.87 124.7,4.91 121.67,4.91 120.69,5.89 119.6,5.89 118.27,7.22 102.17,7.22 100.82,8.57 86.6,8.57 86.45,8.72 69.63,8.72 69.46,8.54 59.14,8.54 56.64,6.05 36.62,6.05 36.61,6.06 35.27,6.06 35.02,6.31 v2(35.01,6.31)
  BOTTOM w0.254: v2(191.07,36.07) 191,36 FAN1.3
FB_CAL_PD_VDDQ: length 11.8
  TOP w0.305: R7805.2 v1(174.38,65.85) 174.38,65.77 174.82,65.33 v2(175.12,65.33)
  L3 w0.457: 170.18,62.61 169.6,62.61 169.59,62.62 168.09,62.62 v2(167.51,63.2)
  L3 w0.508: 170.18,62.61 171.11,63.53 171.11,64.04 171.39,64.32 172.86,64.32 173.88,65.33 v2(175.12,65.33)
  BOTTOM w0.254: v2(167.51,63.2) 167.51,62.56 GPU1.D22
FB_CAL_PU_GND: length 11.6
  TOP w0.508: v2(176.1,66.07) 176.11,66.07 v1(176.67,66.63) 176.67,66.7 R7807.1
  L3 w0.508: v2(176.1,66.07) 176.1,66.21 175.35,66.96 171.44,66.96 170.32,65.84 170.32,65.54 169.86,65.08 169.86,64.68 169.27,64.09 v2(169.27,63.76)
  BOTTOM w0.305: v2(169.27,63.76) 169.28,63.76 GPU1.C24
FB_CAL_TERM_GND: length 10.2
  TOP w0.305: v2(175.17,66.09) 175.76,65.51 v1(175.76,65.34)
  TOP w0.508: R7806.1 175.12,67.24 175.12,66.15 v2(175.17,66.09)
  L3 w0.508: v2(175.17,66.09) 174.94,66.32 173.96,66.32 173.94,66.35 171.95,66.35 170.92,65.32 170.92,65.29 170.46,64.84 170.46,64.43 170.45,64.42 170.45,64.01 169.88,63.45 169.88,63.24 v2(169.84,63.19)
  BOTTOM w0.203: GPU1.B25 169.89,63.2 169.89,63.19 v2(169.84,63.19)
FBA_CLK0_MIDPT: length 1.7
  TOP w0.114: C8101.1 183,42.96 R8102.2 R8101.2
FBA_CLK0N: length 37.5
  TOP w0.114: R8102.1 v2(183,46.92)
  L3 w0.102: v2(183,46.92) 183,46.93 182.77,47.15 182.77,47.3 183.07,47.59 183.07,49.13 183.59,49.65 183.59,50.12 183.59,50.26 v2(183.89,50.56)
  L8 w0.102: v2(168.11,63.75) 168.81,64.44 179.17,64.44 182.65,60.96 182.65,60.46 183.3,59.81 183.3,58.86 182.38,57.94 182.38,57 183.83,55.55 183.83,55.11 182.28,53.56 182.28,52.3 183.7,50.89 v2(183.89,50.56)
  BOTTOM w0.114: v2(183.89,50.56) 183.89,50.57 VRAM1.J11 ; v2(168.11,63.75) 168.42,64.06 GPU1.D25
FBA_CLK0P: length 37.5
  TOP w0.114: v2(182.35,46.93) 182.24,46.82 R8101.1
  L3 w0.102: v2(183.09,50.56) 183.39,50.26 183.39,50.12 183.39,49.73 182.87,49.21 182.87,47.68 182.57,47.38 182.57,47.15 v2(182.35,46.93)
  L8 w0.102: v2(168.71,63.2) 168.71,63.63 168.56,63.79 168.56,63.91 168.89,64.24 179.08,64.24 182.44,60.88 182.44,60.38 183.1,59.73 183.1,58.94 182.18,58.03 182.18,56.92 183.63,55.47 183.63,55.19 182.08,53.64 182.08,52.22 183.49,50.81 183.49,50.66 183.39,50.56 v2(183.09,50.56)
  BOTTOM w0.114: VRAM1.J12 183.33,49.99 183.19,49.99 183.09,50.09 v2(183.09,50.56) ; GPU1.D24 168.51,63.56 168.51,63.4 v2(168.71,63.2)
FBA_CLK1_MIDPT: length 1.5
  TOP w0.114: R8208.1 R8206.1 179.13,87.23 C8201.1
FBA_CLK1N: length 45.8
  TOP w0.114: v2(179.23,84.47) 178.89,84.77 178.89,86.12 R8206.2
  L8 w0.102: v2(163.4,67.28) 162.95,67.26 161.59,67.26 160.95,67.44 160.42,67.77 158.13,70.06 158.13,70.92 157.1,72.88 157.06,72.92 157.06,76.1 157.5,77.44 160.01,79.95 164.24,83.29 172.07,85.19 178.5,85.19 178.92,84.77 v2(179.23,84.47) 179.23,84.17 179.7,83.69 179.7,81.73 179.48,81.51 179.06,81.51 v2(178.81,81.27)
  BOTTOM w0.114: GPU1.M22 163.37,67.31 v2(163.4,67.28) ; VRAM4.J11 179.2,80.88 v2(178.81,81.27)
FBA_CLK1P: length 45.6
  TOP w0.114: v2(178.36,84.42) 178.65,84.74 178.65,86.08 R8208.2
  L8 w0.102: v2(162.85,67.89) 162.97,67.78 162.97,67.59 162.84,67.46 161.62,67.46 161.03,67.63 160.54,67.93 158.33,70.15 158.33,70.98 157.26,73 157.26,76.06 157.68,77.33 160.15,79.8 164.33,83.11 172.1,84.99 178.42,84.99 178.71,84.69 178.71,84.53 178.6,84.42 v2(178.36,84.42) 178.36,84.15 178.46,84.05 179.06,84.05 179.5,83.61 179.5,81.82 179.4,81.72 178.9,81.72 178.79,81.82 v2(178.79,82.08)
  BOTTOM w0.114: VRAM4.J12 178.97,81.67 178.79,81.85 v2(178.79,82.08) ; GPU1.N22 162.84,67.88 v2(162.85,67.89)
FBA_CMD0: length 23.6
  BOTTOM w0.114: GPU1.C27 171.44,65.36 171.97,65.36 172.19,65.14 172.19,64.24 172.81,63.62 172.81,56.69 176.69,52.81 181.57,52.81 182.22,52.15 182.22,50.48 VRAM1.G12
FBA_CMD1: length 23.4
  BOTTOM w0.114: VRAM1.H10 182.7,52.08 181.67,53.12 176.99,53.12 173.24,56.87 173.24,63.66 172.48,64.42 172.48,65.16 172.08,65.56 171.13,65.56 170.41,64.84 GPU1.C26
FBA_CMD2: length 26
  TOP w0.114: v2(183.71,52.99) 177.07,52.99 170.8,59.26 170.8,62.81 169.45,64.17 168.76,64.17 168.54,64.39 v2(167.55,64.39)
  BOTTOM w0.114: GPU1.E24 167.58,64.36 v2(167.55,64.39) ; VRAM1.H11 183.07,51.33 183.07,52.36 v2(183.71,52.99)
FBA_CMD3: length 31.8
  TOP w0.114: v2(183.88,51.38) 183.88,51.82 184.42,52.35 184.42,53.16 183.31,54.27 177.47,54.27 176.6,55.13 176.44,55.13 176.07,54.76 175.91,54.76 175.75,54.92 175.75,55.08 176.12,55.45 176.12,55.62 175.96,55.78 175.8,55.78 175.43,55.41 175.26,55.41 175.1,55.57 175.1,55.73 175.47,56.1 175.47,56.26 175.07,56.67 175.07,57.55 174.96,57.67 174.66,57.67 174.55,57.78 174.55,58.01 174.66,58.12 174.96,58.12 175.07,58.24 175.07,58.47 174.96,58.58 174.66,58.58 174.55,58.69 174.55,58.92 174.66,59.04 174.96,59.04 175.07,59.15 175.07,59.38 174.96,59.49 174.66,59.49 174.55,59.61 174.55,59.84 174.66,59.95 174.96,59.95 175.07,60.07 175.07,60.5 174.1,61.47 174.1,61.72 173.66,62.16 172.74,62.16 170.88,64.03 170.88,64.4 170.76,64.52 169.08,64.52 168.68,64.92 v2(168.12,64.92)
  BOTTOM w0.114: VRAM1.K11 184.29,50.96 v2(183.88,51.38) ; v2(168.12,64.92) 167.56,64.92 GPU1.F24
FBA_CMD4: length 25
  BOTTOM w0.114: GPU1.D27 170.76,65.81 172.13,65.81 172.68,65.25 172.68,65.11 172.68,64.65 173.67,63.65 173.67,57.05 177.25,53.47 184.14,53.47 184.3,53.31 VRAM1.K10
FBA_CMD5: length 28.3
  BOTTOM w0.114: VRAM1.L12 184.65,50.61 184.65,53.42 184.24,53.83 177.51,53.83 174.1,57.23 174.1,63.83 172.95,64.98 172.95,65.27 172.14,66.08 170.56,66.08 170.07,65.6 170.07,65.12 GPU1.D26
