# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_DDI_TX_P1: length 85.5
  TOP w0.102: C5707.1 24.59,51 25.2,51 25.36,50.83 25.92,50.83 v2(26.2,50.55)
  L3 w0.089: v3(84.09,61.9) 84.67,62.49 84.67,63.5 82.74,65.43 72.91,65.43 71.13,67.21 63.22,67.21 58.65,71.79 53.45,71.79 51.16,69.5 45.26,69.5 44.36,68.6 40.03,68.6 39.09,67.66 37.99,67.66 37.97,67.68 37.83,67.68 37.6,67.91 37.6,68.23 37.32,68.51 36.2,68.51 33.06,65.36 33.06,64.71 32.44,64.09 32.44,62.53 31.61,61.7 31.61,58.97 29.4,56.76 24.98,56.76 24.57,56.35 24.57,50.98 25,50.55 v2(26.2,50.55)
  BOTTOM w0.102: CPU1.AJ6 84.36,62.18 v3(84.09,61.9)
HDMI_DDI_TX_P2: length 73.2
  TOP w0.102: C5705.1 24.51,54.47 25.1,54.47 v2(25.3,54.27)
  L3 w0.089: v2(82.29,63.08) 82.56,62.81 82.84,62.81 82.93,62.9 82.93,64.01 82.37,64.57 72.48,64.57 70.61,66.44 62.7,66.44 59.19,69.95 54.97,69.95 53.35,68.33 51.39,68.33 50.96,68.76 46.61,68.76 45.6,67.76 40.23,67.76 39.39,66.92 36.72,66.92 35.39,65.59 35.39,64.22 32.42,61.25 32.42,58.74 28.97,55.29 26.68,55.29 26.26,54.87 25.71,54.87 25.59,54.75 25.59,54.37 25.49,54.27 v2(25.3,54.27)
  BOTTOM w0.102: v2(82.29,63.08) 82.54,62.83 CPU1.AF5
HDMI_DDI_TX_P3: length 70.3
  TOP w0.102: C5703.1 24.46,52.77 25.73,52.77 v2(25.9,52.6)
  L3 w0.089: v2(25.9,52.6) 26.19,52.89 26.67,52.89 27.03,53.24 28.04,53.24 28.38,52.91 28.95,52.91 29.62,53.57 29.62,55.12 33.04,58.55 33.04,61.09 35.94,63.99 35.94,65.37 36.92,66.34 44.33,66.34 44.88,66.89 45.76,66.89 46.58,67.72 49.84,67.72 50.51,67.05 52.09,67.05 55.8,63.34 78.78,63.34 80.19,61.93 80.72,61.93 80.85,62.06 81.09,62.06 v2(81.37,61.78)
  BOTTOM w0.102: CPU1.AE6 81.39,61.87 v2(81.37,61.78)
HDMI_HPD_B: length 3.5
  TOP w0.102: R5711.2 19.25,60.05 v1(18.66,59.47) 18.38,59.19 v2(17.59,59.19)
  BOTTOM w0.102: v2(17.59,59.19) 17.39,59.38 17.39,59.88 Q5701.B
HDMI_HPD_CPU: length 119.9
  TOP w0.102: R5712.1 20.15,58.9 v2(20,58.76) 19.72,58.48 v1(19.38,58.48)
  L5 w0.102: v2(20,58.76) 20,60.58 19.7,60.89 19.7,62.33 19.8,62.43 19.8,62.43 20.48,63.12 20.89,63.12 22.87,65.11 23.44,65.11 25.04,66.71 26.48,66.71 27.98,68.2 34.04,68.2 34.37,68.53 37.09,68.53 37.59,68.02 37.59,67.91 37.83,67.67 37.94,67.67 37.95,67.67 39.22,67.67 40.38,68.83 40.38,72.51 43.01,75.14 48.25,75.14 49.43,73.97 50.26,73.97 50.51,74.22 50.51,74.4 51.04,74.94 52.94,74.94 53.94,73.93 59.79,73.93 66.62,67.11 71.04,67.11 72.72,65.43 84.53,65.43 85.26,66.16 85.62,66.16 85.81,65.96 88.41,65.96 89.32,66.87 90.5,66.87 91.45,65.91 91.62,65.91 92.31,65.22 96.7,65.22 97.69,64.22 112.79,64.22 v2(113.34,63.68)
  BOTTOM w0.102: v2(20,58.76) 19.93,58.83 18.24,58.83 Q5701.E ; CPU1.CN6 111.35,62.43 111.71,62.79 112.71,62.79 113.34,63.41 v2(113.34,63.68)
HDMI_PLL_GND:
  vias: v1(20.76,47.96)
HOST_DEBUG_TX: length 22
  TOP w0.102: R2480.2 33.32,13.24 v1(33.37,13.19) ; R2480.2 32.51,12.5 R6801.1 32.32,12.22 32.32,11.24 34.5,9.06 34.5,8.47 33.41,7.38 32.44,7.38 31.78,8.04 DB3.5 ; R2480.2 31.93,13.83 31.21,13.83 31.11,13.73 31.11,12.76 30.18,11.83 27.87,11.83 27.55,12.15 26.67,12.15 25.33,13.49 v2(24.49,13.49)
  BOTTOM w0.102: v2(24.49,13.49) 24.57,13.41 U2401.81
HOST_DEBUG_TX_CON: length 18.3
  TOP w0.102: R6801.2 35.86,12.26 36.57,12.98 36.57,14.15 36.41,14.3 35.84,14.3 33.31,16.84 33.31,17.38 32.14,18.55 v1(32.14,19) 32.14,20.02 32.13,20.03 32.13,20.32 32.14,20.33 32.14,21.92 31.24,22.82 29.25,22.82 DB1.11
HPD_HDMI_CON: length 12.9
  TOP w0.102: v2(14.12,65.07) 15.21,65.07 15.78,64.5 ED5703.2 ED5703.9 15.78,61.98 16.06,61.69 16.08,61.69 16.1,61.67 16.46,61.67 16.47,61.69 16.81,61.69 17.03,61.92 v1(17.53,61.92) 18.13,61.92 18.38,61.68 R5710.1 18.39,61.39 R5711.1
  L8 w0.102: HDMI1.19 11.01,64.28 11.96,64.28 12.75,65.07 v2(14.12,65.07)
HPDIN: length 2.5
  TOP w0.102: U7101.32 v2(17.25,36.98)
  BOTTOM w0.102: R7121.2 16.73,36.25 v1(17.4,36.25) 17.25,36.4 v2(17.25,36.98)
HVA_GATE1: length 3.1
  BOTTOM w0.102: U7201.B9 25.08,64.15 25.34,64.41 25.34,65.28 25.83,65.77
  BOTTOM w0.254: 25.83,65.77 26.18,65.77 26.55,66.15 R7218.1
HVA_GATE2: length 2.8
  BOTTOM w0.102: 25.33,65.84 25.08,65.58 U7201.A9
  BOTTOM w0.254: R7219.1 25.63,67.08 v1(25.63,66.32) 25.63,66.1 25.36,65.84 25.33,65.84
HW_ACAV_IN: length 217.7
  TOP w0.254: PR4490.1 144.21,3.75 145.49,5.03 v1(147.92,5.03) 149.61,5.03 v2(150,5.42)
  L3 w0.254: v2(111.43,4.61) 111.43,5.11 109.93,6.62 108.97,6.62 103.69,11.9 91.5,11.9 90.16,13.24 88.83,13.24 88.55,13.52 70.3,13.52 69.99,13.82 61.62,13.82 60.17,12.36 50.73,12.36 50.72,12.37 50.3,12.37 50.29,12.36 42.59,12.36 42.52,12.43 38.53,12.43 37.9,11.79 30.97,11.79 30.43,12.34 30.34,12.34 30.3,12.37 28.43,12.37 28.39,12.34 26.69,12.34 25.12,10.76 23.86,10.76 23.39,10.28 23.24,10.28 22.16,9.2 17.97,9.2 v2(16.18,10.99)
  L6 w0.254: v2(16.18,10.99) 15.5,11.67 15.5,15.4 14.8,16.09 14.8,18.61 15.22,19.02 15.22,21.67 17.1,23.56 17.1,26.81 v2(17.15,26.86) 16.65,27.36 16.65,28.92 16.96,29.24 17.46,29.24 19.79,31.56 19.79,33.34 18.7,34.43 18.7,37.46 20.65,39.4 20.65,40.88 20.15,41.38 20.15,44.05 20.4,44.31 20.4,54.99 21.55,56.14 21.55,58.31 19.8,60.06 19.8,61.11 18.61,62.3 18.61,63.66 17.64,64.63 17.64,66.07 v2(18.14,66.57)
  BOTTOM w0.254: D6402.K 18.59,66.12 v2(18.14,66.57) ; v2(111.43,4.61) 111.43,4.52 111.87,4.08 113.01,4.08 114.79,2.3 135.81,2.3 137.43,3.92 137.51,3.92 137.84,4.25 144.07,4.25 144.92,3.4 145.64,3.4 146.5,2.54 148.08,2.54 148.28,2.74 148.28,3 150.02,4.74 150.02,5.4 v2(150,5.42) ; U2401.128 v2(17.15,26.86)
HW_ACAVIN_NB: length 183
  TOP w0.254: R4378.2 33.14,59.54 33.39,59.29 33.39,56.75 v2(33.19,56.55) 32.75,56.11 32.75,50 31.2,48.45 v1(31.2,45.69) 31.2,44.87 29.47,43.14 29.47,41.26 29.68,41.05 29.68,38.37 29.7,38.35 29.7,38.34 31,37.05 31,35.44 32.04,34.4 32.04,34.3 32.03,34.3 32.03,33.97 32.02,33.96 32.02,33.24 32.03,33.22 32.03,32.61 32.57,32.06 32.57,27.78 v2(32.45,27.65) ; v3(138.77,3.41) 138.63,3.55 PR4471.1
  L3 w0.254: v2(32.45,27.65) 30.7,25.9 26.39,25.9 25.92,25.44 v2(25.92,25.33) ; v2(27.34,7.1) 27.5,7.26 64.78,7.26 65.67,8.15 70.21,8.15 71.07,9.01 81.38,9.01 81.6,8.78 82.4,8.78 82.85,9.22 102.04,9.22 108.81,2.45 110.02,2.45 110.84,2.44 110.96,2.43 111.11,2.43 129.7,2.43 129.91,2.23 132.67,2.23 132.87,2.43 135.48,2.43 135.9,2.85 138.2,2.85 v3(138.77,3.41)
  L6 w0.254: v2(27.34,7.1) 27.34,9.46 26.71,10.1 26.71,15.88 26.05,16.54 26.05,19.72 26.57,20.24 26.57,23.79 26.25,24.11 26.25,24.8 25.92,25.12 v2(25.92,25.33)
  BOTTOM w0.203: U2401.24 27.77,27.09 27.7,27.02 27.7,26.96 27.57,26.82 27.34,26.82 25.92,25.41 v2(25.92,25.33)
  BOTTOM w0.254: U4302.1 33.19,56.8 v2(33.19,56.55)
I2C_CLK_PD: length 40.5
  TOP w0.127: v1(22.24,45.17) 21.73,44.66 v2(21.73,44.57) 21.42,44.26 21.42,43.67 21.67,43.42 R7114.2
  L8 w0.127: v2(21.73,44.57) 21.45,44.29 21.45,43.45 22.29,42.6 23.65,42.6 23.96,42.92 23.96,44.09 25.31,45.43 26.2,45.43 26.8,46.03 26.8,47.12 28.75,49.07 29.83,49.07 29.93,49.16 29.93,56.7 32.86,59.63 33.65,59.63 34.51,60.49 34.51,62.94 34.27,63.17 33.34,63.17 v2(33.06,62.89)
  BOTTOM w0.127: RN7206.3 33.11,62.84 v2(33.06,62.89) 32.78,63.17 32.49,63.17 32.02,63.64 31.24,63.64 30.89,63.29 30.58,63.29 30.38,63.09 30.24,63.09 30.07,62.92 29.67,62.92 29.63,62.89 28.97,62.89 28.96,62.9 28.9,62.9 28.66,63.14 U7201.D2
I2C_CLK_PD_MUX: length 3.6
  TOP w0.127: 21.43,41 21.43,40.46 21.3,40.33 21.3,39.51 21.37,39.44 U7101.21 ; 21.43,41 21.43,41.35 21.42,41.36 21.42,41.54 21.67,41.79 R7114.1 ; 21.43,41 v1(21.61,41)
I2C_DATA_PD: length 40.9
  TOP w0.127: R7116.2 20.91,43.28 21.17,43.53 21.17,44.31 v2(20.91,44.57) v1(20.91,45.14)
  L8 w0.127: v2(33.06,63.71) 33.34,63.43 34.38,63.43 34.76,63.05 34.76,60.38 33.75,59.38 32.97,59.38 30.19,56.6 30.19,49.06 29.94,48.81 28.85,48.81 27.05,47.01 27.05,45.92 26.31,45.18 25.41,45.18 24.22,43.99 24.22,42.81 23.75,42.35 22.19,42.35 21.19,43.34 21.19,44.29 v2(20.91,44.57)
  BOTTOM w0.127: U7201.D1 29.53,63.14 29.56,63.18 29.96,63.18 30.13,63.35 30.27,63.35 30.47,63.55 30.78,63.55 31.13,63.9 32.13,63.9 32.6,63.43 32.78,63.43 v2(33.06,63.71) 33.26,63.51 RN7206.4
I2C_DATA_PD_MUX: length 3.5
  TOP w0.127: U7101.22 20.97,39.44 21.05,39.51 21.05,40.44 21.17,40.57 21.17,41.25 21.17,41.25 21.17,41.54 20.91,41.79 R7116.1
I2CB_SCL: length 9.1
  TOP w0.127: RN7905.1 160.61,54.07 160.34,54.07 v1(159.98,53.71) 159.98,53.44 160.47,52.96 160.47,52.64 160.48,52.63 160.48,51.91 161.2,51.19 162.09,51.19 v2(162.16,51.12)
  BOTTOM w0.127: v2(162.16,51.12) 162.16,51.17 162.04,51.29 162.04,51.65 162.04,51.65 162.04,52.05 160.93,53.16 160.93,53.36 160.5,53.79 GPU1.C9
I2CB_SDA: length 6.1
  TOP w0.127: v2(161.55,51.6) 161.14,51.6 160.74,52.01 160.74,52.71 v1(160.81,52.79) 160.83,52.81 160.83,53.35 RN7905.2
  BOTTOM w0.127: v2(161.55,51.6) 161.21,51.61 160.8,52.02 160.8,52.26 160.19,52.88 160.19,52.89 159.9,53.17 GPU1.C8
I2CC_SCL: length 7.2
  TOP w0.127: RN7904.2 163.45,52.86 163.45,52.4 163.1,52.05 v1(163.1,51.7) 163.17,51.64 163.17,50.13 v2(163.22,50.08)
  BOTTOM w0.127: v2(163.22,50.08) 163.22,51.14 162.51,51.84 162.51,52.28 161.63,53.16 GPU1.A9
I2CC_SDA: length 7.1
  TOP w0.127: v2(162.71,50.59) 162.92,50.8 162.92,50.98 v1(161.84,52.05) 162.22,52.44 162.52,52.44 RN7904.1
  BOTTOM w0.127: GPU1.B9 161.26,53.65 161.26,53.29 161.26,53.17 161.45,52.98 162.25,52.17 162.25,51.74 162.71,51.28 v2(162.71,50.59)
I2CEN: length 4.6
  TOP w0.102: v2(22.87,37.01) 22.84,36.98 U7101.17
  BOTTOM w0.102: R7174.2 21.66,39.13 21.18,38.65 v1(21.18,38.48) 21.35,38.48 22.27,37.57 R7173.1 22.33,37.27 22.67,36.94 22.81,36.94 v2(22.87,37.01)
I_ADP: length 5.9
  TOP w0.102: C2435.1 17.95,20.04 18.23,19.76 v1(18.55,19.76) 19.08,19.76 19.29,19.97 R2421.1 19.85,19.84 v2(19.85,19.31)
  BOTTOM w0.102: v2(19.85,19.31) 19.61,19.07 U2401.110
I_BATT: length 3.6
  TOP w0.254: R2423.2 19.25,21.09 18.74,21.09 v1(18.7,21.13) v2(18.28,20.72) 18.25,20.75 17.63,20.75 C2441.1
  BOTTOM w0.203: v2(18.28,20.72) 18.17,20.6 17.21,20.6 U2401.114
IC_DELAY: length 1.3
  BOTTOM w0.102: C4344.1 36.12,60.05 U4302.4
ICSP_CLK: length 29.4
  TOP w0.127: v2(33.34,8.73) 33.01,9.07 33.01,9.24 32.73,9.52 31.97,9.52 31.95,9.54 DB3.2 ; v2(18.67,15.26) 18.38,15.54 18.08,15.54 R2403.2
  L8 w0.127: v2(33.34,8.73) 32.98,9.09 32.98,9.22 32.42,9.79 28.7,9.79 27.8,10.69 24.91,10.69 23.82,9.6 20.58,9.6 19.31,10.88 19.31,12.36 17.3,14.38 17.3,15.33 17.52,15.55 18.37,15.55 v2(18.67,15.26)
  BOTTOM w0.127: v2(18.67,15.26) 18.38,15.54 18.06,15.54 17.99,15.47 U2401.101 ; v2(33.34,8.73) 33.72,8.35 34.17,8.35 34.43,8.61 34.43,8.64 v1(34.66,8.86)
ICSP_CLR: length 14.7
  TOP w0.102: v1(23.68,9.22) 23.17,9.72 v2(23.17,10.79) 23.31,10.92 25.28,10.92 25.74,10.46 28.42,10.46 28.95,9.93 29.48,9.93 R2414.2 29.91,10.08 29.91,9.1 30.09,8.92 30.09,8.91 30.34,8.66 30.35,8.66 30.49,8.52 30.49,7.89 30.84,7.54 DB3.6
  BOTTOM w0.102: U2401.87 22.17,11.81 23.17,10.8 v2(23.17,10.79)
ICSP_DAT: length 28.4
  TOP w0.127: v2(32.52,8.73) 32.75,8.96 32.75,9.14 32.63,9.27 32.18,9.27 31.95,9.04 DB3.3 ; v1(18.68,16.79) 18.67,16.78 v2(18.67,16.08) 18.52,15.93 18.2,15.93 R2404.2
  L8 w0.127: v2(18.67,16.08) 18.39,15.8 17.41,15.8 17.04,15.43 17.04,14.27 19.06,12.26 19.06,10.77 20.48,9.35 23.93,9.35 25.01,10.43 27.69,10.43 28.59,9.53 32.31,9.53 32.73,9.12 32.73,8.94 v2(32.52,8.73)
  BOTTOM w0.127: U2401.102 17.99,15.87 18.06,15.79 18.38,15.79 v2(18.67,16.08)
INPUT3VSEL: length 29.7
  L6 w0.102: v2(125.83,48.53) 125.42,48.13 123.48,48.13 122.83,47.48 119.21,47.48 117.79,48.9 116.07,48.9 115.78,49.18 115.33,49.18 114.27,50.24 109.18,50.24 109.05,50.37 107.78,50.37 107.62,50.22 107.31,50.22 v2(106.81,49.72)
  BOTTOM w0.102: v1(125.38,51.11) 125.38,50.39 R1520.2 125.9,49.87 R1521.1 125.9,48.61 v2(125.83,48.53) ; CPU1.BT27 101.68,49.74 106.79,49.74 106.79,49.72 v2(106.81,49.72)
INT_ITE8010: length 7
  TOP w0.102: v2(196.91,8.9) 196.55,8.9 196.24,9.22 196.24,13.9 AFTP4317.1
  BOTTOM w0.102: IO2.2 v2(196.91,8.9)
IR_CAM_DET#: length 6.8
  BOTTOM w0.076: 113.37,52.5 112.71,52.5 112.7,52.51 arc(112.61,52.57) 112.51,52.59 112.42,52.59 arc(112.39,52.59) 112.35,52.58 arc(112.35,52.58) 112.35,52.58 arc(112.3,52.56) 112.25,52.53 112.11,52.39 112.11,52.23 112.04,52.16 arc(111.96,52.1) 111.87,52.08 111.79,52 110.77,52 CPU1.CM22
  BOTTOM w0.102: R2046.2 115.94,54.38 115.73,54.16 v1(115.1,54.16) 115.07,54.14 114.87,54.14 114.57,53.84 114.55,53.84 114.31,53.6 114.31,53.58 114.03,53.3 114.03,53.17 113.37,52.5
ISH_TABLE_MODE#: length 13.9
  TOP w0.102: R2027.1 111.1,33.54 v1(111.1,33.75) 111.1,34.13 v2(111.28,34.31)
  L5 w0.102: v2(104.42,41.25) 104.42,40.62 110.73,34.31 v2(111.28,34.31)
  BOTTOM w0.102: CPU1.CA37 104.68,42.82 104.68,42.43 104.66,42.42 104.66,42.26 104.7,42.23 104.7,41.61 104.43,41.33 104.43,41.25 v2(104.42,41.25)
IST_TRIG: length 4.5
  BOTTOM w0.102: CPU1.CP36 112.55,42.81 112.55,42.43 112.58,42.4 112.58,42 112.97,41.61 112.97,40.54 113.43,40.08 113.43,39.79 TP620.1
ITP_PMODE: length 8.9
  BOTTOM w0.102: CPU1.W4 78.34,63.84 78.34,66.02 78.09,66.27 77.38,66.27 75.65,68 74.76,68 74.72,68.04 74.71,68.04 74.51,68.24 74.51,68.25 74.26,68.5 74.26,69.26 74.56,69.57 TP618.1
JGND:
  vias: v4(32.94,74.11) v4(33.01,73.28) v4(33.64,74.58) v4(33.75,73.73)
JIO3_PCIE_WAKE#: length 105.9
  TOP w0.089: AFTP6115.1 158.29,16.92 v2(158.29,17.04) ; v2(156.43,55.61) 151.11,55.61 148.01,58.71 146.28,58.71 145.55,59.43 141.3,59.43 139.72,57.85 138.28,57.85 137.4,56.97 136.97,56.97 136.69,56.69 v2(136.69,55.26) ; v2(164.47,16.6) 164.55,16.68 164.66,16.68 166.36,18.37 166.36,22.02 164.73,23.65 164.73,24.06 164.21,24.58 164.21,28.75 166.41,30.96 166.41,33.27 170.09,36.95 v2(170.17,36.95)
  L3 w0.076: v2(156.43,55.61) 156.83,55.61 157.65,54.79 159.59,54.79 160.74,53.65 162.52,53.65 165.16,51.01 165.16,50.27 165.14,50.25 165.14,49.92 165.16,49.9 165.16,49.03 164.56,48.42 164.56,47.88 164.57,47.86 164.57,47.79 165.56,46.8 167.78,46.8 170.05,44.53 170.05,44.49 170.17,44.38 v2(170.17,36.95)
  L6 w0.089: v2(123.45,59.66) 124.14,60.35 129.63,60.35 130.57,59.4 130.57,58.96 132.23,57.3 132.23,56.55 132.48,56.3 132.83,56.3 133.05,56.52 134.07,56.52 134.74,55.85 135.78,55.85 136.01,55.62 136.01,55.51 136.26,55.26 v2(136.69,55.26)
  BOTTOM w0.089: R1806.2 123.35,57.97 R1819.2 123.9,58.52 123.9,59.25 123.49,59.66 v2(123.45,59.66) ; v2(164.47,16.6) 164.47,17.92 163.91,18.48 161.32,18.48 160.64,17.8 WLAN1.55 158.82,17.8 158.29,17.28 v2(158.29,17.04)
KB_DET#: length 152.8
  L5 w0.102: v2(118.96,22.93) 119.61,22.93 121.61,24.93 121.61,31 122.19,31.58 122.19,39.58 123.93,41.33 123.93,44.59 125.29,45.95 125.29,49.4 125.07,49.62 125.07,50 124.09,50.98 124.09,54.24 122.68,55.65 122.68,58.56 119.97,61.27 117.33,61.27 v2(116.9,60.84)
  L8 w0.102: v2(44.32,14.03) 45.3,15.02 72.15,15.02 72.99,14.18 91.45,14.18 92.96,12.67 108.34,12.67 108.67,12.34 117.41,12.34 120.16,15.09 120.16,18.42 120.38,18.64 120.38,19 119.76,19.61 119.76,22.13 v2(118.96,22.93)
  BOTTOM w0.076: 114.56,59.49 114.54,59.51 113.57,59.51 113.47,59.61 112.87,59.61 112.74,59.49 112.31,59.49 112.31,59.49 arc(112.28,59.5) 112.24,59.51 112.06,59.51 arc(112,59.5) 111.94,59.47 arc(111.87,59.44) 111.8,59.44 arc(111.73,59.45) 111.67,59.48 arc(111.63,59.5) 111.58,59.51 111.56,59.53 110.72,59.53 110.54,59.35 110.54,58.71 CPU1.CM12
  BOTTOM w0.102: R2045.2 118.2,60.83 118.2,61.13 118.06,61.27 117.33,61.27 v2(116.9,60.84) 116.84,60.84 115.49,59.49 114.56,59.49 ; v2(44.32,14.03) 43.17,12.89 v1(43.17,12.32) 43.17,11.01 41.14,8.98 40.91,8.98 40.88,8.95 40.52,8.95 40.49,8.98 40.11,8.98 40.08,8.95 39.72,8.95 39.69,8.98 39.31,8.98 39.28,8.95 38.96,8.95 38.7,8.7 KB1.30
KB_LED_BL_DET: length 143.5
  TOP w0.102: v1(14.66,16.1) 14.61,16.15 14.61,16.67 v2(14.19,17.1)
  L8 w0.102: v2(109.47,50.76) 109.47,48.91 109.38,48.82 109.38,44.84 109.38,44.48 107.98,43.08 107.98,42.05 108.33,41.7 108.33,40.85 108.58,40.59 108.79,40.59 111.25,38.13 111.25,37.63 111.25,37.02 114.56,33.71 114.56,31.31 114.55,31.3 114.55,27.77 114.51,27.72 114.51,22.86 113.89,22.24 113.89,19.74 110.87,16.72 73.97,16.72 73.23,17.46 60.89,17.46 59.77,18.58 44.62,18.58 43.59,17.54 39.62,17.54 38.21,16.13 37.85,16.13 37.54,16.45 32.76,16.45 31.71,15.4 29.65,15.4 28.09,16.96 23.63,16.96 22.57,18.02 22.22,18.02 21.96,17.76 21.96,17.71 20.79,16.53 14.75,16.53 v2(14.19,17.1)
  BOTTOM w0.102: CPU1.CK23 109.47,50.92 v2(109.47,50.76) ; R6508.1 13.41,17.11 R6507.1 14.18,17.1 v2(14.19,17.1)
KB_LED_DET_C: length 28.1
  TOP w0.102: C6504.1 24.73,7.02 25.63,7.92 v1(25.63,8.48) 25.74,8.58 v2(26.7,8.58)
  L8 w0.102: v2(14.16,16.46) 13.68,15.98 13.68,13.57 14.98,12.26 14.98,9.65 16.27,8.36 16.82,8.36 17.2,8.74 18.38,8.74 20.83,6.3 23.77,6.3 26.05,8.58 v2(26.7,8.58)
  BOTTOM w0.102: v2(14.16,16.46) 14.14,16.46 13.91,16.24 R6507.2 ; v2(26.7,8.58) 26.89,8.77 26.89,9.78 26.68,9.98 KBBL1.2
KB_LED_PWM: length 20
  BOTTOM w0.102: U2401.44 34.11,21.87 34.37,21.61 36.89,21.61 37.81,20.69 39.19,20.69 39.67,20.21 39.67,19.6 40.85,18.41 40.85,16.93 40.33,16.41 40.33,13.25 v1(40.39,13.19) 38.53,11.32 R6509.1 37.99,10.8 Q6501.G
KBC_BEEP_R: length 3.1
  TOP w0.254: D2703.2 172.89,4.53 173.8,4.53 173.82,4.55 v1(174.39,4.55) 175.32,4.55 175.51,4.36 R2734.2
KBC_PWRBTN#: length 223.8
  TOP w0.102: v2(142.85,8.4) 141.8,7.35 137.09,7.35 135.85,6.11 131.47,6.11 128.65,3.29 115.1,3.29 v1(114.39,4) v2(113.66,4.74)
  L3 w0.102: v2(9.74,5.47) 11.73,5.47 13.8,7.54 13.8,9.66 15.88,11.73 17.94,11.73 19.42,10.25 20.35,10.25 22.07,11.98 22.68,11.98 23.38,12.68 30.66,12.68 30.9,12.92 33.73,12.92 33.94,12.7 34.3,12.7 34.52,12.92 36.88,12.92 37.17,13.22 40.66,13.22 42.06,14.62 42.42,14.62 42.46,14.58 72.11,14.58 72.36,14.32 88.89,14.32 89.23,13.99 91.56,13.99 92.94,12.62 104.71,12.62 109.31,8.02 110.38,8.02 v2(113.66,4.74)
  L6 w0.102: v2(15.63,66.05) 15.14,65.55 12.61,65.55 12.42,65.36 11.82,65.36 11.2,64.73 11.2,54.06 13,52.26 13,51.44 11.37,49.81 11.37,47.85 11.46,47.75 11.46,47.02 10.71,46.27 10.71,37.08 9.41,35.78 9.41,33.21 10.55,32.07 10.55,31.68 10.45,31.58 10.45,29.24 11.09,28.6 11.09,27.8 ; 11.09,27.8 10.54,27.25 10.54,26.62 9,25.08 9,21.83 5.54,18.36 5.54,9.38 9.45,5.47 v2(9.74,5.47) ; 11.09,27.8 v2(11.07,27.8)
  BOTTOM w0.102: Q6406.E 16.34,64.69 15.63,65.39 v2(15.63,66.05) ; R2432.1 13.45,27.9 11.16,27.9 v2(11.07,27.8) ; v2(142.85,8.4) 142.16,8.4 141.85,8.71 FP1.2
KBC_SMB_SCL_BAT: length 10
  TOP w0.127: v2(109.59,13) 109.64,12.96 109.64,12.78 109.61,12.75 AFTP4311.1 109.69,11.36 110.51,11.36 110.63,11.24 RN4302.4
  BOTTOM w0.127: v2(109.59,13) 109.59,13.6 109.12,14.08 107.1,14.08 106.73,13.7 106.73,13.7 106.21,13.18 106.21,12.54 106.09,12.42 105.84,12.42 105.71,12.29 BATT1.5
KBC_SMB_SDA_BAT: length 10.5
  TOP w0.127: v2(108.95,13.04) 109.49,13.57 AFTP4310.1 109.74,13.45 109.78,13.45 110.04,13.19 110.04,12.82 109.87,12.65 109.87,11.74 110,11.61 110.39,11.61 110.62,11.84 110.98,11.84 RN4302.3
  BOTTOM w0.127: BATT1.6 106.96,12.29 106.84,12.42 106.59,12.42 106.47,12.54 106.47,13.08 106.71,13.32 v1(106.99,13.32) 106.99,13.6 107.21,13.82 109.01,13.82 109.14,13.69 109.14,13.45 108.95,13.26 v2(108.95,13.04)
KSI0: length 42.5
  TOP w0.089: AFTP6512.1 44.88,4.41 45.1,4.19 v2(45.1,4.11) 45.26,3.94 RN2403.5
  L5 w0.089: v2(18.93,14.52) 19.45,14 23.03,14 24.16,12.87 25.24,12.87 26.55,11.57 26.55,10.58 27.52,9.6 27.52,8.09 30.11,5.49 43.71,5.49 v2(45.1,4.11)
  BOTTOM w0.089: v2(18.93,14.52) 18.93,14.36 18.71,14.14 18.1,14.14 17.97,14.27 U2401.98 ; KB1.22 v2(45.1,4.11)
KSI1: length 39.2
  TOP w0.089: AFTP6501.1 43.5,4.43 v2(43.5,4.13) 44.18,3.45 RN2403.7
  L5 w0.089: v2(18.28,14.57) 18.28,14.03 19.43,12.88 23.88,12.88 24.08,12.68 25.16,12.68 26.36,11.49 26.36,10.5 27.33,9.52 27.33,8.01 30.03,5.3 42.33,5.3 v2(43.5,4.13)
  BOTTOM w0.089: v2(18.28,14.57) 18.18,14.67 U2401.99 ; KB1.24 v2(43.5,4.13)
KSI2: length 42.4
  TOP w0.089: RN2403.8 43.59,3.02 42.59,4.01 42.59,5.98 41.47,7.11 AFTP6508.1 42,9.02 42.5,9.53 v2(42.5,9.61)
  L5 w0.089: v2(20.53,26.55) 20.99,26.09 20.99,25.3 23.95,22.34 23.95,21.46 26.71,18.7 30.46,18.7 33.16,16 33.16,13.5 34.13,12.53 34.89,12.53 35.89,11.53 40.54,11.53 40.83,11.24 40.87,11.24 v2(42.5,9.61)
  BOTTOM w0.089: v2(20.53,26.55) 20.57,26.59 U2401.6 ; KB1.26 42.5,9 v2(42.5,9.61)
KSI3: length 44.5
  TOP w0.089: RN2403.6 44.68,3.48 44.57,3.58 44.57,4.04 42.93,5.68 AFTP6509.1 42.93,8.24 v2(44.22,9.53)
  L5 w0.089: v2(20.57,25.88) 20.57,25.45 23.76,22.26 23.76,21.3 24.77,20.28 24.77,19.42 26.48,17.71 30.81,17.71 32.96,15.57 32.96,13.43 34.05,12.34 34.75,12.34 35.79,11.29 40.49,11.29 42.08,9.71 42.08,9.43 42.33,9.18 43.87,9.18 v2(44.22,9.53)
  BOTTOM w0.089: v2(44.22,9.53) 44.3,9.45 KB1.23 ; v2(20.57,25.88) 20.97,26.28 U2401.7
KSI4: length 43.9
  TOP w0.089: RN2404.6 40.65,2.99 40.65,3.56 41.1,4.01 v2(41.1,4.21) 41.1,4.95 AFTP6505.1
  L5 w0.089: v2(41.1,4.21) 40.56,4.75 37.13,4.75 36.77,4.38 36.76,4.38 35.87,3.49 35.87,3.49 35.65,3.26 29.29,3.26 29.25,3.3 24.4,3.3 24.05,3.65 24.05,6.13 18.08,12.11 17.54,12.11 15.56,14.08 15.56,15.45 15.28,15.73 15.28,16.08 15.34,16.14 v2(15.34,17)
  BOTTOM w0.089: v2(15.34,17) 15.8,16.54 16.31,16.54 16.43,16.67 U2401.104 ; KB1.27 v2(41.1,4.21)
KSI5: length 44.2
  TOP w0.089: AFTP6506.1 42.16,5.88 v2(42.16,4.07) 41.26,3.16 RN2404.5
  L5 w0.089: v2(42.16,4.07) 41.12,5.11 29.96,5.11 27.14,7.93 27.14,9.44 26.16,10.42 26.16,11.41 25.08,12.49 24,12.49 23.8,12.69 19.35,12.69 17.58,14.46 17.58,15.52 v2(16.13,16.97)
  BOTTOM w0.089: v2(42.16,4.07) 42.51,4.07 42.7,4.26 KB1.25 ; U2401.105 16.23,17.07 v2(16.13,16.97)
KSI6: length 45.3
  TOP w0.089: RN2404.7 40.17,4.08 v2(40.3,4.21) 39.54,4.98 AFTP6503.1
  L5 w0.089: v2(15.31,18.15) 14.72,17.56 14.72,15.75 15.18,15.29 15.18,13.93 17.38,11.73 17.92,11.73 22.74,6.9 22.74,4.42 24.24,2.92 29.09,2.92 29.13,2.88 35.81,2.88 36.25,3.33 36.25,3.34 36.62,3.71 39.62,3.71 40.12,4.21 v2(40.3,4.21)
  BOTTOM w0.089: v2(15.31,18.15) 15.72,17.74 16.15,17.74 16.28,17.87 U2401.107 ; KB1.28 v2(40.3,4.21)
KSI7: length 43.7
  TOP w0.089: AFTP6502.1 38.61,3.31 v2(39.5,4.19) 39.5,3.06 RN2404.8
  L5 w0.089: v2(39.5,4.19) 39.2,3.9 36.54,3.9 36.06,3.42 36.06,3.41 35.73,3.07 29.21,3.07 29.17,3.11 24.32,3.11 22.93,4.5 22.93,6.98 18,11.92 17.46,11.92 15.37,14 15.37,15.37 14.91,15.83 14.91,17.18 15.46,17.72 15.53,17.72 v2(15.98,18.17)
  BOTTOM w0.089: U2401.108 16.08,18.27 v2(15.98,18.17) ; KB1.29 v2(39.5,4.19)
KSO0: length 59.6
  TOP w0.089: RN2411.8 51.42,8.27 AFTP6507.1 52.3,9.16 v2(52.3,9.65)
  L5 w0.089: v2(52.3,9.65) 51.36,8.71 42.13,8.71 41.61,9.23 41.61,9.51 40.3,10.82 35.6,10.82 34.55,11.87 33.81,11.87 32.46,13.22 32.46,14.96 31.54,15.88 27.22,15.88 24.09,19.01 24.09,19.33 22.62,20.8 22.61,20.8 19.84,23.57 17.74,23.57 15.68,25.64 15.68,25.99 16.97,27.28 17.43,27.28 18.55,28.41 v2(18.55,28.74)
  BOTTOM w0.089: KB1.13 v2(52.3,9.65) ; v2(18.55,28.74) 18.97,28.33 U2401.2
KSO1: length 47.1
  TOP w0.089: v2(50.66,9.36) 50.3,9 AFTP6511.1 49.57,5.9 49.57,3.88 49.87,3.58 49.87,2.9 RN2412.6
  L5 w0.089: v2(50.66,9.36) 50.66,9.79 47.89,12.56 45.59,12.56 44.92,13.23 44.85,13.23 44.85,13.23 39.25,13.23 37.22,15.26 37.08,15.26 32.13,20.21 32.13,21.91 28.62,25.43 28.35,25.43 27.24,26.54 27.24,28.75 26.75,29.24 25.34,29.24 25.25,29.16 24.24,29.16 23.83,28.75 v2(23.67,28.75)
  BOTTOM w0.089: v2(23.67,28.75) 23.67,27.79 U2401.14 ; KB1.15 50.7,9.24 50.66,9.28 v2(50.66,9.36)
KSO2: length 48.6
  TOP w0.089: v2(51.5,9.63) 51.5,9.23 51.02,8.76 51.02,5.51 AFTP6513.1 50.16,3.79 50.45,3.5 RN2412.5
  L5 w0.089: v2(51.5,9.63) 48.38,12.75 45.67,12.75 44.97,13.45 39.3,13.45 37.29,15.46 37.15,15.46 32.32,20.29 32.32,21.99 28.69,25.62 28.43,25.62 27.6,26.44 27.6,28.66 26.83,29.43 25.26,29.43 25.2,29.37 v2(23.85,29.37)
  BOTTOM w0.089: v2(23.85,29.37) 24.04,29.17 24.04,29.14 24.09,29.09 24.09,28.4 24.17,28.32 U2401.15 ; KB1.14 v2(51.5,9.63)
KSO3: length 44
  TOP w0.089: RN2412.7 49.36,3.55 49.14,3.77 AFTP6518.1 49.9,8.93 v2(49.9,9.37)
  L5 w0.089: v2(49.9,9.37) 49.9,9.87 47.4,12.37 45.51,12.37 44.85,13.04 44.77,13.04 44.77,13.04 39.03,13.04 38.66,13.42 38.5,13.42 37.63,13.42 36.46,14.59 36.46,15.44 27.95,23.95 27.95,24.62 26.15,26.42 26.15,26.75 24.52,28.38 v2(24.52,28.73)
  BOTTOM w0.089: KB1.16 v2(49.9,9.37) ; v2(24.52,28.73) 24.52,28.76 24.47,28.71 24.47,27.79 U2401.16
KSO4: length 43.2
  TOP w0.089: v2(46.63,9.42) 46.63,5.86 AFTP6514.1 46.55,3.74 46.82,3.46 RN2409.7
  L5 w0.089: v2(26.95,24.13) 26.95,20.72 27.22,20.46 30.28,20.46 34.99,15.75 34.99,13.55 36.62,11.92 40.24,11.92 40.6,12.28 44.45,12.28 46.63,10.1 v2(46.63,9.42)
  BOTTOM w0.089: U2401.37 31.81,24.67 31.69,24.79 27.61,24.79 v2(26.95,24.13) ; KB1.20 46.7,9.35 v2(46.63,9.42)
KSO5: length 46.7
  TOP w0.089: v2(45.9,9.48) 45.61,9.48 AFTP6510.1 45.78,8.56 45.78,3.85 46.24,3.4 RN2409.8
  L5 w0.089: v2(45.9,9.48) 45.9,10.56 44.37,12.09 40.68,12.09 40.3,11.72 36.32,11.72 34.12,13.92 34.12,15.98 33.2,16.9 32.63,16.9 30.15,19.38 30.15,20.06 29.95,20.27 27.14,20.27 26.53,20.88 26.53,23.8 v2(25.74,24.59)
  BOTTOM w0.089: U2401.38 31.81,24.27 31.5,24.57 28,24.57 27.13,23.7 26.63,23.7 v2(25.74,24.59) ; KB1.21 45.9,9.48 v2(45.9,9.48)
KSO6: length 41.4
  TOP w0.089: RN2409.5 47.91,4.23 AFTP6517.1 47.85,8.94 v2(48.3,9.39)
  L5 w0.089: v2(27.48,23.45) 28.18,23.45 35.6,16.03 35.6,14.56 35.85,14.31 36.47,14.31 37.56,13.23 38.58,13.23 38.95,12.85 44.69,12.85 44.69,12.85 44.77,12.85 45.43,12.18 47.32,12.18 48.3,11.2 v2(48.3,9.39)
  BOTTOM w0.089: KB1.18 v2(48.3,9.39) ; U2401.39 31.42,23.87 31.28,23.72 31.27,23.72 31.26,23.71 27.74,23.71 v2(27.48,23.45)
KSO7: length 40.2
  TOP w0.089: AFTP6515.1 47.32,9.71 v2(47.32,9.5) 47.32,8.67 47.23,8.58 47.23,3.88 47.33,3.78 RN2409.6
  L5 w0.089: v2(27.4,20.88) 30.12,20.88 35.22,15.79 35.22,13.59 35.97,12.84 38.42,12.84 38.8,12.47 44.53,12.47 47.32,9.68 v2(47.32,9.5)
  BOTTOM w0.089: v2(27.4,20.88) 28.7,19.58 31.15,19.58 31.27,19.47 U2401.50 ; KB1.19 47.5,9.32 v2(47.32,9.5)
KSO8: length 41.8
  TOP w0.089: v2(49.1,9.43) 48.42,8.75 AFTP6516.1 48.42,5.71 48.72,5.41 48.72,2.95 RN2412.8
  L5 w0.089: v2(27.39,21.54) 29.73,21.54 35.41,15.87 35.41,13.67 36.05,13.04 38.5,13.04 38.87,12.66 44.61,12.66 47.35,9.92 47.5,9.92 47.75,9.67 47.75,9.51 47.81,9.45 47.81,9.28 48.12,8.97 48.64,8.97 v2(49.1,9.43)
  BOTTOM w0.089: U2401.46 31.33,21.07 31.23,20.96 28.47,20.96 27.9,21.54 v2(27.39,21.54) ; KB1.17 v2(49.1,9.43)
KSO9: length 44.5
  TOP w0.089: R2452.2 R2453.1 60.66,3.28 AFTP6504.1 60.66,8.28 58.92,10.02 57.51,10.02 v2(57.1,9.61)
  L5 w0.089: v2(57.1,9.61) 56.71,9.99 54.61,9.99 54.19,9.57 54.19,9.24 52.43,7.48 38.92,7.48 38.5,7.9 36.36,7.9 34.35,9.91 33.43,9.91 30.35,12.99 v2(30.35,13.57)
  BOTTOM w0.089: KB1.7 v2(57.1,9.61) ; v2(30.35,13.57) 30.29,13.57 29.77,13.06 U2401.68
KSO10: length 45.5
  TOP w0.089: v2(58.75,9.59) 58.75,6.41 AFTP6523.1 58.34,5.71 57.18,4.55 RN2410.6
  L5 w0.089: v2(27.86,13.97) 28.65,13.97 33.15,9.47 34.25,9.47 36.2,7.52 38.34,7.52 38.77,7.09 53.06,7.09 55.77,9.8 56.3,9.8 56.92,9.18 58.34,9.18 v2(58.75,9.59)
  BOTTOM w0.089: KB1.5 58.7,9.54 v2(58.75,9.59) ; U2401.72 28.17,12.45 28.17,13.77 27.97,13.97 v2(27.86,13.97)
KSO11: length 42.7
  TOP w0.089: RN2410.5 57.9,3.06 v2(57.9,3.75) 58.74,3.75 AFTP6522.1
  L5 w0.089: v2(57.9,3.75) 54.84,6.81 38.78,6.81 38.26,7.33 36.12,7.33 34.19,9.27 33.08,9.27 28.81,13.54 v2(27.37,13.54)
  BOTTOM w0.089: KB1.6 v2(57.9,3.75) ; U2401.74 27.37,12.45 v2(27.37,13.54)
KSO12: length 43.9
  TOP w0.089: RN2411.7 52.02,2.91 AFTP6519.1 54.75,8.45 v2(54.75,9.53)
  L5 w0.089: v2(54.75,9.53) 53.49,8.27 53.49,8.16 52.62,7.28 38.85,7.28 38.42,7.71 36.28,7.71 34.27,9.72 33.17,9.72 28.41,14.48 v2(27.29,14.48)
  BOTTOM w0.089: v2(54.75,9.53) 53.58,9.53 53.1,9.05 KB1.12 ; v2(27.29,14.48) 26.92,14.11 26.92,13.32 26.97,13.28 U2401.75
KSO13: length 45.1
  TOP w0.089: AFTP6520.1 54.77,6.04 54.75,6.03 55.5,5.28 v2(55.5,4.32) 55.5,3.94 56.09,3.35 RN2410.8
  L5 w0.089: v2(55.5,4.32) 53.34,6.48 38.84,6.48 38.18,7.14 35.67,7.14 35.46,7.34 33.31,7.34 32.1,8.55 32.1,9.1 28.08,13.12 27.19,13.12 26.94,13.37 26.94,13.77 26.08,14.64 v2(25.95,14.64)
  BOTTOM w0.089: U2401.76 26.57,12.45 26.57,14.27 26.24,14.59 25.99,14.59 v2(25.95,14.64) ; v2(55.5,4.32) KB1.9
KSO14: length 43.5
  TOP w0.089: RN2410.7 56.68,3.43 56.3,3.81 v2(56.3,3.94) 56.3,5.16 AFTP6521.1
  L5 w0.089: v2(56.3,3.94) 56,3.64 55.46,3.64 52.95,6.15 36.39,6.15 35.38,7.15 33.23,7.15 31.91,8.47 31.91,9.02 29.15,11.78 28.25,11.78 v2(26.02,14)
  BOTTOM w0.089: v2(26.02,14) 26.02,13.38 26.17,13.23 U2401.77 ; KB1.8 v2(56.3,3.94)
KSO15: length 51.9
  TOP w0.089: AFTP6524.1 54.48,3.78 v2(54.59,3.89) 54.59,4.34 53.85,5.07 53.57,5.07 52.58,4.08 52.58,2.97 RN2411.6
  L5 w0.089: v2(21.52,14.63) 21.59,14.56 24.1,14.56 26.93,11.73 26.93,10.97 26.99,10.9 26.99,10.67 27.9,9.76 27.9,8.24 30.27,5.87 52.6,5.87 v2(54.59,3.89)
  BOTTOM w0.089: v2(21.52,14.63) 21.52,14.28 22.57,13.24 U2401.86 ; KB1.10 54.7,4 v2(54.59,3.89)
KSO16: length 47.9
  TOP w0.089: AFTP6539.1 53.48,4.49 v2(53.48,3.9) 53.48,3.28 RN2411.5
  L5 w0.089: v2(20.17,14.48) 20.73,14.48 21.01,14.2 23.1,14.2 24.24,13.06 25.32,13.06 26.74,11.65 26.74,10.66 27.71,9.68 27.71,8.16 30.19,5.68 51.7,5.68 v2(53.48,3.9)
  BOTTOM w0.089: v2(53.48,3.9) 53.9,4.33 KB1.11 ; U2401.92 v2(20.17,14.48)
L_BKLT_CTRL: length 103.2
  TOP w0.127: v2(63.42,85.7) 63.39,85.7 ; 63.39,85.7 63.71,86.02 D5502.1 64.73,86.02 65.38,85.37 v1(65.38,84.92) ; 63.39,85.7 63.39,85.53 R5502.2
  L5 w0.127: v2(108.17,59.09) 107.74,58.66 106.54,58.66 106.29,58.41 105.13,58.41 103.14,60.4 103.14,61.92 101.5,63.55 97.45,63.55 96.43,64.57 92.04,64.57 91.35,65.26 89.81,65.26 89.2,64.65 70.96,64.65 70.26,65.35 69.75,65.35 68.92,66.17 68.92,66.2 68.66,66.46 66.35,66.46 64.75,68.05 64.75,68.06 59.61,73.2 51.97,73.2 51.96,73.2 44.61,73.2 44.36,73.46 v2(43.45,73.46)
  L6 w0.127: v2(63.42,85.7) 63.42,84.52 57.14,78.24 52.61,78.24 47.6,73.22 43.69,73.22 v2(43.45,73.46)
  BOTTOM w0.127: v2(108.17,59.09) 108.27,59.19 108.27,59.31 108.53,59.58 CPU1.CH11
L_BKLT_EN: length 169.3
  TOP w0.102: R2427.1 25.86,19.04 25.86,16.05 26.46,15.45 26.46,13.03 27.14,12.35 27.64,12.35 27.8,12.19 29.95,12.19 30.9,13.14 30.9,13.81 31.12,14.03 32.83,14.03 33.11,13.76 35.96,13.76 v2(36.07,13.87)
  L5 w0.102: v2(110.07,60.22) 110.19,60.22 111.69,61.72 115.68,61.72 116.05,61.35 116.05,60.91 116.74,60.22 117.89,60.22 118.68,59.43 119.25,59.43 121.68,56.99 121.68,55.51 122.51,54.67 122.51,41.04 121.49,40.02 121.49,31.87 120.09,30.47 120.09,28.53 120.03,28.47 120.03,24.88 119.3,24.16 119.3,24.07 119.05,23.82 118.96,23.82 118.51,23.37 118.51,22.58 118.82,22.27 v2(118.97,22.27)
  L8 w0.102: v2(36.07,13.87) 36.07,14.13 36.92,14.98 37.45,14.98 38.71,13.72 43.51,13.72 43.89,14.1 43.89,14.21 44.89,15.22 72.24,15.22 73.03,14.43 91.5,14.43 92.42,13.52 94.01,13.52 94.02,13.53 94.38,13.53 94.39,13.52 107.66,13.52 108.59,14.45 114.95,14.45 115.45,13.95 118.73,13.95 119.58,14.79 119.58,16.6 119.41,16.76 119.41,21.83 v2(118.97,22.27)
  BOTTOM w0.102: R2440.2 34.58,12.16 v1(35.24,11.5) 35.38,11.64 R2455.1 35.49,12.51 35.49,13.21 36.07,13.79 v2(36.07,13.87) ; v2(110.07,60.22) 109.86,60.01 CPU1.CK11
L_BKLT_EN_L: length 2.8
  TOP w0.102: D2401.2 23.53,22.26 v1(24.46,21.34) 25.22,20.58 R2427.2
LAN_WAKE#: length 2.7
  TOP w0.102: R1707.2 101.98,47.9 101.98,47.4 102.36,47.01 102.36,46.96 102.47,46.86 v2(102.47,46.86)
  BOTTOM w0.102: v2(102.47,46.86) 102.47,46.36 CPU1.BU32
LCD_BRIGHTNESS: length 30.6
  TOP w0.127: RN5505.1 61.67,86.56 v1(61.66,86.56) 61.73,86.63 62.02,86.63 v2(62.47,86.18)
  L5 w0.127: v2(62.47,86.18) 62.29,86.36 62.29,88.19 61.93,88.55 61.59,88.55 60.71,87.67 60.44,87.67 59.58,86.81 59.39,86.81 57.18,84.6 57.18,83.05 56.19,82.05 43.3,82.05 42.62,81.37 v2(42.62,80.36)
  BOTTOM w0.127: LCD1.9 42,79.69 42.56,80.24 42.56,80.3 v2(42.62,80.36)
LCD_TST: length 106.2
  TOP w0.102: v2(60.25,84.46) 60.25,84.47 59.8,84.92 59.8,84.92 59.58,85.14 RN5501.4 ; D5502.2 64.08,87.93 63.75,88.26 v2(63.15,88.26) ; v2(28.46,28.86) 28.27,29.06 28.27,29.5 v1(28.27,29.51)
  L6 w0.102: v2(63.15,88.26) 62.88,88.52 61.58,88.52 59.78,86.72 59.78,84.94 59.8,84.92 59.8,84.92 60.25,84.47 v2(60.25,84.46) 60.25,83.78 57.68,81.21 53.48,81.21 52.49,80.22 51.17,80.22 50.74,79.79 48.15,79.79 47.72,80.22 47.72,80.53 47.69,80.56 47.69,81.08 46.95,81.82 30.81,81.82 27.72,78.73 27.72,78.25 29.25,76.73 29.25,70.71 27.86,69.32 27.7,69.32 27.44,69.07 27.44,67.45 29.14,65.75 29.14,63.05 30.09,62.1 30.13,62.06 30.13,59.3 32,57.16 32.07,57.16 32.32,56.9 32.32,56.8 33.36,55.76 33.7,55.74 33.97,55.46 33.97,53.44 31.01,50.48 31.01,44.46 29.52,42.97 29.52,38.35 30.55,37.32 30.55,34.83 30.08,34.36 30.08,30.48 v2(28.46,28.86)
  BOTTOM w0.102: v2(28.46,28.86) 28.47,28.86 28.57,28.76 U2401.26
LCD_TST_C: length 25.6
  TOP w0.102: v2(60.21,86.37) 59.76,86.37 RN5501.1 ; v2(42.8,79.71) 42.8,78.53 42.98,78.35 v1(42.98,78.35)
  L5 w0.102: v2(42.8,79.71) 43.28,79.23 47.46,79.23 47.49,79.25 52.69,79.25 52.77,79.18 53.75,79.18 53.86,79.29 56.06,79.29 57.69,80.93 57.69,83.85 v2(60.21,86.37)
  BOTTOM w0.102: v2(42.8,79.71) 42.66,79.71 42.4,79.45 LCD1.10
LCD_VCC_TEST_EN: length 107.9
  L3 w0.102: v2(62.32,79.05) 62.63,78.74 62.63,78.32 62.12,77.81 59.73,77.81 59.03,78.52 38.01,78.52 36.25,76.76 32.74,76.76 32.52,76.54 30.64,76.54 28.87,74.77 28.87,70.7 28.06,69.88 25.64,69.88 24.04,68.28 24.04,67.6 19.8,63.35 19.8,62.43 19.14,61.77 19.14,57.84 18.21,56.92 18.21,55.22 18.66,54.77 18.66,50.19 17.07,48.61 17.07,40.52 17.68,39.91 17.68,33.6 17.43,33.35 17.43,31.89 18.99,30.33 18.99,25.56 17.88,24.45 17.88,21.82 18.86,20.83 v2(18.86,20.3)
  BOTTOM w0.102: D5501.2 v1(64.48,82.23) 64.38,82.12 62.98,82.12 62.32,81.46 v2(62.32,79.05) ; U2401.113 18.83,20.27 v2(18.86,20.3)
LCDVDD_MONITOR: length 2.1
  BOTTOM w0.102: Q5510.B 45.82,75.08 v1(45.88,75.14) 45.88,75.98 R5539.2
LCDVDD_MONITOR_BJT_B: length 2.3
  TOP w0.102: v1(35.11,69.54) 35.31,69.54 Q5509.B 35.83,70.34 R5538.2
LCDVDD_MONITOR_BJT_C: length 15.2
  TOP w0.102: Q5509.C 38.12,69.91 38.26,70.05 v2(38.43,70.05)
  L5 w0.102: v2(38.43,70.05) 38.43,73.34 41.66,76.56 45.15,76.56 v2(45.91,77.32)
  BOTTOM w0.102: v2(45.91,77.32) 46.2,77.32 v1(46.59,76.93) 46.7,76.82 R5539.1
LCDVDD_MONITOR_BJT_E: length 2.3
  TOP w0.102: Q5509.E 35.8,68.13 35.42,68.13 v1(35.03,67.73) 34.51,68.25 R5540.2
LCDVDD_MONITOR_R: length 4.8
  TOP w0.102: R5538.1 37.29,71.34 v1(37.55,71.61) 38.29,70.87 D5505.K 38.54,71 38.54,72.48 ; 38.54,72.48 C5555.1 ; 38.54,72.48 38.53,72.47 R5537.1
LDO1_CAP: length 5.6
  TOP w0.203: U2701.21 185.2,13.01 185.41,12.81 185.96,12.81
  TOP w0.254: v1(186.82,10.59) 186.94,10.47 R2702.1 187.66,10.63 C2703.1 187.14,12.03 187.07,12.03 186.3,12.79 185.97,12.79 185.96,12.81
LDO2_CAP: length 6.2
  TOP w0.203: U2701.32 184.11,18 184.28,18.16 184.3,18.16 184.62,18.48 185.14,18.48 185.66,19
  TOP w0.254: 185.66,19 187.54,19 C2711.2 v1(189.28,19.65)
LDO3_CAP: length 3
  TOP w0.203: 179.6,14.96 U2701.6
  TOP w0.254: 179.6,14.96 v1(179.32,14.96) 177.57,14.96 C2722.1
LID_CL_NB#: length 29.7
  TOP w0.102: HALL1.2 1.21,50.34 1.99,50.34 2.68,49.66 7.5,49.66 9.69,47.46 10.1,47.46 12.68,44.89 14.12,44.89 14.71,45.48 R6743.2 15.7,46.45 R6742.2 16.5,46.77 v2(16.52,46.79) 17.53,47.8 18.62,47.8 19.07,47.35 D6702.K
  BOTTOM w0.102: R6701.1 15.27,46.42 C6701.1 16.47,46.84 v2(16.52,46.79) 17.07,46.24 17.07,44.21 16.4,43.54 v1(16.4,43.47) 16.4,43.05 16.5,42.94 17.39,42.94 D6701.K
LID_CL_SIO#: length 305.7
  TOP w0.102: RN2405.7 20.63,15.66 20.73,15.55 22.32,15.55 22.44,15.68 v2(22.41,15.68) ; v2(10.93,68.8) 10.79,68.94 8.39,68.94 8.29,69.04 U6402.1 ; v2(21.36,46.63) 21.37,46.65 D6702.A ; ED6701.1 115.07,5.5 v2(114.29,4.72) 115.52,3.49 128.56,3.49 131.44,6.37 135.82,6.37 137.01,7.55 140.1,7.55 140.25,7.7 v2(140.25,8.29)
  L3 w0.102: v2(34.12,13.14) 36.8,13.14 37.09,13.42 40.53,13.42 41.93,14.82 42.51,14.82 42.55,14.78 72.19,14.78 72.45,14.53 88.98,14.53 89.31,14.19 91.65,14.19 92.31,13.53 96.03,13.53 96.74,12.82 107.06,12.82 114.29,5.59 v2(114.29,4.72)
  L5 w0.102: v2(21.86,40.06) 22.47,39.45 24.69,39.45 27.19,36.95 28,36.95 28.16,36.79 30.3,36.79 30.79,36.3 43.73,36.3 44.79,37.36 44.79,37.5 47.59,40.3 v2(48.14,40.3)
  L6 w0.102: v2(10.93,68.8) 11.25,69.12 11.25,69.37 12.3,70.42 16.55,70.42 17.85,69.13 17.85,67.48 18.58,66.75 18.58,66.39 17.94,65.76 17.94,64.76 18.91,63.79 18.91,62.45 20.1,61.26 20.1,60.47 20.1,60.19 21.86,58.43 21.86,56.01 20.91,55.06 20.91,54.91 20.91,47.09 v2(21.36,46.63) 22.16,45.83 22.16,44.04 22.14,44.02 22.14,40.34 v2(21.86,40.06) 21.28,39.48 21.28,32.22 18.97,29.92 18.97,28.93 18.99,28.92 18.99,28.8 20.99,26.8 20.99,26.07 21,26.06 21,24.35 21.92,23.42 21.92,16.59 21.85,16.51 21.85,16.06 22.23,15.68 v2(22.41,15.68) ; v2(104.59,45.39) 104.17,45.39 103.52,44.74 98.21,44.74 97.91,45.04 93.46,45.04 93.22,45.28 92.71,45.28 92.63,45.2 91.54,45.2 91.39,45.05 90.37,45.05 89.26,46.16 89.26,48.37 88.29,49.35 87.94,49.35 87.84,49.45 87.84,49.54 87.73,49.64 87.54,49.64 87.13,50.05 72.28,50.05 72.2,50.14 71.26,50.14 71.18,50.05 64.15,50.05 61.27,47.17 56.68,47.17 51.22,41.71 51.01,41.71 49.86,40.56 48.96,40.56 48.7,40.3 v2(48.14,40.3)
  L8 w0.102: v2(34.12,13.14) 33.48,13.14 32.38,14.24 29.27,14.24 27.47,16.04 22.96,16.04 22.59,15.68 v2(22.41,15.68)
  BOTTOM w0.102: U2401.66 30.57,11.69 30.62,11.63 31.76,11.63 33.45,13.33 v1(33.48,13.33) 33.93,13.33 v2(34.12,13.14) 34.81,13.82 D2402.K ; v2(104.59,45.39) 104.6,45.38 CPU1.CA34 ; FP1.6 139.85,8.68 v2(140.25,8.29)
LID_CL_SIO_TAB#: length 22.9
  BOTTOM w0.102: CPU1.BW37 103.66,42.62 103.66,40.42 v1(103.88,40.19) 104.18,39.89 104.18,37.87 105.7,36.35 111.85,36.35 112.56,37.06 112.56,37.4 112.67,37.5 114.97,37.5 115.22,37.25 115.22,36.93 115.47,36.69 115.8,36.69 116.04,36.93 116.04,38.15 116.55,38.65 117.46,38.65 R2042.2
LID_POWER_ON#: length 4.9
  TOP w0.102: R2497.2 19.73,23.82 R2495.2 19.36,23.8 19.22,23.66 v1(18.78,23.66) 18.78,23.97 v2(19.04,24.23)
  BOTTOM w0.102: v2(19.04,24.23) 18.95,24.23 18.56,24.62 18.56,24.64 17.74,25.47 U2401.126
LID_POWER_ON#_R: length 54.9
  TOP w0.102: R2495.1 20.5,23.88 v2(20.5,24.57)
  L3 w0.102: v2(9.49,26.21) 9.89,25.8 9.89,22.85 13.09,19.65 19.02,19.65 20.5,21.13 v2(20.5,24.57)
  L6 w0.102: v2(11.03,47.23) 10.5,46.71 10.5,37.16 9.21,35.87 9.21,30.33 9.41,30.13 9.49,30 9.55,29.87 9.58,29.72 10.32,28.98 10.32,27.94 9.49,27.1 v2(9.49,26.21)
  BOTTOM w0.102: C6702.1 15.21,44.4 v1(13.94,44.4) 13.86,44.4 v2(11.03,47.23) 11.3,47.23 12.83,48.77 12.83,50.18 14.05,51.4 14.73,51.4 Q6701.3
LINE1_L: length 3.6
  TOP w0.203: U2701.18 183.71,12.32 183.78,12.25 183.78,11.77 183.8,11.75 183.8,11.67 184.11,11.36
  TOP w0.254: 184.11,11.36 184.34,11.36 v1(184.64,11.06) 185.23,10.47 185.28,10.47 185.5,10.25 C2907.1
LINE1_R: length 3.1
  TOP w0.203: U2701.17 183.31,12.28 183.29,12.27 183.29,11.96
  TOP w0.254: C2908.1 184.31,10.45 184,10.76 184,10.92 183.29,11.63 183.29,11.96
LINE1_VREFO: length 6.3
  TOP w0.203: U2701.24 185.68,14.56 186.23,14.02 187.07,14.02 187.35,13.73 187.35,13.71 187.46,13.59
  TOP w0.254: 187.46,13.59 189.4,13.59 189.49,13.5 v1(189.91,13.5) 191.01,13.5 D2901.3
LINE1_VREFO_L: length 4.7
  TOP w0.127: RN2902.1 189.86,14.08 190.87,15.09 190.87,15.97 190.99,16.1 v1(191.03,16.1)
  TOP w0.254: D2901.1 191.52,16.14 191.07,16.14 v1(191.03,16.1)
LINE1_VREFO_R: length 1.9
  TOP w0.127: RN2902.2 189.7,14.73 190.08,15.11 D2901.2
LPS_SW: length 23.4
  TOP w0.254: 19.01,67.39 19.72,67.39 v2(19.77,67.44) ; 19.01,67.39 18.2,67.39 17.8,67.79 v1(17.8,68.02) R7402.1 ; 19.01,67.39 19.01,66.51 R7404.2 18.82,66.22 C7401.2 19.51,64.82 R7403.1 ; U7418.4 26.89,77.43 25.82,78.5 25.82,78.58 25.52,78.88 25.1,78.88 24.64,78.41 23.32,78.41 22.19,77.28 v2(22.19,75.16)
  L3 w0.254: v2(19.77,67.44) 19.77,68.08 21.69,69.99 21.69,74.65 v2(22.19,75.16)
LPS_SW_A: length 3
  TOP w0.254: Q7406.3 20.12,70.29 19.39,69.57 v1(19.22,69.57) 17.98,69.57 R7402.2
LPS_SW_B: length 3.3
  TOP w0.254: Q7401.D 22.37,62.88 v1(21.44,62.88) 21.44,62.93 20.56,63.8 20.56,64.45 R7403.2
LPS_SW_C: length 3.5
  TOP w0.254: Q7401.G 22.96,65.06 v1(22.45,65.57) 22.29,65.73 R7406.2 22.29,67.42 R7405.1
LPS_SW_D: length 1.3
  TOP w0.254: Q7406.6 21.42,68.07 R7405.2
LVDS_VDD_EN_R: length 16.7
  TOP w0.102: v2(60.24,85.73) 60.64,86.14 60.64,86.7 60.41,86.93 RN5502.7
  BOTTOM w0.102: v2(60.24,85.73) 60.67,85.73 61.48,84.92 61.48,83.67 61.73,83.42 62.61,83.42 D5501.3 63.54,83.29 63.43,83.18 v1(63.4,83.18) 63.3,83.09 62.87,83.09 61.18,81.39 61.18,77.07 61.32,76.93 U5501.4
M2_PCIE_LED2#: length 19.8
  TOP w0.127: v2(195.18,18.5) 194.98,18.7 R6626.2
  L3 w0.127: v2(195.18,18.5) 195.24,18.44 195.24,15.09 195.84,14.49 195.84,7.14 195.98,7 195.98,4.04 v2(196.77,3.26)
  BOTTOM w0.127: v2(195.18,18.5) 196.17,17.52 v1(196.17,16.72) ; IO2.28 196.32,3.7 v2(196.77,3.26)
M2_PCIE_LED#: length 261.6
  TOP w0.127: v2(29.93,44.38) 29.68,44.63 v1(29.68,45.12) ; D6401.2 20.16,74.1 20.52,73.73 v2(20.52,73.45) ; R6626.1 193.03,18.7 189.82,21.91 189.82,22.23 189.67,22.39 v3(189.61,22.39)
  L3 w0.127: v2(165.13,16.38) 166.31,16.38 168.63,18.7 168.63,18.78 168.89,19.04 171.13,19.04 171.58,18.59 174.35,18.59 175.85,20.09 179.38,20.09 181.22,21.93 182.29,21.93 182.74,21.48 182.74,21.03 183.06,20.71 183.83,20.71 185.05,21.93 186.25,21.93 186.44,22.11 186.78,22.11 187.15,22.48 189.51,22.48 v3(189.61,22.39) ; v2(20.52,73.45) 20.07,72.99 20.07,69.85 18.89,68.66 18.89,66.67 17.73,65.51 17.73,62.93 16.88,62.08 16.88,60.2 14.87,58.2 14.87,51.53 12.98,49.63 12.98,47.73 12.62,47.38 12.62,44.24 13.79,43.07 13.79,41.92 v2(14.5,41.21)
  L5 w0.127: v2(14.5,41.21) 17.96,44.67 18.46,44.67 18.72,44.41 18.72,44.28 20.72,42.28 23.9,42.28 24.82,43.2 28.76,43.2 v2(29.93,44.38)
  L6 w0.127: v3(110.3,18.99) 112.69,18.99 115.16,21.47 116.84,21.47 117.75,20.55 119.74,20.55 121.33,22.15 124.65,22.15 125.07,21.72 133.16,21.72 133.52,22.08 134.33,22.08 134.82,22.57 134.82,22.93 134.81,22.94 134.81,23.36 135.3,23.85 136.26,23.85 139.69,20.41 143.17,20.41 144.48,19.1 147.03,19.1 147.56,19.63 148.46,19.63 148.85,20.02 153.84,20.02 154.67,20.85 159.16,20.85 161.18,18.83 163.82,18.83 164.56,18.09 164.8,18.09 165.56,17.33 165.56,16.81 v2(165.13,16.38)
  L8 w0.127: v2(29.93,44.38) 29.69,44.14 29.69,39.61 33.28,36.03 36.37,36.03 36.37,36.03 36.68,35.88 39.61,32.95 39.67,32.95 42.47,30.15 v2(42.48,30.15)
  BOTTOM w0.127: R6405.2 19.6,72.52 v2(20.52,73.45) ; SSD1.10 114.39,18.14 114.21,18.32 110.96,18.32 v3(110.3,18.99) 110.3,18.96 109.08,17.74 55.2,17.74 53.08,19.86 47.04,19.86 43.17,23.72 43.17,29.38 42.69,29.87 42.69,29.94 v2(42.48,30.15)
M2_SSD_PEDET: length 67.8
  TOP w0.102: v2(124.26,33.2) 123.6,33.85 119.86,33.85 119.17,34.54 118.41,34.54 118.09,34.22 117.9,34.09 117.68,34 117.46,33.96 115.95,33.96 R6305.2
  L5 w0.102: v2(124.26,33.2) 124.26,34.76 130.29,40.79 130.29,43.31 131.33,44.34 131.33,46.85 131.14,47.03 131.14,49.52 131.33,49.71 131.33,55.89 131.04,56.18 131.04,57.49 131.46,57.91 133.36,57.91 v2(133.66,57.6)
  BOTTOM w0.076: CPU1.CP10 112.06,59.9 112.25,60.09 arc(112.32,60.14) 112.41,60.16 112.43,60.16 112.44,60.17 113.71,60.17 113.72,60.16 114.6,60.16
  BOTTOM w0.102: SSD1.69 123.95,32.89 v2(124.26,33.2) 124.96,32.49 AFTP6303.1 ; v2(133.66,57.6) 133.66,58.64 130.73,61.58 129.97,61.58 129.65,61.26 123.91,61.26 123.35,61.82 119.51,61.82 119.45,61.88 116.93,61.88 116.87,61.82 116.73,61.82 115.12,60.21 114.65,60.21 114.6,60.16
M_A_A0: length 49.3
  TOP w0.152: RN1201.5 55.94,20.92 v3(55.94,23.32) 55.71,23.32 55.03,24 55.03,24.61 RAM1.R2
  L5 w0.152: v3(79.63,40.34) 79.2,40.34 79.03,40.18 79.03,36.65 79.27,36.42 79.27,34.47 77.24,32.44 70.29,32.44 69.91,32.82 65.71,32.82 61.9,29.01 61.9,27.8 59.67,25.57 59.67,24.93 60.03,24.57 60.03,23.96 60.19,23.8 60.91,23.8 61.13,23.59 61.13,23.25 60.92,23.04 60.19,23.04 60.03,22.89 60.03,22.15 59.78,21.9 59.02,21.9 57.87,23.04 56.21,23.04 v3(55.94,23.32)
  BOTTOM w0.076: 80.29,40.83 80.29,42.98 80.34,43.11 80.34,43.33 80.3,43.43 80.3,43.72 80.21,43.84 CPU1.AB35
  BOTTOM w0.114: 80.29,40.83 79.8,40.34 v3(79.63,40.34)
M_A_A1: length 48.5
  TOP w0.152: RAM1.P2 54.38,24.61 54.38,24.09 v3(54.59,23.88) 55.22,23.25 RN1201.6
  L5 w0.152: v3(77.34,39.93) 77.81,39.45 77.81,36.12 78.05,35.89 78.05,34.97 76.73,33.66 70.79,33.66 70.42,34.04 65.21,34.04 64.53,33.36 64.32,33.36 63.89,33.79 63.68,33.79 63.46,33.57 63.46,33.36 63.89,32.93 63.89,32.71 63.67,32.5 63.45,32.5 63.03,32.92 62.81,32.92 62.6,32.71 62.6,32.49 63.02,32.07 63.02,31.85 62.81,31.64 62.59,31.64 62.17,32.06 61.95,32.06 61.73,31.85 61.73,31.63 62.16,31.2 62.16,30.99 60.68,29.51 60.68,28.51 57.75,25.57 57.75,25.36 58.08,25.02 58.08,24.81 57.86,24.59 57.65,24.59 57.31,24.93 57.1,24.93 56.54,24.37 55.08,24.37 v3(54.59,23.88)
  BOTTOM w0.076: 78.23,40.83 78.23,42.51 78.47,42.75 78.47,43.02 78.44,43.07 78.42,43.09 78.37,43.19 78.37,43.21 78.22,43.49 CPU1.W36
  BOTTOM w0.152: 78.23,40.83 78.23,40.08 78.09,39.93 v3(77.34,39.93)
M_A_A2: length 50.3
  TOP w0.152: RAM1.N2 53.73,24.61 53.73,23.9 v3(53.55,23.72) 54.07,23.21 54.07,20.85 RN1201.8
  L6 w0.152: v3(53.55,23.72) 54.13,24.31 54.77,24.31 54.87,24.21 57.79,24.21 58.49,24.9 58.49,25.01 67.1,33.62 70.54,33.62 71.29,32.87 75.96,32.87 76.37,33.28 76.91,33.28 77.81,34.19 77.81,35.81 v3(77.34,36.29)
  BOTTOM w0.076: CPU1.AA37 79.57,42.76 79.57,41.93 79.19,41.56 79.19,38.75
  BOTTOM w0.152: 79.19,38.75 79.13,38.69 79.13,34.11 78.99,33.96 77.72,33.96 77.57,34.12 77.57,34.44 77.76,34.63 78.36,34.63 78.51,34.78 78.51,35.18 78.41,35.28 77.94,35.28 77.84,35.38 77.84,36.05 77.6,36.29 v3(77.34,36.29)
M_A_A3: length 46.6
  TOP w0.089: RAM1.N3 54.05,25.09 54.05,23.83 v3(54.59,23.29)
  TOP w0.152: v3(54.59,23.29) 54.72,23.17 RN1201.7
  L5 w0.152: v3(54.59,23.29) 55.06,23.77 58.55,23.77 59.07,24.28 59.07,26.03 61.29,28.25 61.29,29.26 65.46,33.43 70.16,33.43 70.54,33.05 76.99,33.05 78.66,34.72 78.66,36.17 78.42,36.4 78.42,40.46 79.47,41.51 v3(79.68,41.51)
  BOTTOM w0.076: v3(79.68,41.51) 79.75,41.58 79.75,44.42 79.85,44.52 CPU1.AB34
M_A_A4: length 51.3
  TOP w0.089: RAM1.M3 53.08,25.41 53.39,25.1 53.39,24.51 53.38,24.49 53.38,24.49 53.2,24.32 53.2,24.32 53.14,24.25 53.14,23.78
  TOP w0.152: R1206.2 53.1,22.69 v3(53.55,23.14) 53.14,23.55 53.14,23.78
  L6 w0.152: v3(77.34,37.46) 77.36,37.46 77.77,37.05 77.77,36.83 78.42,36.18 78.42,33.93 77.11,32.62 76.57,32.62 76.21,32.26 71.04,32.26 70.28,33.01 68.19,33.01 63.51,28.33 63.51,26.99 60.81,24.29 58.74,24.29 57.31,22.86 53.83,22.86 v3(53.55,23.14)
  BOTTOM w0.076: CPU1.AA36 79.43,43.48 79.22,43.08 79.18,43.01 79.18,42.73 79.4,42.51 79.4,42 79.03,41.63 79.03,39.15 78.83,38.95
  BOTTOM w0.152: v3(77.34,37.46) 77.87,37.46 78.18,37.15 78.18,35.81 78.28,35.71 78.73,35.71 78.83,35.81 78.83,38.95
M_A_A5: length 52.2
  TOP w0.076: 49.18,25.41 49.18,25.19 49.5,24.88 49.5,24.32 49.55,24.27 49.55,23.88 49.43,23.77
  TOP w0.152: v3(49.52,25.81) 49.53,25.81 49.53,25.8 49.49,25.8 49.18,25.48 49.18,25.41 RAM1.F3 ; 49.43,23.77 49.43,23.21 48.54,22.31 R1205.2
  L5 w0.152: v3(49.52,25.81) 49.53,25.81 49.53,25.8 50,25.8 50.62,25.18 52.74,25.18 53.74,26.19 55.56,26.19 55.78,26.42 55.78,26.99 56.92,28.12 57.24,28.12 58.6,29.48 58.6,32.54 64.96,38.91 67.46,38.91 69.34,37.03 70.51,37.03 71.67,38.19 71.67,40.76 72.02,41.12 73.61,41.12 74.08,40.64 74.08,39.76 v3(75.38,38.46)
  BOTTOM w0.152: CPU1.V34 77.25,44.21 77.25,41.96 76.9,41.6 76.9,41.23 76.38,40.71 76.38,39.43 75.42,38.46 v3(75.38,38.46)
M_A_A6: length 51.7
  TOP w0.102: RAM1.E3 48.82,25.12 48.82,24.75 48.83,24.74 48.83,24.49 48.75,24.4 48.75,23.88
  TOP w0.152: 48.75,23.88 48.75,23.34 47.68,22.26 RN1202.3 ; RAM1.E3 48.53,25.51 48.81,25.79 48.81,25.82 v3(48.83,25.82)
  L6 w0.152: v3(48.83,25.82) 49.28,25.36 49.67,25.36 50.03,25.45 50.38,25.45 50.74,25.36 53.14,25.36 53.8,26.02 57.61,26.02 66.7,35.11 71.85,35.11 72.87,34.09 75.31,34.09 75.86,34.64 75.86,36.84 77.05,38.03 v3(77.33,38.12)
  BOTTOM w0.076: CPU1.AA34 79.13,44.22 79.13,43.27 79.01,43.06 79.01,42.66 79.24,42.44 79.24,42.07 78.86,41.7 78.86,39.65 78.49,39.28
  BOTTOM w0.152: v3(77.33,38.12) 77.57,37.88 78.39,37.88 78.49,37.99 78.49,38.46 78.35,38.6 77.91,38.6 77.81,38.71 77.81,39.18 77.91,39.28 78.49,39.28
M_A_A7: length 50.1
  TOP w0.152: 48.53,24.61 48.23,24.31 48.23,23.42 47.03,22.22 RN1202.4 ; 48.53,24.61 48.19,24.95 v3(48.19,25.02) ; 48.53,24.61 RAM1.E2
  L6 w0.152: v3(48.19,25.02) 48.45,24.75 49.82,24.75 49.99,24.59 50.35,24.59 50.37,24.62 53.3,24.62 53.83,25.15 54.79,25.15 55.12,24.82 56.65,24.82 57.02,25.18 57.72,25.18 66.8,34.27 70.55,34.27 72.76,33.48 75.58,33.48 v3(77.38,34.92)
  BOTTOM w0.076: CPU1.W34 78.02,44.5 77.96,44.29 77.96,43.43 77.98,43.36 77.98,43.08 77.91,42.88 77.91,42.77 77.9,42.76 77.9,41.28 77.52,40.9 77.26,40.9 77.11,40.85 76.99,40.74 76.9,40.32 76.9,38.8
  BOTTOM w0.152: 76.9,38.8 76.9,35.4 v3(77.38,34.92)
M_A_A8: length 51.3
  TOP w0.152: 47.88,24.61 47.88,24.05 46.13,22.3 RN1206.3 ; 47.88,24.61 RAM1.D2 ; 47.88,24.61 47.56,24.93 v3(47.56,25.03)
  L5 w0.152: v3(47.56,25.03) 47.56,22.75 47.68,22.63 48.3,22.63 48.6,22.93 48.6,24.4 48.79,24.59 50.32,24.59 50.5,24.78 52.95,24.78 54.01,25.84 55.93,25.84 58.38,28.29 59.21,29.12 59.21,31.62 61.36,33.77 61.36,33.99 61.63,34.26 61.85,34.26 63.11,35.51 71.05,35.51 73.44,37.9 73.79,37.9 73.81,37.88 v3(75.4,37.88)
  BOTTOM w0.076: 76.7,40.68 77.08,41.07 77.45,41.07 77.74,41.35 77.74,42.94 77.77,42.98 77.82,43.11 77.82,43.33 77.79,43.42 77.79,43.65 CPU1.V35
  BOTTOM w0.152: v3(75.4,37.88) 75.4,37.88 75.4,37.9 76.7,39.2 76.7,40.68
M_A_A9: length 50.1
  TOP w0.152: RN1206.4 45.48,22.29 46.14,22.95 46.25,22.95 47.35,24.04 47.35,24.5 RAM1.C2 46.92,24.92 46.92,24.99 v3(46.92,25)
  L6 w0.152: v3(77.33,39.31) 76,40.64 75.27,40.64 74.66,40.04 74.66,39.13 73.74,38.21 73.32,38.21 70.82,35.72 65.09,35.72 57.3,27.93 48.76,27.93 48.19,27.35 48.19,26.59 47.76,26.17 47.76,25.84 v3(46.92,25)
  BOTTOM w0.076: 78.62,41.37 78.62,41.73 78.4,41.95 78.4,42.44 78.63,42.68 78.63,43.06 78.53,43.25 78.53,44.12 78.46,44.19 CPU1.W35
  BOTTOM w0.152: v3(77.33,39.31) 77.64,39.62 78.39,39.62 78.62,39.85 78.62,41.37
M_A_B0: length 40.3
  TOP w0.152: RN1207.3 75.06,16.99 75.06,18.62 74.32,19.36 v3(74.32,19.97) 74.32,20.71 74.16,20.87 RAM2.R2
  L3 w0.114: v3(74.32,19.97) 74.32,19.94 74.38,19.99 76.81,19.99 81.19,24.37 81.19,24.74 81.08,24.85 80.49,24.85 80.38,24.97 80.38,25.2 80.49,25.31 81.08,25.31 81.19,25.42 81.19,33.37 80.61,33.95 80.61,40.03 80.49,40.15 80.25,40.15 80.13,40.26 80.13,40.49 80.25,40.61 80.49,40.61 80.61,40.72 80.61,40.95 80.49,41.06 80.25,41.06 80.13,41.18 80.13,41.41 80.25,41.52 80.49,41.52 80.61,41.63 80.61,42.57 80.44,42.74 80.21,42.74 80.1,42.85 80.1,43.08 80.21,43.19 80.44,43.19 80.56,43.31 80.56,43.54 80.44,43.65 80.21,43.65 80.1,43.77 80.1,43.99 80.21,44.11 80.44,44.11 80.56,44.22 80.56,44.45 80.44,44.57 80.21,44.57 80.1,44.68 80.1,44.91 80.21,45.02 80.44,45.02 80.56,45.14 v3(80.56,46.12)
  BOTTOM w0.152: CPU1.AC32 v3(80.56,46.12)
