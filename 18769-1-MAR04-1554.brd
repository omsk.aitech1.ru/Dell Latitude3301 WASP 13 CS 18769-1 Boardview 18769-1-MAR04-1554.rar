# Allegro board 18769-1-MAR04-1554.brd (continued)
## Library data of the parts (continued)
C2218 C2604 C2723 C3302 C3312 C5502 C5503 C5515 C7610 C7611 C7620 C7621 C7934 C8001-C8004 C8008 C8009 C8015 C8016 C8019-C8025 C8030-C8032 PC4422 PC4452 PC4507 PC4551 PC5102 = C603H36: tolerance: 78.47520.5BLDL
C2405 C2739 PC44A1 PC44A9 PC44B1 PC44B3 PC44C1 = C402H22: tolerance: 78.10134.1FLDL
C2424 C2425 = C402H22: tolerance: 78.18034.1FLDL
C2427 C2702 C2703 C2705 C2708 C2709 C2740 C3304 C3307 C4009 C7201-C7203 PC44C2 PC4562 PC5001 PC8617 = C603H36: tolerance: 78.22523.5BLDL
C2435 C2436 C2441 C2607 C5555 C5557 PC4601 PC4611 PC4612 PC4623 PC4632 PC4640 = C402H22: tolerance: 78.22224.2FLDL
C2606 C4001 C4002 PC4614 PC4618 = C402H22: tolerance: 78.47124.2FLDL
C3301 C3313 = C402H22: tolerance: 78.6R074.1FLDL
C4003 C6302 C6303 C6311-C6316 C7212 PC8612 = C402H22: tolerance: 078.22423.05FD
C4004 C4005 C4306 C5514 C7305 EC4301 PC4402 PC4404-PC4406 PC4441-PC4444 PC4449 PC4450 PC4461 PC4462 PC4554 PC4555 PC5002 PC5003 PC5101 PC5105 PC5209 PC5210 PC8551-PC8553 PC8568 PC8610 PC8615 = C805H58: tolerance: 78.10622.51LDL
C4040 C4302 C5512 C5556 C7101 C7102 C7115-C7118 C7161-C7164 C7302-C7304 C7307 C7616 C8525 EC4302 EC4303 EC8908-EC8917 FC8901-FC8938 PC44B2 PC4401 PC4420 PC4501 PC4506 PC4508 PC4513 PC4552 PC4553 PC4564 PC4565 PC4602 PC4603 PC4631 PC4633 PC5004 PC5108 PC5110 PC5114 PC5156 PC5204 PC5208 PC8554 PC8556 PC8562 PC8569 PC8619 = C402H22: tolerance: 78.10422.5FLDL
C4301 = C603H36: tolerance: 078.10524.05BD
C4303-C4305 C6106 C6111 C8101 C8201 PC4654 PC5213 = C402H22: tolerance: 78.10322.2FLDL
C4344 C5513 EC2701-EC2705 EC2901-EC2904 EC4307 EC4312 EC4401-EC4408 EC8918-EC8934 EC8939-EC8954 PC4432 PC4433 PC4435 PC4526 PC4563 PC4616 PC4617 PC4619 PC4642 PC4643 PC4651 PC4710 PC4713 PC4806 PC8560 = C402H22: tolerance: 78.10224.2FLDL
C6304 C6305 EC2706 EC5503 EC5504 EC6501 EC6502 PC4610 PC4624 PC4639 PC8561 PC8563 PC8564 PC8566 = C402H22: tolerance: 78.33034.1FLDL
C7120-C7123 = C0201H13: tolerance: 078.33410.05S1
C7301 C7306 PC4416 PC4417 PC4419 PC4424 PC4425 PC4439 PC4440 PC4451 = C603H36: tolerance: 78.10522.5BLDL
C7401 PC4469 PC5115 = C402H22: tolerance: 78.15224.2FLDL
C7907 C7908 = C402H22: tolerance: 78.20034.1FLDL
C8126 C8202 = C402H22: tolerance: 78.82124.2FLDL
C8901-C8903 PC44C3 PC4702-PC4705 PC4714-PC4717 PC4801-PC4804 = C603H40: tolerance: 078.10612.05BD
CARD1 = 503398-0891: tolerance: 62.10051.I71
CN1 = DF30FC-20DP-D4V-81: tolerance: 20.F1450.020
CPU1 = BGA1528M2446-1H52: tolerance: ZZ.00CPU.271
D1701 PD4407 = SOD523AKH26: tolerance: 83.R2003.A8M
D2401 D2501 D2703 D5501 D5502 D8601 PD4401 PD4408 = SOT-23-9H44: tolerance: 75.00054.A7D
D2402 D6702 = SOD323-2513AKH36: tolerance: 83.R2004.J8F
D2403 D4001 D6701 D7902 PD44A1 PD44B1 PD4403 = SOD323AKH44: tolerance: 83.00355.G1F
D2503 D6401 = SOT-23-9H44: tolerance: 75.BAT54.07D
D2901 D5701 = SOT23-2D4-312H44: tolerance: 75.00056.07D
D4301 = D4724AKH44: tolerance: 083.00624.00AM
D4302 ED4304-ED4306 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D4303 = SOT23-2D4-312H60: tolerance: 83.03024.0A1
D4304 = SOD123AK-2H43: tolerance: 83.SMF18.AAH
D5504 D5505 = SOD323AKH38: tolerance: 83.R5003.H8H
D6402 = SOD323AKH38: tolerance: 83.R2004.B8F
D7301 = D4724AKH44: tolerance: 83.3R010.C8M
DB1 = 87212-1400N: tolerance: 20.F0765.014
DB3 = 50696-00601-001: tolerance: 20.K0691.006
DCIN1 = 50224-0080N-W02-U: tolerance: 20.F1295.008
EC1901 EC2501 EC2601 EC2602 EC4306 EC4309 EC4310 EC6401 EC6402 PC4430 = C402H22: tolerance: 78.10034.1FLDL
EC2709-EC2711 PC5305 PC8624 PC8632 = C402H22: tolerance: 078.22034.M004
EC4308 = C603H35: tolerance: 78.10424.2BLDL
ED301 = SOT23-2D4-312H46: tolerance: 75.05125.07D
ED1701-ED1704 = SOD882-10D6-1H20: tolerance: 083.00051.00AF
ED1706 ED1707 ED5503 ED5504 ED6701 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
ED5501 = SOT-6H58: tolerance: 075.09904.0A7C
ED5502 = DFN10G2510-1H20: tolerance: 075.PUSB3.0073
ED5701-ED5703 ED7301-ED7304 ED9201 = SLP2510P8-1H22: tolerance: 075.00550.0071
EL4301-EL4304 ER7301 ER7302 PG5152 R5546 R6302 = R805H24: tolerance: 63.R0031.16L
EL5501 EL7201 EL7202 = LD85D65-4P-1H20: tolerance: 068.09002.2001
ER2901-ER2904 R9213 = R603H22: tolerance: 63.00000.00L
ER5714-ER5717 = R402H16: tolerance: 63.15134.1DL
F5502 F5701 = POLYSW-2114H30: tolerance: 69.48001.081
F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F6501 = POLYSW-2114H30: tolerance: 69.50011.081
FAN1 SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
FC8939-FC8973 = C402H22: tolerance: 78.12034.1FLDL
FP1 = FH52-8S-D5SH: tolerance: 20.K0767.008
FSW1 = MSS3-Q-T-R: tolerance: 62.40018.641
G1801 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA595M23H83: tolerance: 071.0N17S.0000
H5 H9-H12 H20 = HOLE233R142: tolerance: ZZ.00PAD.5S1
H13-H15 = HOLE276R150: tolerance: ZZ.00PAD.H91
H22 = HOLET237B213R142: tolerance: ZZ.SCREW.0A1
HALL1 = SOT23-2D8-312H56: tolerance: 074.09247.009B
HDMI1 = SKT-HDMI23-178125-2: tolerance: 022.10025.00A1
HS1 HS2 = STFT237B158R128H48: tolerance: 434.0FD01.0001
IO1 = 20455-030E-12: tolerance: 020.F1027.0030
IO2 = DF40C-40DP-D4V-51: tolerance: 20.F1985.040
KB1 = 50699-03001-W01: tolerance: 020.K0254.0030
KBBL1 = 50698-00401-W01-U: tolerance: 020.K0298.0004
L7801 L7901 = L603H38: tolerance: 68.00335.051
LCD1 = 20879-040E-01: tolerance: 020.F1308.0040
LED1 = LED3020-3P-19H44: tolerance: 083.1212A.0070
PC4415 PC4502 PC4503 PC5202 = C805H54: tolerance: 78.47522.51LDL
PC4423 PC4436 PC4606 PC4708 PC4711 PC4807 PC5005 = C603H36: tolerance: 78.22422.2BLDL
PC4429 PC8565 = C402H22: tolerance: 78.47224.2FLDL
PC4431 PC4613 PC4615 PC4620 PC4622 PC4637 PC4644 PC8557 PC8567 PC8609 = C402H22: tolerance: 78.10324.2FLDL
PC4465 PC4466 = C805H58: tolerance: 078.22612.051D
PC4604 PC4629 PC4638 PC4641 PC8602 = C402H22: tolerance: 78.33124.2FLDL
PC4621 = C402H22: tolerance: 78.68124.2FLDL
PC4709 PC4712 PC4766 PC4777 PC4808 PC4866 PC5103 PC5104 PC8555 = C402H22: tolerance: 78.22510.5FLDL
PC5152 = C402H22: tolerance: 78.68034.1FLDL
PC5153 PC8558 PC8559 PC8570 PC8571 = C805H54: tolerance: 78.22610.51LDL
PD5101 = SOD323AKH40: tolerance: 083.04024.0AA1
PG4401 PG4402 PG4405 PG4406 PG4408 PG4530 PG4532 PG4562 PG4565 PG4601 PG4708 PG4709 PG4713 PG4715 PG4807 PG4808 PG5001 PG5011 PG5104-PG5116 PG5201-PG5203 PG5210 PG5302 PG5303 PG8601-PG8621 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PL4401 = L109100-2430-UH119: tolerance: 068.2R210.2351
PL4501 PL4551 PL5101 = L7066-1830-UH119: tolerance: 68.1R510.10K
PL4701 PL4702 PL4801 PL8551 PL8552 = L7366-1830H119: tolerance: 068.R1510.1171
PL4703 PL4704 PL4802 PL4803 = L20125H42: tolerance: 68.00216.191
PL5001 = L7066-1830-UH119: tolerance: 68.R4710.10M
PL5201 = L7066-1830-UH119: tolerance: 68.1R01A.20B
PL5301 PL8601 PL8602 = L2520-D620H48: tolerance: 068.1R010.1281
PL8603 = L4947-1115H119: tolerance: 68.1R010.20R
PQ44A1 PQ44B1 PQ4405 PQ4415 PQ4416 PQ4418 PQ4452 Q401 Q1702 Q2416 Q2601 Q5702 Q6504 Q6701 Q7404 Q7405 Q8614 = SOT-363H44: tolerance: 75.27002.F7C
PQ4402 PQ4417 Q502 Q2408 Q2414 Q2505 Q2510 Q2602 Q4001 Q5703 Q8504 Q8602 Q8603 Q8605 Q9202 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4408 Q5509 Q5512 = SOT23CBE2D4H44: tolerance: 84.03906.R11
PQ4451 Q2507 = SOT23DGS2D4H48: tolerance: 084.02421.0031
PR44A1 = R402H16: tolerance: 64.24935.6DL
PR44A2 = R402H16: tolerance: 64.36535.6DL
PR44A3 = R402H16: tolerance: 64.10735.6DL
PR44A4 PR44B4 PR44C1 PR44C3 PR4443 PR4460 PR4467 PR4609 PR5152 PR5204 R2449 R7602 R7816 R7820 R7821 R7824 = R402H16: tolerance: 64.10025.6DL
PR44A5 PR44C5 PR44C6 R1708 R5718 R7204 R7218 R7219 R9121 R9124 R9131 = R402H16: tolerance: 63.R0034.1DL
PR44A6 = R402H16: tolerance: 64.20535.6DL
PR44B1 PR2455 R5711 = R402H16: tolerance: 64.15035.6DL
PR44B2 R2711 R5710 R7402 R7408-R7410 = R402H16: tolerance: 64.20035.6DL
PR44B3 = R402H16: tolerance: 64.13335.6DL
PR44B5 PR44B6 PR44C4 PR4406 PR4409 PR4417 PR4429 PR4435 PR4437 PR4438 PR4442 PR4461 PR4462 PR4464 PR4466 PR4472 PR4608 PR4629 PR4721-PR4724 PR5203 PR5305 PR5306 PR8611 PR8612 R1506 R1508 R1510 R1524 R1716 R1718 R1731 R2441 R2444 R6305 R7215 R7405 R7406 R7423-R7428 R7908 R7909 R7911 R7914 R7915 R7918-R7921 R7924-R7926 R7928 R7929 R7932 R7935 R7938 R7939 R8534 = R402H16: tolerance: 64.10035.L3L
PR44B7 = R402H16: tolerance: 64.16535.6DL
PR44C2 = R402H16: tolerance: 64.16925.6DL
PR44C7 = R402H16: tolerance: 64.13325.6DL
PR4401 = R1206H38: tolerance: 64.R0105.81L
PR4402 PR4408 PR4704 PR4710 PR4805 PR5001 PR8551 PR8556 PR8561 PR8573 = R603H24: tolerance: 64.2R205.L0L
PR4403 PR4416 PR5110 = R805H24: tolerance: 63.2R231.16L
PR4404 = R402H16: tolerance: 64.40235.6DL
PR4405 = R402H16: tolerance: 64.4R705.6DL
PR4407 = RL3720H40: tolerance: 64.R0055.7FL
PR4410 = R402H16: tolerance: 64.93125.6DL
PR4411 PR4636 PR4658 R302 R6401 = R402H16: tolerance: 64.49905.6DL
PR4413 = R402H16: tolerance: 64.13725.6DL
PR4422 PR4424 PR4425 PR4482 = R402H16: tolerance: 64.1R005.6DL
PR4426 = R402H16: tolerance: 64.19635.6DL
PR4436 PR4514 PR4556 PR5156 R1841 R2567 R5558 R6701 R7208 R7214 R7231 R7237 R7241 R7242 R7245 R7250 R7903 R8604 = R402H16: tolerance: 63.10534.1DL
PR4439 R6702 = R402H16: tolerance: 64.68035.6DL
PR4440 PR4465 PR4471 PR4613 PR5107 PR5310 PR5311 PR8510 PR8517 PR8520 PR8522 PR8621 PR8623 PR8630 PR8631 PR8634 R709 R732 R1605 R1704 R1706 R1713 R1806 R2003 R2004 R2025-R2027 R2102 R2119 R2401 R2402 R2405 R2406 R2440 R2445 R2447 R2473 R2477 R2482 R2495 R2505 R2601 R2708 R2709 R2712 R2719 R2734 R2741 R3321 R3329 R4011 R4039 R4502 R4503 R5510 R5512 R5536 R5540 R6104 R6105 R6301 R6421 R6422 R6603 R6605 R6607 R6626 R6744 R7001-R7006 R7114 R7116 R7124 R7149 R7151 R7153 R7201 R7211 R7212 R7216 R7217 R7220 R7221 R7227 R7229 R7235 R7236 R7403 R7957 R8110 R8209 R8523 R8525 R8530 R8617 R8621 R8626 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR4441 PR4469 PR4470 = R402H16: tolerance: 64.R0005.6DL
PR4459 PR4463 PR4614 PR4669 PR8571 PR8632 R1601 R1602 R1908 R1920 R2407 R2410 R2427 R2461 R2471 R3306-R3311 R3314-R3320 R3322-R3324 R3326 R4010 R4024 R4040 R5502 R5521 R5522 R5701-R5708 R6106-R6110 R6314 R6419 R6505 R6506 R6510 R6601 R6602 R6604 R6606 R6745 R6801-R6803 R7604 R7937 R8521 R8524 R8531-R8533 R8611 R8614 R8615 R9102 R9123 R9130 R9209 R9210 R9806 = R402H15: tolerance: 63.R0034.L0L
PR4468 PR4505 PR4552 PR5104 PR5208 R303 R403 R1715 R1727 R1737 R2403 R2404 R2415 R2434 R2435 R2451-R2456 R2480 R2489 R2497 R2518 R2520 R2702 R2710 R2716 R2717 R4309 R4310 R4378 R5504 R5535 R6103 R6508 R6509 R6742 R6743 R7101 R7102 R7202 R7905 R7910 R8612 R8613 R8616 R9201 R9212 = R402H16: tolerance: 63.10434.1DL
PR4483 PR4604 PR4607 PR4627 PR4631 PR4659 PR4685 PR4686 PR8569 PR8577 R719 R720 R726 R807-R810 R1604 = R402H14: tolerance: 64.10005.6DL
PR4485-PR4492 PR4494 PR4496-PR4498 PR4612 PR4623 PR4647 PR4649 PR4665 PR4666 PR4692-PR4695 PR4702 PR4706 PR4711 PR4712 PR4801 PR4802 PR4806 PR5004 PR5153 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR4501 PR4554 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
PR4502 = R402H16: tolerance: 64.34835.6DL
PR4506 PR4555 PR4603 PR4615 PR4635 PR4645 PR4651 R3331-R3333 R9805 = R402H16: tolerance: 64.10015.6DL
PR4508 PR4509 PR4557 PR4558 PR8562 = R402H16: tolerance: 64.49935.6DL
PR4605 = R402H16: tolerance: 64.75R05.6DL
PR4606 = R402H16: tolerance: 64.45R35.6DL
PR4610 = R402H16: tolerance: 63.1R034.1DL
PR4611 PR4646 PR4650 = NTC-402H22-U: tolerance: 69.60011.201
PR4616 PR8627 R4302 R7206 = R402H16: tolerance: 64.15025.6DL
PR4617 PR4654 = NTC-402H22-U: tolerance: 069.60012.0001
PR4618 PR4643 PR4652 = R402H16: tolerance: 64.11025.6DL
PR4620 = R402H16: tolerance: 64.43005.6DL
PR4621 = R402H16: tolerance: 64.27425.6DL
PR4622 PR4709 PR4715 R1224 R1323 = R402H16: tolerance: 64.10R05.L1L
PR4624 R304 R305 R601 = R402H16: tolerance: 64.49R95.6DL
PR4625 PR4641 PR4653 = R402H16: tolerance: 64.26115.6DL
PR4626 = R402H16: tolerance: 64.33015.6DL
PR4628 = R402H16: tolerance: 64.93115.6DL
PR4630 PR4638 PR4657 = R402H16: tolerance: 64.20015.L0L
PR4632 = R402H16: tolerance: 64.30105.6DL
PR4633 = R402H16: tolerance: 64.25515.6DL
PR4637 = R402H16: tolerance: 64.17815.6DL
PR4640 R7601 = R402H16: tolerance: 64.24915.L0L
PR4642 = R402H16: tolerance: 64.53605.6DL
PR4644 R7907 = R402H16: tolerance: 64.40225.6DL
PR4648 = R402H16: tolerance: 64.36505.6DL
PR4655 = R402H16: tolerance: 64.23225.6DL
PR4656 = R402H16: tolerance: 64.28715.6DL
PR4660 = R402H16: tolerance: 64.19115.6DL
PR4661 R4377 = R402H16: tolerance: 64.84525.6DL
PR4662 = R402H16: tolerance: 64.95315.6DL
PR4703 PR4713 PR4804 = R402H16: tolerance: 64.2R205.6DL
PR4705 PR4714 PR4803 = R1206H28: tolerance: 63.2R232.11L
PR4708 PR4716 PR4808 PR5003 = R402H16: tolerance: 64.36515.6DL
PR4717 PR4718 PR4812 = R402H16: tolerance: 64.51115.6DL
PR5101 R8624 R8625 = R402H16: tolerance: 63.10034.L0L
PR5102 = R402H16: tolerance: 64.64915.6DL
PR5105 = R402H16: tolerance: 64.62015.6DL
PR5106 = R402H16: tolerance: 64.10225.6DL
PR5108 = R402H16: tolerance: 64.51035.6DL
PR5111 = 0R0805-PAD-U: tolerance: ZZ.R0805.001
PR5151 = R402H16: tolerance: 63.47334.1DL
PR5154 = R402H16: tolerance: 64.18025.6DL
PR5155 = R402H16: tolerance: 64.14325.6DL
PR5201 = R402H16: tolerance: 64.95325.6DL
PR5202 = R402H16: tolerance: 64.31615.6DL
PR5210 R1719 R4308 = R402H16: tolerance: 64.47025.6DL
PR5304 PR8559 PR8614 = R402H16: tolerance: 64.49925.6DL
PR5307 R2701 R2707 R5508 R6114 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
PR8557 PR8624 PR8625 PR8650 R402 R506 R507 R1519 R1606 R1608 R1701 R1707 R1717 R1721-R1723 R1726 R1738 R1819-R1821 R1910 R1911 R2002 R2008-R2018 R2022 R2029-R2035 R2037 R2038 R2041-R2046 R2053 R2110-R2118 R2408 R2414 R2426 R2430 R2460 R2514 R3325 R4009 R4034 R4303 R5533 R5538 R5712 R6113 R6115 R6118 R6303 R6304 R6405 R6406 R6511 R7008 R7016 R7118 R7222 R7224 R7243 R7247 R7603 R7606 R7701 R7901 R7902 R7912 R7917 R7927 R7933 R7948 R7949 R7952 R7953 R8529 R8541 R8634 R8635 R8637 R9148 R9151 = R402H15: tolerance: 63.10334.L0L
PR8563 PR8570 = R402H16: tolerance: 64.16525.6DL
PR8564 = R402H16: tolerance: 64.14735.6DL
PR8566 = R402H16: tolerance: 64.20525.6DL
PR8567 = R402H16: tolerance: 64.61915.6DL
PR8568 = R402H16: tolerance: 64.43215.6DL
PR8572 = R402H16: tolerance: 64.30905.6DL
PR8613 = R402H16: tolerance: 64.34825.6DL
PR8620 = R402H16: tolerance: 64.51025.6DL
PR8626 = R402H16: tolerance: 64.12025.6DL
PR8633 R1103 R1104 R2202-R2205 R2446 R2516 R2612 R2703-R2706 R2715 R3301 R4036 R4043 R4317 R5501 R5511 R6502 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PT4701 PT4703 PT4801 PT8553 PT8555 = CT7343H83: tolerance: 79.33719.20C
PU44A1 PU44B1 = SOT-23-5H58: tolerance: 74.00331.H2F
PU44C1 = SOT-23-5H58: tolerance: 74.02204.03F
PU4301 PU4415 U7418 = PPAK-8P-3232H36: tolerance: 084.21321.0037
PU4401 = QFN32J4-G2D85H34: tolerance: 074.09538.0073
PU4402 PU4403 PU8552-PU8555 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU4412 = PPAK-8P-3232H40: tolerance: 084.03305.0037
PU4501 = QFN20Z3-G1D1H36: tolerance: 074.08288.0A43
PU4551 = QFN20Z3-G1D1H36: tolerance: 074.08288.0B43
PU4601 = QFN40J5-G3D6-DIFF-H34: tolerance: 074.95859.0D33
PU4701 PU4702 PU4801 = QFN31G5-G4P-9H34: tolerance: 074.05038.0A73
PU5001 PU5003 = PPAK-8P-3232H36: tolerance: 084.07408.0037
PU5002 = DFN8G2-G1710-U1H40: tolerance: 074.95808.0B73
PU5101 = QFN32J4-G3P-1UH32: tolerance: 074.08861.0043
PU5151 = SOIC8-G3530H63: tolerance: 074.05934.003D
PU5201 = QFN22G4-G2PH42: tolerance: 074.02262.M002
PU5301 PU8601 PU8603 = DFN8-G125065H32: tolerance: 074.05797.0073
PU8551 = QFN20-G1D75H32: tolerance: 074.08816.0A73
PU8602 = QFN20Z3-G1H36: tolerance: 074.08288.0043
Q501 Q4301 Q6403 Q7601 Q7906 Q8101 Q8601 Q8613 = SOT23DGS2D4H44: tolerance: 084.00138.0A31
Q1701 Q6404 Q7406 Q7407 Q7901 Q7907 Q8509 Q8612 Q8615 Q8616 = SOT-363H44: tolerance: 075.00138.0A7C
Q2603 Q4302 Q5508 Q5510 Q5701 Q6406 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
Q4002 Q7401 Q8611 Q9201 = SOT23DGS2D4H44: tolerance: 084.03415.0031
Q4304 = SOT323CBE2D2H40: tolerance: 84.05212.B11
Q4305 Q6407 = SOT323CBE2D2H40: tolerance: 084.05112.001K
Q6401 Q6402 Q6505 = SOT23CBE2D4H44: tolerance: 084.00144.0B11
Q6501 = SOT23DGS2D4H44: tolerance: 084.03402.0031
R301 R308 R1502 R1503 R1507 R1517 R1518 R1527 R1702 R1909 R2432 R2463 R2510 R2735 R4005 R6513 R7140-R7147 R7152 R7170-R7174 R7904 R8111 R8210 = R402H16: tolerance: 63.10234.1DL
R310 R317 = R402H16: tolerance: 63.51034.1DL
R401 R1225 R1229 R1322 = R402H16: tolerance: 64.24R95.6DL
R501 R1901 R2108 = R402H16: tolerance: 64.20005.6DL
R502 R1217-R1221 R1249 R1252 R1313-R1319 = R402H16: tolerance: 64.80R65.6DL
R503 = R402H16: tolerance: 64.16205.6DL
R723 = R402H16: tolerance: 64.54R95.6DL
R727 = R402H16: tolerance: 63.56034.1DL
R728 = R402H16: tolerance: 63.22134.1DL
R1201-R1204 R1301-R1304 = R402H16: tolerance: 64.24005.6DL
R1205-R1208 R1305-R1308 = R402H16: tolerance: 63.68034.1DL
R1214-R1216 R1246 R1310-R1312 R1341 = R402H16: tolerance: 64.38R35.6DL
R1222 R1223 R1226 R1227 R1320 R1321 = R402H16: tolerance: 64.82015.6DL
R1228 = R402H16: tolerance: 64.5R105.6DL
R1501 R1505 R1515 R1523 R1525 R1552-R1555 R4035 R4041 R4316 R6121-R6123 = R402H16: tolerance: 63.20334.1DL
R1504 R1509 R1511-R1514 R1520-R1522 R1551 R2511 R2519 R5517 R5518 R5534 R5539 R7121 = R402H15: tolerance: 63.47234.L0L
R1603 = R402H16: tolerance: 64.11305.6DL
R1730 = R402H16: tolerance: 63.33434.1DL
R1803 R7806 R7808 R7809 = R402H16: tolerance: 64.60R45.6DL
R1805 R1839 R1840 R1912 R1913 R1921 R2506-R2509 = R402H16: tolerance: 64.33R05.6DL
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1837 = R402H16: tolerance: 63.15434.1DL
R2048 R2049 R6507 = R402H16: tolerance: 63.51334.1DL
R2101 R6413 = R402H16: tolerance: 64.15005.6DL
R2120 = R402H16: tolerance: 63.75334.1DL
R2421 R2423 R6426 = R402H16: tolerance: 63.33134.1DL
R2437 = R402H16: tolerance: 63.43034.1DL
R2442 = R402H16: tolerance: 64.27025.6DL
R2443 = R402H16: tolerance: 64.37425.6DL
R2457 = R402H16: tolerance: 64.11535.6DL
R2503 = R402H16: tolerance: 64.15R05.6DL
R2603 R2604 = R402H16: tolerance: 64.75015.6DL
R2723 R2724 R6101 R6102 = R402H16: tolerance: 63.22034.L0L
R4006 = R402H16: tolerance: 64.20025.6DL
R4045 = 0R1206-PAD: tolerance: ZZ.R1206.ZZZ
R4304 R8620 = R402H16: tolerance: 63.22234.1DL
R4305 R4306 R6111 R6112 R6117 R9132 R9133 R9138 = R402H16: tolerance: 63.33034.1DL
R4307 = R603H22: tolerance: 63.24434.15L
R4327 R8618 R8622 R8623 = R402H14: tolerance: 63.10134.1DL
R4376 = R402H16: tolerance: 64.47035.6DL
R5001 R5101 = R1206H26: tolerance: 63.R0037.L0L
R5532 R5537 = R402H16: tolerance: 63.20434.1DL
R6119 = R402H16: tolerance: 64.71525.6DL
R6120 = R402H16: tolerance: 64.75025.6DL
R6124 R6608-R6625 = R0201H12: tolerance: 63.R003C.1IL
R6402 = R402H16: tolerance: 64.68005.6DL
R6404 R7330 R7331 = R402H16: tolerance: 64.20045.6DL
R6425 = R402H16: tolerance: 64.33035.6DL
R7119 R7120 R7122 R7123 = R402H16: tolerance: 64.22035.L1L
R7223 = R402H16: tolerance: 64.43025.6DL
R7225 R7226 R7228 R7230 = R402H16: tolerance: 63.33234.1DL
R7404 R7407 R7411 R7422 = R402H16: tolerance: 64.10045.6DL
R7805 R7807 R8101 R8102 R8206 R8208 = R402H16: tolerance: 64.40R25.6DL
R8104 = R402H16: tolerance: 64.93105.6DL
R8106 = R402H16: tolerance: 64.54905.6DL
R8107 = R402H16: tolerance: 64.13315.6DL
R8108 R8213 = R402H16: tolerance: 64.12105.6DL
R9101 = R402-TO0D2H20: tolerance: 063.R0132.L001
R9118 = R402H16: tolerance: 64.22015.6DL
R9804 = R402H16: tolerance: 64.47015.6DL
RAM1-RAM4 = BGA178M110115H40-COLAY-U1: tolerance: ZZ.00PAD.JX1
RN401 RN403 RN1811 RN2413 RN2602 RN2901 RN5701 RN6503 RN7206 RN7904 RN7905 = ARES2H16: tolerance: 66.22236.04L
RN405 RN1704 RN2009 RN6501 RN7202 RN7910 = ARES2H18: tolerance: 66.10336.04L
RN1201 RN1205 RN1301 = ARES8-CN24: tolerance: 66.68035.08L
RN1202 RN1203 RN1206 RN1207 RN1302-RN1304 RN1306-RN1308 = SMD-ARES4H18: tolerance: 66.68036.04L
RN1601 RN1813 RN2403 RN2404 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1703 = SMD-ARES4: tolerance: 66.10436.04L
RN1801 = SMD-ARES4H20: tolerance: 66.20336.04L
RN1806 = ARES8-CN24-MUH20: tolerance: 66.15035.A8L
RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN2007 = SMD-ARES4H18: tolerance: 66.10236.04L
RN2402 RN2902 RN7901 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2405 RN2409-RN2412 RN5502 RN7203 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN4302 RN5501 RN5505 = SMD-ARES4H18: tolerance: 66.10136.04L
RN5503 RN5504 = SMD-ARES4H18: tolerance: 66.33036.04L
RN5702 RN5703 = ARES8-CN24H20: tolerance: 66.47136.08L
RN6502 = SMD-ARES4H20: tolerance: 66.R0036.04L
RTC1 = 3703K-Q02N-11L-U: tolerance: 20.F1841.002
SSD1 = NFSM0-S6701-TP20: tolerance: 062.10003.00A1
TC4702 TC4805 = CT7343H83: tolerance: 79.33612.20L
TP302-TP310 TP313 TP314 TP316 TP317 TP618-TP620 TP1706 TP1708 TP1710 TP1714 TP1715 TP1807 TP1808 TP1903 TP2201 TP2202 TP2402 TP4401 TP4402 TP4601 TP7202-TP7205 TP7614 TP7901-TP7906 TP9102-TP9105 = TPAD14-OP: tolerance: ZZ.PAD14.001
TPAD1 = 196574-08021-3: tolerance: 020.K0255.0008
U2401 = LQFP128H48: tolerance: 071.01418.000K
U2502 U5501 = SOT-23-5H56: tolerance: 074.06288.007B
U2601 = MSOP8-1H44: tolerance: 74.07718.0B9
U2701 = QFN40J5-G3D75H36: tolerance: 071.03204.0003
U3301 = QFN32J4-G2D85H36: tolerance: 071.05100.0003
U4001 = SON14J3020-G2610H34: tolerance: 074.22976.0091
U4002 U4003 U4006 = DFN8F3-G2517H32: tolerance: 074.05027.0093
U4008 U6402 U7601 U8502 U8604 U8605 = SC70-5H44: tolerance: 73.01G08.L04
U4302 = SOT-23-5H52: tolerance: 074.01004.00BF
U7002 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
U7101 = QFN40J4060-G2848H32: tolerance: 071.00546.M001
U7201 = BGA96G60-1H40: tolerance: 071.18040.000U
U7202 = SOIC8H69: tolerance: 072.25Q80.0C01
U7419 = CSP15G154256H24: tolerance: 074.20509.007Z
U9101 = QFN32G5-G3D6H32: tolerance: 071.00750.0E03
USB1 = SKT-USB34-124103-U1: tolerance: 022.10005.M021
VRAM1 VRAM4 = BGA170D1214H48: tolerance: 72.05224.A0U
WLAN1 = 40-42258-06741RHF-U1: tolerance: 062.10003.0401
X1801 = OSC-3225-4P-3H36: tolerance: 082.30006.0531
X1802 X2401 = SMD49-12H34: tolerance: 082.30003.0301
X7901 = SMD-OSC38H32: tolerance: 082.30008.0421

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
0R0603-PAD
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD
  rect 1.549x1.346 smd: 1(0,0.838) 2(0,-0.838)
0R0805-PAD-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
0R1206-PAD
  rect 1.854x1.829 smd: 1(0,1.347) 2(0,-1.347)
40-42258-06741RHF-U1
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
3703K-Q02N-11L-U
  rect 0.61x1.549 smd: 1(-0.5,3.775) 2(0.5,3.775)
  rect 1.194x2.007 smd: 3(-1.8,0) 4(1.8,0)
20455-030E-12
  rect 0.305x0.889 smd: 1(7.25,2.817) 2(6.75,2.817) 3(6.25,2.817) 4(5.75,2.817) 5(5.25,2.817) 6(4.75,2.817) 7(4.25,2.817) 8(3.75,2.817) 9(3.25,2.817) 10(2.75,2.817) 11(2.25,2.817) 12(1.75,2.817) 13(1.25,2.817) 14(0.75,2.817) 15(0.25,2.817) 16(-0.25,2.817) 17(-0.75,2.817) 18(-1.25,2.817) 19(-1.75,2.817) 20(-2.25,2.817) 21(-2.75,2.817) 22(-3.25,2.817) 23(-3.75,2.817) 24(-4.25,2.817) 25(-4.75,2.817) 26(-5.25,2.817) 27(-5.75,2.817) 28(-6.25,2.817) 29(-6.75,2.817) 30(-7.25,2.817)
  rect 0.559x0.889 smd: 31(8.15,2.817) 32(-8.15,2.817)
  rect 1.397x1.905 smd: 33(10.348,0) 34(-10.348,0)
20879-040E-01
  rect 0.203x0.635 smd: 1(-7.8,2.28) 2(-7.4,2.28) 3(-7,2.28) 4(-6.6,2.28) 5(-6.2,2.28) 6(-5.8,2.28) 7(-5.4,2.28) 8(-5,2.28) 9(-4.6,2.28) 10(-4.2,2.28) 11(-3.8,2.28) 12(-3.4,2.28) 13(-3,2.28) 14(-2.6,2.28) 15(-2.2,2.28) 16(-1.8,2.28) 17(-1.4,2.28) 18(-1,2.28) 19(-0.6,2.28) 20(-0.2,2.28) 21(0.2,2.28) 22(0.6,2.28) 23(1,2.28) 24(1.4,2.28) 25(1.8,2.28) 26(2.2,2.28) 27(2.6,2.28) 28(3,2.28) 29(3.4,2.28) 30(3.8,2.28) 31(4.2,2.28) 32(4.6,2.28) 33(5,2.28) 34(5.4,2.28) 35(5.8,2.28) 36(6.2,2.28) 37(6.6,2.28) 38(7,2.28) 39(7.4,2.28) 40(7.8,2.28)
  rect 1.448x0.356 smd: 41(-8.505,3.03) 55(8.505,3.03)
  rect 0.457x0.356 smd: 42(-7.2,3.03) 43(-6,3.03) 44(-4.8,3.03) 45(-3.6,3.03) 46(-2.4,3.03) 47(-1.2,3.03) 48(0,3.03) 49(1.2,3.03) 50(2.4,3.03) 51(3.6,3.03) 52(4.8,3.03) 53(6,3.03) 54(7.2,3.03)
  rect 0.305x0.813 smd: 56(9.585,2.355) 74(-9.585,2.355)
  rect 0.406x0.889 smd: 57(9.535,0) 73(-9.535,0)
  rect 1.397x0.508 smd: 58(8.44,-0.635) 72(-8.44,-0.635)
  rect 0.457x0.508 smd: 59(7.2,-0.635) 60(6,-0.635) 61(4.8,-0.635) 62(3.6,-0.635) 63(2.4,-0.635) 64(1.2,-0.635) 65(0,-0.635) 66(-1.2,-0.635) 67(-2.4,-0.635) 68(-3.6,-0.635) 69(-4.8,-0.635) 70(-6,-0.635) 71(-7.2,-0.635)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50224-0080N-W02-U
  rect 0.406x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.797,0) 10(4.797,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
50698-00401-W01-U
  rect 0.305x1.6 smd: 1(1.5,5.2) 2(0.5,5.2) 3(-0.5,5.2) 4(-1.5,5.2)
  rect 1.803x2.007 smd: 5(4.21,0) 6(-4.21,0)
50699-03001-W01
  rect 0.229x0.813 smd: 1(-11.6,3.3) 2(-10.8,3.3) 3(-10,3.3) 4(-9.2,3.3) 5(-8.4,3.3) 6(-7.6,3.3) 7(-6.8,3.3) 8(-6,3.3) 9(-5.2,3.3) 10(-4.4,3.3) 11(-3.6,3.3) 12(-2.8,3.3) 13(-2,3.3) 14(-1.2,3.3) 15(-0.4,3.3) 16(0.4,3.3) 17(1.2,3.3) 18(2,3.3) 19(2.8,3.3) 20(3.6,3.3) 21(4.4,3.3) 22(5.2,3.3) 23(6,3.3) 24(6.8,3.3) 25(7.6,3.3) 26(8.4,3.3) 27(9.2,3.3) 28(10,3.3) 29(10.8,3.3) 30(11.6,3.3)
  rect 0.559x1.295 smd: 31(-13.075,0) 32(13.075,0)
87212-1400N
  rect 0.61x1.549 smd: 1(-6.5,-2.525) 2(-5.5,-2.525) 3(-4.5,-2.525) 4(-3.5,-2.525) 5(-2.5,-2.525) 6(-1.5,-2.525) 7(-0.5,-2.525) 8(0.5,-2.525) 9(1.5,-2.525) 10(2.5,-2.525) 11(3.5,-2.525) 12(4.5,-2.525) 13(5.5,-2.525) 14(6.5,-2.525)
  rect 1.194x1.803 smd: 15(-7.797,0) 16(7.797,0)
88231-1201-LP
  rect 0.813x1.905 smd: 1(6.875,5.025) 2(5.625,5.025) 3(4.375,5.025) 4(3.125,5.025) 5(1.875,5.025) 6(0.625,5.025) 7(-0.625,5.025) 8(-1.875,5.025) 9(-3.125,5.025) 10(-4.375,5.025) 11(-5.625,5.025) 12(-6.875,5.025)
  rect 1.295x3.048 smd: 13(9.725,0) 14(-9.725,0)
196574-08021-3
  rect 0.305x0.991 smd: 1(-3.5,3.2) 2(-2.5,3.2) 3(-1.5,3.2) 4(-0.5,3.2) 5(0.5,3.2) 6(1.5,3.2) 7(2.5,3.2) 8(3.5,3.2)
  rect 0.406x0.991 smd: 9(-5.185,0) 10(5.185,0)
503398-0891
  rect 0.711x1.092 smd: 1(-3.21,0.015) 2(-2.11,0.015) 3(-1.01,0.015) 4(0.09,0.015) 5(1.19,0.015) 6(2.29,0.015) 7(3.39,0.015) 8(4.49,0.015)
  rect 1.143x1.829 smd: 9(-7.089,0)
  rect 0.711x3.327 smd: 10(-7.305,-11.252) 13(5.644,-11.252)
  rect 0.889x0.94 smd: 11(-5,-12.445)
  rect 1.041x0.787 smd: 12(-0.739,-12.522)
  rect 0.864x2.794 smd: 14(5.568,-0.483)
AFTE14P-75
  round 0.356 smd: 1(0,0)
ARES2H16
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES2H18
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES8-CN24
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
ARES8-CN24-MUH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24-UH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24H20
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
BGA96G60-1H40
  oval 0.178x0.33 smd rot 135: A1(-2.5,2.5) L11(2.5,-2.5)
  oval 0.178x0.33 smd: A2(-2,2.5) A3(-1.5,2.5) A4(-1,2.5) A5(-0.5,2.5) A6(0,2.5) A7(0.5,2.5) A8(1,2.5) A9(1.5,2.5) A10(2,2.5) L2(-2,-2.5) L3(-1.5,-2.5) L4(-1,-2.5) L5(-0.5,-2.5) L6(0,-2.5) L7(0.5,-2.5) L8(1,-2.5) L9(1.5,-2.5) L10(2,-2.5)
  oval 0.33x0.178 smd rot 135: A11(2.5,2.5) L1(-2.5,-2.5)
  oval 0.33x0.178 smd: B1(-2.5,2) B11(2.5,2) C1(-2.5,1.5) C11(2.5,1.5) D1(-2.5,1) D11(2.5,1) E1(-2.5,0.5) E11(2.5,0.5) F1(-2.5,0) F11(2.5,0) G1(-2.5,-0.5) G11(2.5,-0.5) H1(-2.5,-1) H11(2.5,-1) J1(-2.5,-1.5) J11(2.5,-1.5) K1(-2.5,-2) K11(2.5,-2)
  round 0.356 smd: B2(-2,2) B3(-1.5,2) B4(-1,2) B5(-0.5,2) B6(0,2) B7(0.5,2) B8(1,2) B9(1.5,2) B10(2,2) C2(-2,1.5) C10(2,1.5) D2(-2,1) D5(-0.5,1) D6(0,1) D7(0.5,1) D8(1,1) D10(2,1) E2(-2,0.5) E4(-1,0.5) E5(-0.5,0.5) E6(0,0.5) E7(0.5,0.5) E8(1,0.5) E10(2,0.5) F2(-2,0) F4(-1,0) F5(-0.5,0) F6(0,0) F7(0.5,0) F8(1,0) F10(2,0) G2(-2,-0.5) G4(-1,-0.5) G5(-0.5,-0.5) G6(0,-0.5) G7(0.5,-0.5) G8(1,-0.5) G10(2,-0.5) H2(-2,-1) H4(-1,-1) H5(-0.5,-1) H6(0,-1) H7(0.5,-1) H8(1,-1) H10(2,-1) J2(-2,-1.5) J10(2,-1.5) K2(-2,-2) K3(-1.5,-2) K4(-1,-2) K5(-0.5,-2) K6(0,-2) K7(0.5,-2) K8(1,-2) K9(1.5,-2) K10(2,-2)
BGA170D1214H48
  round 0.406 smd: A1(-5.2,6.4) A2(-4.4,6.4) A3(-3.6,6.4) A12(3.6,6.4) A13(4.4,6.4) A14(5.2,6.4) B1(-5.2,5.6) B2(-4.4,5.6) B3(-3.6,5.6) B12(3.6,5.6) B13(4.4,5.6) B14(5.2,5.6) C1(-5.2,4.8) C2(-4.4,4.8) C3(-3.6,4.8) C12(3.6,4.8) C13(4.4,4.8) C14(5.2,4.8) R1(-5.2,-4.8) R2(-4.4,-4.8) R3(-3.6,-4.8) R12(3.6,-4.8) R13(4.4,-4.8) R14(5.2,-4.8) T1(-5.2,-5.6) T2(-4.4,-5.6) T3(-3.6,-5.6) T12(3.6,-5.6) T13(4.4,-5.6) T14(5.2,-5.6) U1(-5.2,-6.4) U2(-4.4,-6.4) U3(-3.6,-6.4) U12(3.6,-6.4) U13(4.4,-6.4) U14(5.2,-6.4)
  round 0.356 smd: A4(-2.8,6.4) A5(-2,6.4) A10(2,6.4) A11(2.8,6.4) B4(-2.8,5.6) B5(-2,5.6) B10(2,5.6) B11(2.8,5.6) C4(-2.8,4.8) C5(-2,4.8) C10(2,4.8) C11(2.8,4.8) D1(-5.2,4) D2(-4.4,4) D3(-3.6,4) D4(-2.8,4) D5(-2,4) D10(2,4) D11(2.8,4) D12(3.6,4) D13(4.4,4) D14(5.2,4) E1(-5.2,3.2) E2(-4.4,3.2) E3(-3.6,3.2) E4(-2.8,3.2) E5(-2,3.2) E10(2,3.2) E11(2.8,3.2) E12(3.6,3.2) E13(4.4,3.2) E14(5.2,3.2) F1(-5.2,2.4) F2(-4.4,2.4) F3(-3.6,2.4) F4(-2.8,2.4) F5(-2,2.4) F10(2,2.4) F11(2.8,2.4) F12(3.6,2.4) F13(4.4,2.4) F14(5.2,2.4) G1(-5.2,1.6) G2(-4.4,1.6) G3(-3.6,1.6) G4(-2.8,1.6) G5(-2,1.6) G10(2,1.6) G11(2.8,1.6) G12(3.6,1.6) G13(4.4,1.6) G14(5.2,1.6) H1(-5.2,0.8) H2(-4.4,0.8) H3(-3.6,0.8) H4(-2.8,0.8) H5(-2,0.8) H10(2,0.8) H11(2.8,0.8) H12(3.6,0.8) H13(4.4,0.8) H14(5.2,0.8) J1(-5.2,0) J2(-4.4,0) J3(-3.6,0) J4(-2.8,0) J5(-2,0) J10(2,0) J11(2.8,0) J12(3.6,0) J13(4.4,0) J14(5.2,0) K1(-5.2,-0.8) K2(-4.4,-0.8) K3(-3.6,-0.8) K4(-2.8,-0.8) K5(-2,-0.8) K10(2,-0.8) K11(2.8,-0.8) K12(3.6,-0.8) K13(4.4,-0.8) K14(5.2,-0.8) L1(-5.2,-1.6) L2(-4.4,-1.6) L3(-3.6,-1.6) L4(-2.8,-1.6) L5(-2,-1.6) L10(2,-1.6) L11(2.8,-1.6) L12(3.6,-1.6) L13(4.4,-1.6) L14(5.2,-1.6) M1(-5.2,-2.4) M2(-4.4,-2.4) M3(-3.6,-2.4) M4(-2.8,-2.4) M5(-2,-2.4) M10(2,-2.4) M11(2.8,-2.4) M12(3.6,-2.4) M13(4.4,-2.4) M14(5.2,-2.4) N1(-5.2,-3.2) N2(-4.4,-3.2) N3(-3.6,-3.2) N4(-2.8,-3.2) N5(-2,-3.2) N10(2,-3.2) N11(2.8,-3.2) N12(3.6,-3.2) N13(4.4,-3.2) N14(5.2,-3.2) P1(-5.2,-4) P2(-4.4,-4) P3(-3.6,-4) P4(-2.8,-4) P5(-2,-4) P10(2,-4) P11(2.8,-4) P12(3.6,-4) P13(4.4,-4) P14(5.2,-4) R4(-2.8,-4.8) R5(-2,-4.8) R10(2,-4.8) R11(2.8,-4.8) T4(-2.8,-5.6) T5(-2,-5.6) T10(2,-5.6) T11(2.8,-5.6) U4(-2.8,-6.4) U5(-2,-6.4) U10(2,-6.4) U11(2.8,-6.4)
BGA178M110115H40-COLAY-U1
  round 0.33 smd: A1(-4.8,5.2) A2(-4,5.2) A3(-3.2,5.2) A4(-2.4,5.2) A5(-1.6,5.2) A6(-0.8,5.2) A8(0.8,5.2) A9(1.6,5.2) A10(2.4,5.2) A11(3.2,5.2) A12(4,5.2) A13(4.8,5.2) B1(-4.8,4.55) B2(-4,4.55) B3(-3.2,4.55) B4(-2.4,4.55) B5(-1.6,4.55) B6(-0.8,4.55) B8(0.8,4.55) B9(1.6,4.55) B10(2.4,4.55) B11(3.2,4.55) B12(4,4.55) B13(4.8,4.55) C2(-4,3.9) C3(-3.2,3.9) C4(-2.4,3.9) C5(-1.6,3.9) C6(-0.8,3.9) C8(0.8,3.9) C9(1.6,3.9) C10(2.4,3.9) C11(3.2,3.9) C12(4,3.9) D2(-4,3.25) D3(-3.2,3.25) D4(-2.4,3.25) D5(-1.6,3.25) D6(-0.8,3.25) D8(0.8,3.25) D9(1.6,3.25) D10(2.4,3.25) D11(3.2,3.25) D12(4,3.25) E2(-4,2.6) E3(-3.2,2.6) E4(-2.4,2.6) E5(-1.6,2.6) E6(-0.8,2.6) E8(0.8,2.6) E9(1.6,2.6) E10(2.4,2.6) E11(3.2,2.6) E12(4,2.6) F2(-4,1.95) F3(-3.2,1.95) F4(-2.4,1.95) F5(-1.6,1.95) F6(-0.8,1.95) F8(0.8,1.95) F9(1.6,1.95) F10(2.4,1.95) F11(3.2,1.95) F12(4,1.95) G2(-4,1.3) G3(-3.2,1.3) G4(-2.4,1.3) G5(-1.6,1.3) G6(-0.8,1.3) G8(0.8,1.3) G9(1.6,1.3) G10(2.4,1.3) G11(3.2,1.3) G12(4,1.3) H2(-4,0.65) H3(-3.2,0.65) H4(-2.4,0.65) H5(-1.6,0.65) H6(-0.8,0.65) H8(0.8,0.65) H9(1.6,0.65) H10(2.4,0.65) H11(3.2,0.65) H12(4,0.65) J2(-4,0) J3(-3.2,0) J4(-2.4,0) J5(-1.6,0) J6(-0.8,0) J8(0.8,0) J9(1.6,0) J10(2.4,0) J11(3.2,0) J12(4,0) K2(-4,-0.65) K3(-3.2,-0.65) K4(-2.4,-0.65) K5(-1.6,-0.65) K6(-0.8,-0.65) K8(0.8,-0.65) K9(1.6,-0.65) K10(2.4,-0.65) K11(3.2,-0.65) K12(4,-0.65) L2(-4,-1.3) L3(-3.2,-1.3) L4(-2.4,-1.3) L5(-1.6,-1.3) L6(-0.8,-1.3) L8(0.8,-1.3) L9(1.6,-1.3) L10(2.4,-1.3) L11(3.2,-1.3) L12(4,-1.3) M2(-4,-1.95) M3(-3.2,-1.95) M4(-2.4,-1.95) M5(-1.6,-1.95) M6(-0.8,-1.95) M8(0.8,-1.95) M9(1.6,-1.95) M10(2.4,-1.95) M11(3.2,-1.95) M12(4,-1.95) N2(-4,-2.6) N3(-3.2,-2.6) N4(-2.4,-2.6) N5(-1.6,-2.6) N6(-0.8,-2.6) N8(0.8,-2.6) N9(1.6,-2.6) N10(2.4,-2.6) N11(3.2,-2.6) N12(4,-2.6) P2(-4,-3.25) P3(-3.2,-3.25) P4(-2.4,-3.25) P5(-1.6,-3.25) P6(-0.8,-3.25) P8(0.8,-3.25) P9(1.6,-3.25) P10(2.4,-3.25) P11(3.2,-3.25) P12(4,-3.25) R2(-4,-3.9) R3(-3.2,-3.9) R4(-2.4,-3.9) R5(-1.6,-3.9) R6(-0.8,-3.9) R8(0.8,-3.9) R9(1.6,-3.9) R10(2.4,-3.9) R11(3.2,-3.9) R12(4,-3.9) T1(-4.8,-4.55) T2(-4,-4.55) T3(-3.2,-4.55) T4(-2.4,-4.55) T5(-1.6,-4.55) T6(-0.8,-4.55) T8(0.8,-4.55) T9(1.6,-4.55) T10(2.4,-4.55) T11(3.2,-4.55) T12(4,-4.55) T13(4.8,-4.55) U1(-4.8,-5.2) U2(-4,-5.2) U3(-3.2,-5.2) U4(-2.4,-5.2) U5(-1.6,-5.2) U6(-0.8,-5.2) U8(0.8,-5.2) U9(1.6,-5.2) U10(2.4,-5.2) U11(3.2,-5.2) U12(4,-5.2) U13(4.8,-5.2)
BGA595M23H83
  round 0.432 smd: A2(-9.9,10.7) A3(-9.1,10.7) A25(9.1,10.7) A26(9.9,10.7) AE1(-10.7,-9.1) AE2(-9.9,-9.1) AE3(-9.1,-9.1) AE25(9.1,-9.1) AE26(9.9,-9.1) AE27(10.7,-9.1) AF1(-10.7,-9.9) AF2(-9.9,-9.9) AF3(-9.1,-9.9) AF25(9.1,-9.9) AF26(9.9,-9.9) AF27(10.7,-9.9) AG2(-9.9,-10.7) AG3(-9.1,-10.7) AG25(9.1,-10.7) AG26(9.9,-10.7) B1(-10.7,9.9) B2(-9.9,9.9) B3(-9.1,9.9) B25(9.1,9.9) B26(9.9,9.9) B27(10.7,9.9) C1(-10.7,9.1) C2(-9.9,9.1) C3(-9.1,9.1) C25(9.1,9.1) C26(9.9,9.1) C27(10.7,9.1)
  round 0.381 smd: A4(-8.3,10.7) A6(-6.6,10.7) A7(-5.8,10.7) A9(-4.12,10.7) A10(-3.32,10.7) A12(-1.64,10.7) A13(-0.84,10.7) A15(0.84,10.7) A16(1.64,10.7) A18(3.32,10.7) A19(4.12,10.7) A21(5.8,10.7) A22(6.6,10.7) A24(8.3,10.7) AA1(-10.7,-5.8) AA2(-9.9,-5.8) AA3(-9.1,-5.8) AA4(-8.3,-5.8) AA5(-7.5,-5.8) AA6(-6.66,-5.8) AA7(-5.8,-5.8) AA8(-4.96,-5.8) AA9(-4.12,-5.86) AA10(-3.32,-5.86) AA12(-1.64,-5.86) AA13(-0.84,-5.86) AA14(0,-5.86) AA15(0.84,-5.86) AA16(1.64,-5.86) AA18(3.32,-5.86) AA19(4.12,-5.86) AA20(4.96,-5.8) AA21(5.8,-5.8) AA22(6.66,-5.8) AA23(7.5,-5.8) AA24(8.3,-5.8) AA25(9.1,-5.8) AA26(9.9,-5.8) AA27(10.7,-5.8) AB1(-10.7,-6.6) AB2(-9.9,-6.6) AB3(-9.1,-6.6) AB4(-8.3,-6.6) AB5(-7.5,-6.6) AB6(-6.6,-6.6) AB7(-5.8,-6.66) AB8(-4.96,-6.66) AB9(-4.12,-6.66) AB10(-3.32,-6.66) AB11(-2.48,-6.66) AB12(-1.64,-6.66) AB13(-0.84,-6.66) AB14(0,-6.66) AB15(0.84,-6.66) AB16(1.64,-6.66) AB17(2.48,-6.66) AB18(3.32,-6.66) AB19(4.12,-6.66) AB20(4.96,-6.66) AB21(5.8,-6.66) AB22(6.6,-6.6) AB23(7.5,-6.6) AB24(8.3,-6.6) AB25(9.1,-6.6) AB26(9.9,-6.6) AB27(10.7,-6.6) AC2(-9.9,-7.45) AC3(-9.1,-7.45) AC4(-8.3,-7.45) AC5(-7.45,-7.45) AC6(-6.6,-7.5) AC7(-5.8,-7.5) AC8(-4.96,-7.5) AC9(-4.12,-7.5) AC10(-3.32,-7.5) AC11(-2.48,-7.5) AC12(-1.64,-7.5) AC13(-0.84,-7.5) AC14(0,-7.5) AC15(0.84,-7.5) AC16(1.64,-7.5) AC17(2.48,-7.5) AC18(3.32,-7.5) AC19(4.12,-7.5) AC20(4.96,-7.5) AC21(5.8,-7.5) AC22(6.6,-7.5) AC23(7.45,-7.45) AC24(8.3,-7.45) AC25(9.1,-7.45) AC26(9.9,-7.45) AD1(-10.7,-8.3) AD2(-9.9,-8.3) AD3(-9.1,-8.3) AD4(-8.3,-8.3) AD5(-7.45,-8.3) AD6(-6.6,-8.3) AD7(-5.8,-8.3) AD8(-4.96,-8.3) AD9(-4.12,-8.3) AD10(-3.32,-8.3) AD11(-2.48,-8.3) AD12(-1.64,-8.3) AD13(-0.84,-8.3) AD14(0,-8.3) AD15(0.84,-8.3) AD16(1.64,-8.3) AD17(2.48,-8.3) AD18(3.32,-8.3) AD19(4.12,-8.3) AD20(4.96,-8.3) AD21(5.8,-8.3) AD22(6.6,-8.3) AD23(7.45,-8.3) AD24(8.3,-8.3) AD25(9.1,-8.3) AD26(9.9,-8.3) AD27(10.7,-8.3) AE4(-8.3,-9.1) AE5(-7.45,-9.1) AE6(-6.6,-9.1) AE7(-5.8,-9.1) AE8(-4.96,-9.1) AE9(-4.12,-9.1) AE10(-3.32,-9.1) AE11(-2.48,-9.1) AE12(-1.64,-9.1) AE13(-0.84,-9.1) AE14(0,-9.1) AE15(0.84,-9.1) AE16(1.64,-9.1) AE17(2.48,-9.1) AE18(3.32,-9.1) AE19(4.12,-9.1) AE20(4.96,-9.1) AE21(5.8,-9.1) AE22(6.6,-9.1) AE23(7.45,-9.1) AE24(8.3,-9.1) AF4(-8.3,-9.9) AF5(-7.45,-9.9) AF6(-6.6,-9.9) AF7(-5.8,-9.9) AF8(-4.96,-9.9) AF9(-4.12,-9.9) AF10(-3.32,-9.9) AF11(-2.48,-9.9) AF12(-1.64,-9.9) AF13(-0.84,-9.9) AF14(0,-9.9) AF15(0.84,-9.9) AF16(1.64,-9.9) AF17(2.48,-9.9) AF18(3.32,-9.9) AF19(4.12,-9.9) AF20(4.96,-9.9) AF21(5.8,-9.9) AF22(6.6,-9.9) AF23(7.45,-9.9) AF24(8.3,-9.9) AG4(-8.3,-10.7) AG6(-6.6,-10.7) AG7(-5.8,-10.7) AG9(-4.12,-10.7) AG10(-3.32,-10.7) AG12(-1.64,-10.7) AG13(-0.84,-10.7) AG15(0.84,-10.7) AG16(1.64,-10.7) AG18(3.32,-10.7) AG19(4.12,-10.7) AG21(5.8,-10.7) AG22(6.6,-10.7) AG24(8.3,-10.7) B4(-8.3,9.9) B5(-7.45,9.9) B6(-6.6,9.9) B7(-5.8,9.9) B8(-4.96,9.9) B9(-4.12,9.9) B10(-3.32,9.9) B11(-2.48,9.9) B12(-1.64,9.9) B13(-0.84,9.9) B14(0,9.9) B15(0.84,9.9) B16(1.64,9.9) B17(2.48,9.9) B18(3.32,9.9) B19(4.12,9.9) B20(4.96,9.9) B21(5.8,9.9) B22(6.6,9.9) B23(7.45,9.9) B24(8.3,9.9) C4(-8.3,9.1) C5(-7.45,9.1) C6(-6.6,9.1) C7(-5.8,9.1) C8(-4.96,9.1) C9(-4.12,9.1) C10(-3.32,9.1) C11(-2.48,9.1) C12(-1.64,9.1) C13(-0.84,9.1) C14(0,9.1) C15(0.84,9.1) C16(1.64,9.1) C17(2.48,9.1) C18(3.32,9.1) C19(4.12,9.1) C20(4.96,9.1) C21(5.8,9.1) C22(6.6,9.1) C23(7.45,9.1) C24(8.3,9.1) D1(-10.7,8.3) D2(-9.9,8.3) D3(-9.1,8.3) D4(-8.3,8.3) D5(-7.45,8.3) D6(-6.6,8.3) D7(-5.8,8.3) D8(-4.96,8.3) D9(-4.12,8.3) D10(-3.32,8.3) D11(-2.48,8.3) D12(-1.64,8.3) D13(-0.84,8.3) D14(0,8.3) D15(0.84,8.3) D16(1.64,8.3) D17(2.48,8.3) D18(3.32,8.3) D19(4.12,8.3) D20(4.96,8.3) D21(5.8,8.3) D22(6.6,8.3) D23(7.45,8.3) D24(8.3,8.3) D25(9.1,8.3) D26(9.9,8.3) D27(10.7,8.3) E2(-9.9,7.45) E3(-9.1,7.45) E4(-8.3,7.45) E5(-7.45,7.45) E6(-6.6,7.5) E7(-5.8,7.5) E8(-4.96,7.5) E9(-4.12,7.5) E10(-3.32,7.5) E11(-2.48,7.5) E12(-1.64,7.5) E13(-0.84,7.5) E14(0,7.5) E15(0.84,7.5) E16(1.64,7.5) E17(2.48,7.5) E18(3.32,7.5) E19(4.12,7.5) E20(4.96,7.5) E21(5.8,7.5) E22(6.6,7.5) E23(7.45,7.45) E24(8.3,7.45) E25(9.1,7.45) E26(9.9,7.45) F1(-10.7,6.6) F2(-9.9,6.6) F3(-9.1,6.6) F4(-8.3,6.6) F5(-7.5,6.6) F6(-6.6,6.6) F7(-5.8,6.66) F8(-4.96,6.66) F9(-4.12,6.66) F10(-3.32,6.66) F11(-2.48,6.66) F12(-1.64,6.66) F13(-0.84,6.66) F14(0,6.66) F15(0.84,6.66) F16(1.64,6.66) F17(2.48,6.66) F18(3.32,6.66) F19(4.12,6.66) F20(4.96,6.66) F21(5.8,6.66) F22(6.6,6.6) F23(7.5,6.6) F24(8.3,6.6) F25(9.1,6.6) F26(9.9,6.6) F27(10.7,6.6) G1(-10.7,5.8) G2(-9.9,5.8) G3(-9.1,5.8) G4(-8.3,5.8) G5(-7.5,5.8) G6(-6.66,5.8) G7(-5.8,5.8) G8(-4.96,5.8) G9(-4.12,5.86) G10(-3.32,5.86) G12(-1.64,5.86) G13(-0.84,5.86) G14(0,5.86) G15(0.84,5.86) G16(1.64,5.86) G18(3.32,5.86) G19(4.12,5.86) G20(4.96,5.8) G21(5.8,5.8) G22(6.66,5.8) G23(7.5,5.8) G24(8.3,5.8) G25(9.1,5.8) G26(9.9,5.8) G27(10.7,5.8) H2(-9.9,4.96) H3(-9.1,4.96) H4(-8.3,4.96) H5(-7.5,4.96) H6(-6.66,4.96) H22(6.66,4.96) H23(7.5,4.96) H24(8.3,4.96) H25(9.1,4.96) H26(9.9,4.96) J1(-10.7,4.12) J2(-9.9,4.12) J3(-9.1,4.12) J4(-8.3,4.12) J5(-7.5,4.12) J6(-6.66,4.12) J7(-5.86,4.12) J21(5.86,4.12) J22(6.66,4.12) J23(7.5,4.12) J24(8.3,4.12) J25(9.1,4.12) J26(9.9,4.12) J27(10.7,4.12) K1(-10.7,3.32) K2(-9.9,3.32) K3(-9.1,3.32) K4(-8.3,3.32) K5(-7.5,3.32) K6(-6.66,3.32) K7(-5.86,3.32) K21(5.86,3.32) K22(6.66,3.32) K23(7.5,3.32) K24(8.3,3.32) K25(9.1,3.32) K26(9.9,3.32) K27(10.7,3.32) L2(-9.9,2.48) L3(-9.1,2.48) L4(-8.3,2.48) L5(-7.5,2.48) L6(-6.66,2.48) L22(6.66,2.48) L23(7.5,2.48) L24(8.3,2.48) L25(9.1,2.48) L26(9.9,2.48) M1(-10.7,1.64) M2(-9.9,1.64) M3(-9.1,1.64) M4(-8.3,1.64) M5(-7.5,1.64) M6(-6.66,1.64) M7(-5.86,1.64) M21(5.86,1.64) M22(6.66,1.64) M23(7.5,1.64) M24(8.3,1.64) M25(9.1,1.64) M26(9.9,1.64) M27(10.7,1.64) N1(-10.7,0.84) N2(-9.9,0.84) N3(-9.1,0.84) N4(-8.3,0.84) N5(-7.5,0.84) N6(-6.66,0.84) N7(-5.86,0.84) N21(5.86,0.84) N22(6.66,0.84) N23(7.5,0.84) N24(8.3,0.84) N25(9.1,0.84) N26(9.9,0.84) N27(10.7,0.84) P2(-9.9,0) P3(-9.1,0) P4(-8.3,0) P5(-7.5,0) P6(-6.66,0) P22(6.66,0) P23(7.5,0) P24(8.3,0) P25(9.1,0) P26(9.9,0) R1(-10.7,-0.84) R2(-9.9,-0.84) R3(-9.1,-0.84) R4(-8.3,-0.84) R5(-7.5,-0.84) R6(-6.66,-0.84) R7(-5.86,-0.84) R21(5.86,-0.84) R22(6.66,-0.84) R23(7.5,-0.84) R24(8.3,-0.84) R25(9.1,-0.84) R26(9.9,-0.84) R27(10.7,-0.84) T1(-10.7,-1.64) T2(-9.9,-1.64) T3(-9.1,-1.64) T4(-8.3,-1.64) T5(-7.5,-1.64) T6(-6.66,-1.64) T7(-5.86,-1.64) T21(5.86,-1.64) T22(6.66,-1.64) T23(7.5,-1.64) T24(8.3,-1.64) T25(9.1,-1.64) T26(9.9,-1.64) T27(10.7,-1.64) U2(-9.9,-2.48) U3(-9.1,-2.48) U4(-8.3,-2.48) U5(-7.5,-2.48) U6(-6.66,-2.48) U22(6.66,-2.48) U23(7.5,-2.48) U24(8.3,-2.48) U25(9.1,-2.48) U26(9.9,-2.48) V1(-10.7,-3.32) V2(-9.9,-3.32) V3(-9.1,-3.32) V4(-8.3,-3.32) V5(-7.5,-3.32) V6(-6.66,-3.32) V7(-5.86,-3.32) V21(5.86,-3.32) V22(6.66,-3.32) V23(7.5,-3.32) V24(8.3,-3.32) V25(9.1,-3.32) V26(9.9,-3.32) V27(10.7,-3.32) W1(-10.7,-4.12) W2(-9.9,-4.12) W3(-9.1,-4.12) W4(-8.3,-4.12) W5(-7.5,-4.12) W6(-6.66,-4.12) W7(-5.86,-4.12) W21(5.86,-4.12) W22(6.66,-4.12) W23(7.5,-4.12) W24(8.3,-4.12) W25(9.1,-4.12) W26(9.9,-4.12) W27(10.7,-4.12) Y2(-9.9,-4.96) Y3(-9.1,-4.96) Y4(-8.3,-4.96) Y5(-7.5,-4.96) Y6(-6.66,-4.96) Y22(6.66,-4.96) Y23(7.5,-4.96) Y24(8.3,-4.96) Y25(9.1,-4.96) Y26(9.9,-4.96)
  round 0.457 smd: K10(-4,4) K11(-3,4) K12(-2,4) K13(-1,4) K14(0,4) K15(1,4) K16(2,4) K17(3,4) K18(4,4) L10(-4,3) L11(-3,3) L12(-2,3) L13(-1,3) L14(0,3) L15(1,3) L16(2,3) L17(3,3) L18(4,3) M10(-4,2) M11(-3,2) M12(-2,2) M13(-1,2) M14(0,2) M15(1,2) M16(2,2) M17(3,2) M18(4,2) N10(-4,1) N11(-3,1) N12(-2,1) N13(-1,1) N14(0,1) N15(1,1) N16(2,1) N17(3,1) N18(4,1) P10(-4,0) P11(-3,0) P12(-2,0) P13(-1,0) P14(0,0) P15(1,0) P16(2,0) P17(3,0) P18(4,0) R10(-4,-1) R11(-3,-1) R12(-2,-1) R13(-1,-1) R14(0,-1) R15(1,-1) R16(2,-1) R17(3,-1) R18(4,-1) T10(-4,-2) T11(-3,-2) T12(-2,-2) T13(-1,-2) T14(0,-2) T15(1,-2) T16(2,-2) T17(3,-2) T18(4,-2) U10(-4,-3) U11(-3,-3) U12(-2,-3) U13(-1,-3) U14(0,-3) U15(1,-3) U16(2,-3) U17(3,-3) U18(4,-3) V10(-4,-4) V11(-3,-4) V12(-2,-4) V13(-1,-4) V14(0,-4) V15(1,-4) V16(2,-4) V17(3,-4) V18(4,-4)
BGA1528M2446-1H52
  round 0.356 smd: A3(-10.396,22.315) A36(10.855,22.315) B2(-10.855,21.855) B37(11.315,21.855) C1(-11.315,21.396) CP1(-11.315,-21.855) CP37(11.315,-21.855) CR2(-10.855,-22.315) CR36(10.855,-22.315)
  round 0.33 smd: A4(-9.746,22.315) A35(10.205,22.315) B3(-10.227,21.687) B36(10.687,21.687) C2(-10.687,21.227) C37(11.315,21.205) CN1(-11.315,-21.205) CN37(11.315,-21.205) CP2(-10.687,-21.687) CP36(10.687,-21.687) CR3(-10.205,-22.315) CR35(10.205,-22.315) D1(-11.315,20.746)
  round 0.305 smd: A5(-9.096,22.292) A6(-8.232,22.315) A32(8.228,22.315) A34(9.555,22.315) AA4(-9.365,10.421) AA9(-6.21,10.624) AA24(3.679,10.481) AA26(4.606,10.481) AA34(9.365,10.719) AB3(-10.334,9.763) AB4(-9.325,9.763) AB5(-8.617,10.162) AB6(-7.967,10.162) AB7(-7.317,10.162) AB8(-6.668,10.162) AB9(-6.21,9.7) AB10(-5.753,10.162) AB25(4.142,10.025) AB27(5.069,10.025) AB28(5.719,10.025) AB29(6.369,10.025) AB30(7.019,10.025) AB31(7.669,10.025) AB32(8.32,10.025) AB33(9.04,10.068) AB34(9.69,10.068) AC4(-9.365,9.106) AC5(-8.617,9.238) AC6(-7.967,9.238) AC7(-7.317,9.238) AC8(-6.668,9.238) AC10(-5.753,9.238) AC24(3.679,9.57) AC25(4.142,9.114) AC26(4.606,9.57) AC27(5.069,9.114) AC28(5.719,9.114) AC29(6.369,9.114) AC30(7.019,9.114) AC31(7.669,9.114) AC32(8.32,9.114) AC34(9.365,9.417) AD4(-9.69,8.543) AD9(-6.21,8.776) AD24(3.679,8.658) AD26(4.606,8.658) AD33(9.04,8.809) AD35(10.245,8.809) AE4(-9.365,7.98) AE5(-8.617,8.314) AE6(-7.967,8.314) AE7(-7.317,8.314) AE8(-6.668,8.314) AE9(-6.21,7.852) AE10(-5.753,8.314) AE24(3.679,7.747) AE25(4.142,8.203) AE26(4.606,7.747) AE27(5.069,8.203) AE28(5.719,8.203) AE29(6.369,8.203) AE30(7.019,8.203) AE31(7.669,8.203) AE32(8.32,8.203) AE34(9.365,8.202) AF3(-10.334,7.322) AF4(-9.325,7.322) AF5(-8.617,7.39) AF6(-7.967,7.39) AF7(-7.317,7.39) AF8(-6.668,7.39) AF10(-5.753,7.39) AF25(4.142,7.291) AF27(5.069,7.291) AF28(5.719,7.291) AF29(6.369,7.291) AF30(7.019,7.291) AF31(7.669,7.291) AF32(8.32,7.291) AF33(9.04,7.551) AF34(9.69,7.551) AG4(-9.365,6.665) AG5(-8.617,6.467) AG6(-7.967,6.467) AG7(-7.317,6.467) AG8(-6.668,6.467) AG9(-6.21,6.929) AG10(-5.753,6.467) AG24(3.679,6.835) AG26(4.606,6.835) AG34(9.365,6.9) AH4(-9.69,6.102) AH9(-6.21,6.005) AH24(3.679,5.924) AH25(4.142,6.38) AH26(4.606,5.924) AH27(5.069,6.38) AH28(5.719,6.38) AH29(6.369,6.38) AH30(7.019,6.38) AH31(7.669,6.38) AH32(8.32,6.38) AH33(9.04,6.293) AH35(10.245,6.293) AJ4(-9.365,5.539) AJ5(-8.617,5.543) AJ6(-7.967,5.543) AJ7(-7.317,5.543) AJ8(-6.668,5.543) AJ10(-5.753,5.543) AJ25(4.142,5.468) AJ27(5.069,5.468) AJ28(5.719,5.468) AJ29(6.369,5.468) AJ30(7.019,5.468) AJ31(7.669,5.468) AJ32(8.32,5.468) AJ34(9.365,5.685) AK3(-10.334,4.882) AK4(-9.325,4.882) AK9(-6.21,5.081) AK24(3.679,5.013) AK26(4.606,5.013) AK33(9.04,5.034) AK34(9.69,5.034) AL4(-9.365,4.224) AL5(-8.617,4.619) AL6(-7.967,4.619) AL7(-7.317,4.619) AL8(-6.668,4.619) AL9(-6.21,4.157) AL10(-5.753,4.619) AL24(3.679,4.101) AL25(4.142,4.557) AL26(4.606,4.101) AL27(5.069,4.557) AL28(5.719,4.557) AL29(6.369,4.557) AL30(7.019,4.557) AL31(7.669,4.557) AL32(8.32,4.557) AL34(9.365,4.383) AM4(-9.69,3.661) AM5(-8.617,3.695) AM6(-7.967,3.695) AM7(-7.317,3.695) AM8(-6.668,3.695) AM10(-5.753,3.695) AM25(4.142,3.646) AM27(5.069,3.646) AM28(5.719,3.646) AM29(6.369,3.646) AM30(7.019,3.646) AM31(7.669,3.646) AM32(8.32,3.646) AM33(9.04,3.775) AM35(10.245,3.775) AN4(-9.365,3.098) AN5(-8.617,2.771) AN6(-7.967,2.771) AN7(-7.317,2.771) AN8(-6.668,2.771) AN9(-6.21,3.233) AN10(-5.753,2.771) AN24(3.679,3.19) AN25(4.142,2.734) AN26(4.606,3.19) AN27(5.069,2.734) AN28(5.719,2.734) AN29(6.369,2.734) AN30(7.019,2.734) AN31(7.669,2.734) AN32(8.32,2.734) AN34(9.365,3.168) AP3(-10.334,2.441) AP4(-9.325,2.441) AP9(-6.21,2.31) AP24(3.679,2.278) AP26(4.606,2.278) AP33(9.04,2.517) AP34(9.69,2.517) AR4(-9.365,1.783) AR5(-8.617,1.848) AR6(-7.967,1.848) AR7(-7.317,1.848) AR8(-6.668,1.848) AR10(-5.753,1.848) AR25(4.142,1.823) AR27(5.069,1.823) AR28(5.719,1.823) AR29(6.369,1.823) AR30(7.019,1.823) AR31(7.669,1.823) AR32(8.32,1.823) AR34(9.365,1.866) AT4(-9.69,1.22) AT9(-6.21,1.386) AT24(3.679,1.367) AT26(4.606,1.367) AT33(9.04,1.259) AT35(10.245,1.259) AU4(-9.365,0.657) AU5(-8.617,0.924) AU6(-7.967,0.924) AU7(-7.317,0.924) AU8(-6.668,0.924) AU9(-6.21,0.462) AU10(-5.753,0.924) AU24(3.679,0.456) AU25(4.142,0.911) AU26(4.606,0.456) AU27(5.069,0.911) AU28(5.719,0.911) AU29(6.369,0.911) AU30(7.019,0.911) AU31(7.669,0.911) AU32(8.32,0.911) AU34(9.365,0.65) AV3(-10.334,0) AV4(-9.325,0) AV5(-8.617,0) AV6(-7.967,0) AV7(-7.317,0) AV8(-6.668,0) AV10(-5.753,0) AV25(4.142,0) AV27(5.069,0) AV28(5.719,0) AV29(6.369,0) AV30(7.019,0) AV31(7.669,0) AV32(8.32,0) AV33(9.04,0) AV34(9.69,0) AW4(-9.365,-0.657) AW5(-8.617,-0.924) AW6(-7.967,-0.924) AW7(-7.317,-0.924) AW8(-6.668,-0.924) AW9(-6.21,-0.462) AW10(-5.753,-0.924) AW24(3.679,-0.456) AW25(4.142,-0.911) AW26(4.606,-0.456) AW27(5.069,-0.911) AW28(5.719,-0.911) AW29(6.369,-0.911) AW30(7.019,-0.911) AW31(7.669,-0.911) AW32(8.32,-0.911) AW34(9.365,-0.65) AY4(-9.69,-1.22) AY9(-6.21,-1.386) AY24(3.679,-1.367) AY26(4.606,-1.367) AY33(9.04,-1.259) AY35(10.245,-1.259) B4(-9.515,21.707) B5(-8.866,21.684) B33(8.901,22.004) B34(9.396,21.582) B35(10.037,21.687) BA4(-9.365,-1.783) BA5(-8.617,-1.848) BA6(-7.967,-1.848) BA7(-7.317,-1.848) BA8(-6.668,-1.848) BA10(-5.753,-1.848) BA25(4.142,-1.823) BA27(5.069,-1.823) BA28(5.719,-1.823) BA29(6.369,-1.823) BA30(7.019,-1.823) BA31(7.669,-1.823) BA32(8.32,-1.823) BA34(9.365,-1.866) BB3(-10.334,-2.441) BB4(-9.325,-2.441) BB9(-6.21,-2.31) BB24(3.679,-2.278) BB26(4.606,-2.278) BB33(9.04,-2.517) BB34(9.69,-2.517) BC4(-9.365,-3.098) BC5(-8.617,-2.771) BC6(-7.967,-2.771) BC7(-7.317,-2.771) BC8(-6.668,-2.771) BC9(-6.21,-3.233) BC10(-5.753,-2.771) BC24(3.679,-3.19) BC25(4.142,-2.734) BC26(4.606,-3.19) BC27(5.069,-2.734) BC28(5.719,-2.734) BC29(6.369,-2.734) BC30(7.019,-2.734) BC31(7.669,-2.734) BC32(8.32,-2.734) BC34(9.365,-3.168) BD4(-9.69,-3.661) BD5(-8.617,-3.695) BD6(-7.967,-3.695) BD7(-7.317,-3.695) BD8(-6.668,-3.695) BD10(-5.753,-3.695) BD25(4.142,-3.646) BD27(5.069,-3.646) BD28(5.719,-3.646) BD29(6.369,-3.646) BD30(7.019,-3.646) BD31(7.669,-3.646) BD32(8.32,-3.646) BD33(9.04,-3.775) BD35(10.245,-3.775) BE4(-9.365,-4.224) BE5(-8.617,-4.619) BE6(-7.967,-4.619) BE7(-7.317,-4.619) BE8(-6.668,-4.619) BE9(-6.21,-4.157) BE10(-5.753,-4.619) BE24(3.679,-4.101) BE25(4.142,-4.557) BE26(4.606,-4.101) BE27(5.069,-4.557) BE28(5.719,-4.557) BE29(6.369,-4.557) BE30(7.019,-4.557) BE31(7.669,-4.557) BE32(8.32,-4.557) BE34(9.365,-4.383) BF3(-10.334,-4.882) BF4(-9.325,-4.882) BF9(-6.21,-5.081) BF24(3.679,-5.013) BF26(4.606,-5.013) BF33(9.04,-5.034) BF34(9.69,-5.034) BG4(-9.365,-5.539) BG5(-8.617,-5.543) BG6(-7.967,-5.543) BG7(-7.317,-5.543) BG8(-6.668,-5.543) BG10(-5.753,-5.543) BG25(4.142,-5.468) BG27(5.069,-5.468) BG28(5.719,-5.468) BG29(6.369,-5.468) BG30(7.019,-5.468) BG31(7.669,-5.468) BG32(8.32,-5.468) BG34(9.365,-5.685) BH4(-9.69,-6.102) BH9(-6.21,-6.005) BH24(3.679,-5.924) BH25(4.142,-6.38) BH26(4.606,-5.924) BH27(5.069,-6.38) BH28(5.719,-6.38) BH29(6.369,-6.38) BH30(7.019,-6.38) BH31(7.669,-6.38) BH32(8.32,-6.38) BH33(9.04,-6.293) BH35(10.245,-6.293) BJ4(-9.365,-6.665) BJ5(-8.617,-6.467) BJ6(-7.967,-6.467) BJ7(-7.317,-6.467) BJ8(-6.668,-6.467) BJ9(-6.21,-6.929) BJ10(-5.753,-6.467) BJ24(3.679,-6.835) BJ26(4.606,-6.835) BJ34(9.365,-6.9) BK3(-10.334,-7.322) BK4(-9.325,-7.322) BK5(-8.617,-7.39) BK6(-7.967,-7.39) BK7(-7.317,-7.39) BK8(-6.668,-7.39) BK10(-5.753,-7.39) BK25(4.142,-7.291) BK27(5.069,-7.291) BK28(5.719,-7.291) BK29(6.369,-7.291) BK30(7.019,-7.291) BK31(7.669,-7.291) BK32(8.32,-7.291) BK33(9.04,-7.551) BK34(9.69,-7.551) BL4(-9.365,-7.98) BL5(-8.617,-8.314) BL6(-7.967,-8.314) BL7(-7.317,-8.314) BL8(-6.668,-8.314) BL9(-6.21,-7.852) BL10(-5.753,-8.314) BL24(3.679,-7.747) BL25(4.142,-8.203) BL26(4.606,-7.747) BL27(5.069,-8.203) BL28(5.719,-8.203) BL29(6.369,-8.203) BL30(7.019,-8.203) BL31(7.669,-8.203) BL32(8.32,-8.203) BL34(9.365,-8.202) BM4(-9.69,-8.543) BM9(-6.21,-8.776) BM24(3.679,-8.658) BM26(4.606,-8.658) BM33(9.04,-8.809) BM35(10.245,-8.809) BN4(-9.365,-9.106) BN5(-8.617,-9.238) BN6(-7.967,-9.238) BN7(-7.317,-9.238) BN8(-6.668,-9.238) BN10(-5.753,-9.238) BN25(4.142,-9.114) BN27(5.069,-9.114) BN28(5.719,-9.114) BN29(6.369,-9.114) BN30(7.019,-9.114) BN31(7.669,-9.114) BN32(8.32,-9.114) BN34(9.365,-9.417) BP3(-10.334,-9.763) BP4(-9.325,-9.763) BP5(-8.617,-10.162) BP6(-7.967,-10.162) BP7(-7.317,-10.162) BP8(-6.668,-10.162) BP9(-6.018,-10.162) BP11(-5.093,-9.786) BP12(-4.253,-9.786) BP14(-3.413,-9.786) BP15(-2.574,-9.786) BP16(-1.734,-9.786) BP18(-0.894,-9.786) BP19(-0.054,-9.786) BP20(0.786,-9.786) BP22(1.626,-9.786) BP23(2.465,-9.786) BP24(3.305,-9.786) BP25(4.145,-9.786) BP27(5.069,-10.025) BP28(5.719,-10.025) BP29(6.369,-10.025) BP30(7.019,-10.025) BP31(7.669,-10.025) BP32(8.32,-10.025) BP33(9.04,-10.068) BP34(9.69,-10.068) BR4(-9.365,-10.421) BR11(-5.093,-10.436) BR12(-4.253,-10.436) BR14(-3.413,-10.436) BR15(-2.574,-10.436) BR16(-1.734,-10.436) BR18(-0.894,-10.436) BR19(-0.054,-10.436) BR20(0.786,-10.436) BR22(1.626,-10.436) BR23(2.465,-10.436) BR24(3.305,-10.436) BR25(4.145,-10.436) BR34(9.365,-10.719) BT4(-9.69,-10.984) BT5(-8.617,-11.086) BT6(-7.967,-11.086) BT7(-7.317,-11.086) BT8(-6.668,-11.086) BT9(-6.018,-11.086) BT11(-5.093,-11.086) BT12(-4.253,-11.086) BT14(-3.413,-11.086) BT15(-2.574,-11.086) BT16(-1.734,-11.086) BT18(-0.894,-11.086) BT19(-0.054,-11.086) BT20(0.786,-11.086) BT22(1.626,-11.086) BT23(2.465,-11.086) BT24(3.305,-11.086) BT25(4.145,-11.086) BT27(5.069,-10.937) BT28(5.719,-10.937) BT29(6.369,-10.937) BT30(7.019,-10.937) BT31(7.669,-10.937) BT32(8.32,-10.937) BT33(9.04,-11.327) BT35(10.245,-11.327) BU4(-9.365,-11.547) BU5(-8.617,-12.009) BU6(-7.967,-12.009) BU7(-7.317,-12.009) BU8(-6.668,-12.009) BU9(-6.018,-12.009) BU11(-5.093,-11.736) BU12(-4.253,-11.736) BU14(-3.413,-11.736) BU15(-2.574,-11.736) BU16(-1.734,-11.736) BU18(-0.894,-11.736) BU19(-0.054,-11.736) BU20(0.786,-11.736) BU22(1.626,-11.736) BU23(2.465,-11.736) BU24(3.305,-11.736) BU25(4.145,-11.736) BU27(5.069,-11.848) BU28(5.719,-11.848) BU29(6.369,-11.848) BU30(7.019,-11.848) BU31(7.669,-11.848) BU32(8.32,-11.848) BU34(9.365,-11.934) BV3(-10.334,-12.204) BV4(-9.325,-12.204) BV11(-5.093,-12.386) BV12(-4.253,-12.386) BV14(-3.413,-12.386) BV15(-2.574,-12.386) BV16(-1.734,-12.386) BV18(-0.894,-12.386) BV19(-0.054,-12.386) BV20(0.786,-12.386) BV22(1.626,-12.386) BV23(2.465,-12.386) BV24(3.305,-12.386) BV25(4.145,-12.386) BV27(5.069,-12.76) BV28(5.719,-12.76) BV29(6.369,-12.76) BV30(7.019,-12.76) BV31(7.669,-12.76) BV32(8.32,-12.76) BV33(9.04,-12.585) BV34(9.69,-12.585) BW4(-9.365,-12.861) BW5(-8.617,-12.933) BW6(-7.967,-12.933) BW7(-7.317,-12.933) BW8(-6.668,-12.933) BW9(-6.018,-12.933) BW11(-5.093,-13.036) BW12(-4.253,-13.036) BW14(-3.413,-13.036) BW15(-2.574,-13.036) BW16(-1.734,-13.036) BW18(-0.894,-13.036) BW19(-0.054,-13.036) BW20(0.786,-13.036) BW22(1.626,-13.036) BW23(2.465,-13.036) BW24(3.305,-13.036) BW25(4.145,-13.036) BW34(9.365,-13.236) BY4(-9.69,-13.424) BY5(-8.617,-13.857) BY6(-7.967,-13.857) BY7(-7.317,-13.857) BY8(-6.668,-13.857) BY9(-6.018,-13.857) BY11(-5.093,-13.686) BY12(-4.253,-13.686) BY14(-3.413,-13.686) BY15(-2.574,-13.686) BY16(-1.734,-13.686) BY18(-0.894,-13.686) BY19(-0.054,-13.686) BY20(0.786,-13.686) BY22(1.626,-13.686) BY23(2.465,-13.686) BY24(3.305,-13.686) BY25(4.145,-13.686) BY27(5.069,-13.671) BY28(5.719,-13.671) BY29(6.369,-13.671) BY30(7.019,-13.671) BY31(7.669,-13.671) BY32(8.32,-13.671) BY33(9.04,-13.844) BY35(10.245,-13.844) C3(-10.059,21.059) C4(-9.213,21.132) C9(-6.305,21.245) C21(1.275,21.245) C25(3.792,21.245) C29(6.309,21.245) C33(8.826,21.245) C34(9.396,20.932) C35(10.037,21.037) C36(10.687,21.037) CA4(-9.365,-13.988) CA11(-5.093,-14.336) CA12(-4.253,-14.336) CA14(-3.413,-14.336) CA15(-2.574,-14.336) CA16(-1.734,-14.336) CA18(-0.894,-14.336) CA19(-0.054,-14.336) CA20(0.786,-14.336) CA22(1.626,-14.336) CA23(2.465,-14.336) CA24(3.305,-14.336) CA25(4.145,-14.336) CA27(5.069,-14.582) CA28(5.719,-14.582) CA29(6.369,-14.582) CA30(7.019,-14.582) CA31(7.669,-14.582) CA32(8.32,-14.582) CA34(9.365,-14.451) CB3(-10.334,-14.645) CB4(-9.325,-14.645) CB5(-8.617,-14.781) CB6(-7.967,-14.781) CB7(-7.317,-14.781) CB8(-6.668,-14.781) CB9(-6.018,-14.781) CB11(-5.093,-14.985) CB12(-4.253,-14.985) CB14(-3.413,-14.985) CB15(-2.574,-14.985) CB16(-1.734,-14.985) CB18(-0.894,-14.985) CB19(-0.054,-14.985) CB20(0.786,-14.985) CB22(1.626,-14.985) CB23(2.465,-14.985) CB24(3.305,-14.985) CB25(4.145,-14.985) CB33(9.04,-15.102) CB34(9.69,-15.102) CC4(-9.365,-15.302) CC5(-8.617,-15.705) CC6(-7.967,-15.705) CC7(-7.317,-15.705) CC8(-6.668,-15.705) CC9(-6.018,-15.705) CC11(-5.093,-15.635) CC12(-4.253,-15.635) CC14(-3.413,-15.635) CC15(-2.574,-15.635) CC16(-1.734,-15.635) CC18(-0.894,-15.635) CC19(-0.054,-15.635) CC20(0.786,-15.635) CC22(1.626,-15.635) CC23(2.465,-15.635) CC24(3.305,-15.635) CC25(4.145,-15.635) CC27(5.069,-15.494) CC28(5.719,-15.494) CC29(6.369,-15.494) CC30(7.019,-15.494) CC31(7.669,-15.494) CC32(8.32,-15.494) CC34(9.365,-15.753) CD4(-9.69,-15.865) CD11(-5.093,-16.285) CD12(-4.253,-16.285) CD14(-3.413,-16.285) CD15(-2.574,-16.285) CD16(-1.734,-16.285) CD18(-0.894,-16.285) CD19(-0.054,-16.285) CD20(0.786,-16.285) CD22(1.626,-16.285) CD23(2.465,-16.285) CD24(3.305,-16.285) CD25(4.145,-16.285) CE4(-9.365,-16.428) CE5(-8.617,-16.628) CE6(-7.967,-16.628) CE7(-7.317,-16.628) CE8(-6.668,-16.628) CE9(-6.018,-16.628) CE27(5.069,-16.405) CE28(5.719,-16.405) CE29(6.369,-16.405) CE30(7.019,-16.405) CE31(7.669,-16.405) CE32(8.32,-16.405) CE33(9.04,-16.36) CE35(10.245,-16.36) CF3(-10.334,-17.086) CF4(-9.325,-17.086) CF11(-5.37,-17.115) CF12(-4.368,-17.115) CF14(-3.33,-17.115) CF15(-2.292,-17.115) CF17(-1.254,-17.115) CF19(-0.216,-17.115) CF20(0.822,-17.115) CF22(1.86,-17.115) CF23(2.898,-17.115) CF25(3.936,-17.115) CF27(5.069,-17.317) CF28(5.719,-17.317) CF29(6.369,-17.317) CF30(7.019,-17.317) CF31(7.669,-17.317) CF32(8.32,-17.317) CF34(9.365,-16.968) CG4(-9.365,-17.743) CG5(-8.617,-17.552) CG6(-7.967,-17.552) CG7(-7.317,-17.552) CG8(-6.668,-17.552) CG9(-6.018,-17.552) CG11(-5.37,-17.765) CG12(-4.368,-17.765) CG14(-3.33,-17.765) CG15(-2.292,-17.765) CG17(-1.254,-17.765) CG19(-0.216,-17.765) CG20(0.822,-17.765) CG22(1.86,-17.765) CG23(2.898,-17.765) CG25(3.936,-17.765) CG33(9.04,-17.619) CG34(9.69,-17.619) CH4(-9.69,-18.306) CH5(-8.617,-18.476) CH6(-7.967,-18.476) CH7(-7.317,-18.476) CH8(-6.668,-18.476) CH9(-6.018,-18.476) CH11(-5.37,-18.415) CH12(-4.368,-18.415) CH14(-3.33,-18.415) CH15(-2.292,-18.415) CH17(-1.254,-18.415) CH19(-0.216,-18.415) CH20(0.822,-18.415) CH22(1.86,-18.415) CH23(2.898,-18.415) CH25(3.936,-18.415) CH27(5.069,-18.228) CH28(5.719,-18.228) CH29(6.369,-18.228) CH30(7.019,-18.228) CH31(7.669,-18.228) CH32(8.32,-18.228) CH34(9.365,-18.27) CJ4(-9.365,-18.869) CJ11(-5.37,-19.065) CJ12(-4.368,-19.065) CJ14(-3.33,-19.065) CJ15(-2.292,-19.065) CJ17(-1.254,-19.065) CJ19(-0.216,-19.065) CJ20(0.822,-19.065) CJ22(1.86,-19.065) CJ23(2.898,-19.065) CJ25(3.936,-19.065) CJ27(5.069,-19.139) CJ28(5.719,-19.139) CJ29(6.369,-19.139) CJ30(7.019,-19.139) CJ31(7.669,-19.139) CJ32(8.32,-19.139) CJ33(9.04,-18.833) CJ35(10.245,-18.878) CK1(-11.315,-19.561) CK3(-9.895,-19.83) CK4(-9.325,-19.518) CK5(-8.617,-19.4) CK6(-7.967,-19.4) CK7(-7.317,-19.4) CK8(-6.668,-19.4) CK9(-6.018,-19.4) CK11(-5.37,-19.715) CK12(-4.368,-19.715) CK14(-3.33,-19.715) CK15(-2.292,-19.715) CK17(-1.254,-19.715) CK19(-0.216,-19.715) CK20(0.822,-19.715) CK22(1.86,-19.715) CK23(2.898,-19.715) CK25(3.936,-19.715) CK33(9.15,-19.504) CK34(9.775,-19.326) CK36(10.612,-19.462) CK37(11.315,-19.374) CL2(-10.896,-20.058) CL35(10.061,-19.91) CL36(10.948,-20.019) CM1(-11.315,-20.555) CM3(-10.333,-20.383) CM4(-9.496,-20.343) CM5(-8.782,-20.365) CM6(-8.132,-20.371) CM7(-7.565,-20.69) CM8(-6.999,-20.371) CM9(-6.305,-20.365) CM10(-5.61,-20.371) CM11(-5.044,-20.69) CM12(-4.478,-20.371) CM13(-3.783,-20.365) CM14(-3.088,-20.371) CM15(-2.522,-20.69) CM16(-1.956,-20.371) CM17(-1.261,-20.365) CM18(-0.566,-20.371) CM19(0,-20.69) CM20(0.566,-20.371) CM21(1.261,-20.365) CM22(1.956,-20.371) CM23(2.522,-20.69) CM24(3.088,-20.371) CM25(3.783,-20.365) CM26(4.478,-20.371) CM27(5.044,-20.69) CM28(5.61,-20.371) CM29(6.305,-20.365) CM30(6.955,-20.365) CM31(7.531,-20.814) CM32(8.176,-20.365) CM33(8.826,-20.365) CM34(9.471,-20.286) CM35(10.447,-20.433) CM37(11.315,-20.555) CN2(-10.752,-20.88) CN3(-10.007,-20.946) CN4(-9.358,-20.978) CN5(-8.794,-21.367) CN9(-6.305,-21.245) CN13(-3.783,-21.245) CN17(-1.261,-21.245) CN21(1.261,-21.245) CN25(3.783,-21.245) CN29(6.305,-21.245) CN33(8.826,-21.245) CN34(9.396,-20.932) CN35(10.037,-21.037) CN36(10.687,-21.037) CP3(-10.037,-21.687) CP4(-9.39,-21.627) CP5(-8.942,-22.099) CP33(8.871,-21.968) CP34(9.396,-21.582) CP35(10.037,-21.687) CR4(-9.555,-22.315) CR6(-8.232,-22.315) CR32(8.321,-22.315) CR34(9.555,-22.315) D2(-10.64,20.579) D4(-9.594,20.605) D5(-8.782,20.365) D6(-8.132,20.371) D7(-7.565,20.69) D8(-6.999,20.371) D9(-6.305,20.505) D21(1.275,20.595) D22(1.883,20.365) D23(2.534,20.69) D24(3.184,20.365) D25(3.792,20.595) D26(4.4,20.365) D27(5.051,20.69) D28(5.701,20.365) D30(6.917,20.365) D31(7.568,20.69) D32(8.218,20.365) D34(9.396,20.282) D35(10.447,20.433) D37(11.315,20.555) E1(-11.315,20.096) E3(-10.008,20.089) E4(-9.365,19.995) E9(-6.21,19.862) E23(2.621,20.04) E27(5.051,20.04) E29(6.309,20.04) E31(7.568,20.04) E33(8.781,20.04) E35(10.061,19.91) E36(10.948,20.019) F2(-11.001,19.527) F3(-10.334,19.527) F4(-9.69,19.432) F5(-8.617,19.4) F6(-7.967,19.4) F7(-7.317,19.4) F8(-6.668,19.4) F21(1.149,19.715) F22(2.058,19.715) F24(3.184,19.715) F25(4.093,19.715) F33(9.15,19.504) F34(9.775,19.326) F36(10.612,19.462) F37(11.315,19.374) G1(-11.315,18.844) G4(-9.365,18.869) G9(-6.21,18.938) G21(1.149,19.065) G22(2.058,19.065) G24(3.184,19.065) G25(4.093,19.065) G27(5.069,19.139) G28(5.719,19.139) G29(6.369,19.139) G30(7.019,19.139) G31(7.669,19.139) G32(8.32,19.139) G33(9.04,18.833) G35(10.245,18.878) H4(-9.69,18.306) H5(-8.617,18.476) H6(-7.967,18.476) H7(-7.317,18.476) H8(-6.668,18.476) H9(-6.21,18.014) H21(1.149,18.415) H22(2.058,18.415) H24(3.184,18.415) H25(4.093,18.415) H27(5.069,18.228) H28(5.719,18.228) H29(6.369,18.228) H30(7.019,18.228) H31(7.669,18.228) H32(8.32,18.228) H34(9.365,18.27) J4(-9.365,17.743) J5(-8.617,17.552) J6(-7.967,17.552) J7(-7.317,17.552) J8(-6.668,17.552) J21(1.149,17.765) J22(2.058,17.765) J24(3.184,17.765) J25(4.093,17.765) J33(9.04,17.619) J34(9.69,17.619) K3(-10.334,17.086) K4(-9.325,17.086) K9(-6.21,17.09) K11(-5.322,17.115) K12(-4.38,17.115) K14(-3.438,17.115) K15(-2.496,17.115) K17(-1.554,17.115) K18(-0.613,17.115) K20(0.329,17.115) K21(1.149,17.115) K22(2.058,17.115) K24(3.184,17.115) K25(4.093,17.115) K27(5.069,17.317) K28(5.719,17.317) K29(6.369,17.317) K30(7.019,17.317) K31(7.669,17.317) K32(8.32,17.317) K34(9.365,16.968) L4(-9.365,16.428) L5(-8.617,16.628) L6(-7.967,16.628) L7(-7.317,16.628) L8(-6.668,16.628) L10(-5.753,16.628) L25(4.142,16.405) L27(5.069,16.405) L28(5.719,16.405) L29(6.369,16.405) L30(7.019,16.405) L31(7.669,16.405) L32(8.32,16.405) L33(9.04,16.36) L35(10.245,16.36) M4(-9.69,15.865) M9(-6.21,16.167) M24(3.679,15.949) M26(4.606,15.949) N4(-9.365,15.302) N5(-8.617,15.705) N6(-7.967,15.705) N7(-7.317,15.705) N8(-6.668,15.705) N9(-6.21,15.243) N10(-5.753,15.705) N25(4.142,15.494) N27(5.069,15.494) N28(5.719,15.494) N29(6.369,15.494) N30(7.019,15.494) N31(7.669,15.494) N32(8.32,15.494) N34(9.365,15.753) P3(-10.334,14.645) P4(-9.325,14.645) P5(-8.617,14.781) P6(-7.967,14.781) P7(-7.317,14.781) P8(-6.668,14.781) P10(-5.753,14.781) P24(3.679,15.038) P26(4.606,15.038) P33(9.04,15.102) P34(9.69,15.102) R4(-9.365,13.988) R9(-6.21,14.319) R24(3.679,14.127) R25(4.142,14.582) R26(4.606,14.127) R27(5.069,14.582) R28(5.719,14.582) R29(6.369,14.582) R30(7.019,14.582) R31(7.669,14.582) R32(8.32,14.582) R34(9.365,14.451) T4(-9.69,13.424) T5(-8.617,13.857) T6(-7.967,13.857) T7(-7.317,13.857) T8(-6.668,13.857) T9(-6.21,13.395) T10(-5.753,13.857) T25(4.142,13.671) T27(5.069,13.671) T28(5.719,13.671) T29(6.369,13.671) T30(7.019,13.671) T31(7.669,13.671) T32(8.32,13.671) T33(9.04,13.844) T35(10.245,13.844) U4(-9.365,12.861) U5(-8.617,12.933) U6(-7.967,12.933) U7(-7.317,12.933) U8(-6.668,12.933) U10(-5.753,12.933) U24(3.679,13.215) U26(4.606,13.215) U34(9.365,13.236) V3(-10.334,12.204) V4(-9.325,12.204) V9(-6.21,12.471) V24(3.679,12.304) V25(4.142,12.76) V26(4.606,12.304) V27(5.069,12.76) V28(5.719,12.76) V29(6.369,12.76) V30(7.019,12.76) V31(7.669,12.76) V32(8.32,12.76) V33(9.04,12.585) V34(9.69,12.585) W4(-9.365,11.547) W5(-8.617,12.009) W6(-7.967,12.009) W7(-7.317,12.009) W8(-6.668,12.009) W9(-6.21,11.548) W10(-5.753,12.009) W25(4.142,11.848) W27(5.069,11.848) W28(5.719,11.848) W29(6.369,11.848) W30(7.019,11.848) W31(7.669,11.848) W32(8.32,11.848) W34(9.365,11.934) Y4(-9.69,10.984) Y5(-8.617,11.086) Y6(-7.967,11.086) Y7(-7.317,11.086) Y8(-6.668,11.086) Y10(-5.753,11.086) Y24(3.679,11.392) Y25(4.142,10.937) Y26(4.606,11.392) Y27(5.069,10.937) Y28(5.719,10.937) Y29(6.369,10.937) Y30(7.019,10.937) Y31(7.669,10.937) Y32(8.32,10.937) Y33(9.04,11.327) Y35(10.245,11.327)
  oval 0.254x0.343 smd: A8(-6.915,22.315) A22(1.883,22.315) A24(3.184,22.315) A26(4.4,22.315) A28(5.701,22.315) A30(6.917,22.315) B6(-8.216,21.665) B7(-7.565,21.99) B8(-6.915,21.665) B9(-6.305,21.895) B21(1.275,21.895) B22(1.883,21.665) B23(2.534,21.99) B24(3.184,21.665) B25(3.792,21.895) B26(4.4,21.665) B27(5.051,21.99) B28(5.701,21.665) B29(6.309,21.895) B30(6.917,21.665) B31(7.568,21.99) B32(8.218,21.665) C6(-8.216,21.015) C7(-7.565,21.34) C8(-6.999,21.021) C22(1.883,21.015) C23(2.534,21.34) C24(3.184,21.015) C26(4.4,21.015) C27(5.051,21.34) C28(5.701,21.015) C30(6.917,21.015) C31(7.568,21.34) C32(8.218,21.015) CN6(-8.216,-21.015) CN7(-7.565,-21.34) CN8(-6.999,-21.021) CN10(-5.61,-21.021) CN11(-5.044,-21.34) CN12(-4.478,-21.021) CN14(-3.088,-21.021) CN15(-2.522,-21.34) CN16(-1.956,-21.021) CN18(-0.566,-21.021) CN19(0,-21.34) CN20(0.566,-21.021) CN22(1.956,-21.021) CN23(2.522,-21.34) CN24(3.088,-21.021) CN26(4.478,-21.021) CN27(5.044,-21.34) CN28(5.61,-21.021) CN30(6.912,-21.014) CN31(7.605,-21.461) CN32(8.219,-21.014) CP6(-8.216,-21.665) CP7(-7.565,-21.99) CP8(-6.915,-21.665) CP9(-6.305,-21.895) CP10(-5.694,-21.665) CP11(-5.044,-21.99) CP12(-4.393,-21.665) CP13(-3.783,-21.895) CP14(-3.172,-21.665) CP15(-2.522,-21.99) CP16(-1.871,-21.665) CP17(-1.261,-21.895) CP18(-0.65,-21.665) CP19(0,-21.99) CP20(0.65,-21.665) CP21(1.261,-21.895) CP22(1.871,-21.665) CP23(2.522,-21.99) CP24(3.172,-21.665) CP25(3.783,-21.895) CP26(4.393,-21.665) CP27(5.044,-21.99) CP28(5.694,-21.665) CP29(6.305,-21.895) CP30(6.983,-21.669) CP31(7.605,-22.19) CP32(8.296,-21.665) CR8(-6.915,-22.315) CR10(-5.694,-22.315) CR12(-4.393,-22.315) CR14(-3.172,-22.315) CR16(-1.871,-22.315) CR18(-0.65,-22.315) CR20(0.65,-22.315) CR22(1.871,-22.315) CR24(3.172,-22.315) CR26(4.393,-22.315) CR28(5.694,-22.315) CR30(6.912,-22.315)
  round 0.406 smd: A11(-5.322,22.315) A12(-4.38,22.315) A14(-3.438,22.315) A15(-2.496,22.315) A17(-1.554,22.315) A18(-0.613,22.315) A20(0.329,22.315) B11(-5.322,21.665) B12(-4.38,21.665) B14(-3.438,21.665) B15(-2.496,21.665) B17(-1.554,21.665) B18(-0.613,21.665) B20(0.329,21.665) C11(-5.322,21.015) C12(-4.38,21.015) C14(-3.438,21.015) C15(-2.496,21.015) C17(-1.554,21.015) C18(-0.613,21.015) C20(0.329,21.015) D11(-5.322,20.365) D12(-4.38,20.365) D14(-3.438,20.365) D15(-2.496,20.365) D17(-1.554,20.365) D18(-0.613,20.365) D20(0.329,20.365) F11(-5.322,19.715) F12(-4.38,19.715) F14(-3.438,19.715) F15(-2.496,19.715) F17(-1.554,19.715) F18(-0.613,19.715) F20(0.329,19.715) G11(-5.322,19.065) G12(-4.38,19.065) G14(-3.438,19.065) G15(-2.496,19.065) G17(-1.554,19.065) G18(-0.613,19.065) G20(0.329,19.065) H11(-5.322,18.415) H12(-4.38,18.415) H14(-3.438,18.415) H15(-2.496,18.415) H17(-1.554,18.415) H18(-0.613,18.415) H20(0.329,18.415) J11(-5.322,17.765) J12(-4.38,17.765) J14(-3.438,17.765) J15(-2.496,17.765) J17(-1.554,17.765) J18(-0.613,17.765) J20(0.329,17.765)
  oval 0.343x0.254 smd: AA1(-11.315,10.421) AA2(-10.665,10.421) AA3(-10.015,10.421) AA35(10.015,10.719) AA36(10.665,10.719) AA37(11.315,10.719) AB2(-10.99,9.763) AB35(10.34,10.068) AB36(10.99,10.068) AC1(-11.315,9.106) AC2(-10.665,9.106) AC3(-10.015,9.106) AC35(10.015,9.417) AC36(10.665,9.417) AC37(11.315,9.417) AD3(-10.34,8.543) AD36(10.895,8.809) AE1(-11.315,7.98) AE2(-10.665,7.98) AE3(-10.015,7.98) AE35(10.015,8.202) AE36(10.665,8.202) AE37(11.315,8.202) AF2(-10.99,7.322) AF35(10.34,7.551) AF36(10.99,7.551) AG1(-11.315,6.665) AG2(-10.665,6.665) AG3(-10.015,6.665) AG35(10.015,6.9) AG36(10.665,6.9) AG37(11.315,6.9) AH3(-10.34,6.102) AH36(10.895,6.293) AJ1(-11.315,5.539) AJ2(-10.665,5.539) AJ3(-10.015,5.539) AJ35(10.015,5.685) AJ36(10.665,5.685) AJ37(11.315,5.685) AK2(-10.99,4.882) AK35(10.34,5.034) AK36(10.99,5.034) AL1(-11.315,4.224) AL2(-10.665,4.224) AL3(-10.015,4.224) AL35(10.015,4.383) AL36(10.665,4.383) AL37(11.315,4.383) AM3(-10.34,3.661) AM36(10.895,3.775) AN1(-11.315,3.098) AN2(-10.665,3.098) AN3(-10.015,3.098) AN35(10.015,3.168) AN36(10.665,3.168) AN37(11.315,3.168) AP2(-10.99,2.441) AP35(10.34,2.517) AP36(10.99,2.517) AR1(-11.315,1.783) AR2(-10.665,1.783) AR3(-10.015,1.783) AR35(10.015,1.866) AR36(10.665,1.866) AR37(11.315,1.866) AT3(-10.34,1.22) AT36(10.895,1.259) AU1(-11.315,0.657) AU2(-10.665,0.657) AU3(-10.015,0.657) AU35(10.015,0.65) AU36(10.665,0.65) AU37(11.315,0.65) AV2(-10.99,0) AV35(10.34,0) AV36(10.99,0) AW1(-11.315,-0.657) AW2(-10.665,-0.657) AW3(-10.015,-0.657) AW35(10.015,-0.65) AW36(10.665,-0.65) AW37(11.315,-0.65) AY3(-10.34,-1.22) AY36(10.895,-1.259) BA1(-11.315,-1.783) BA2(-10.665,-1.783) BA3(-10.015,-1.783) BA35(10.015,-1.866) BA36(10.665,-1.866) BA37(11.315,-1.866) BB2(-10.99,-2.441) BB35(10.34,-2.517) BB36(10.99,-2.517) BC1(-11.315,-3.098) BC2(-10.665,-3.098) BC3(-10.015,-3.098) BC35(10.015,-3.168) BC36(10.665,-3.168) BC37(11.315,-3.168) BD3(-10.34,-3.661) BD36(10.895,-3.775) BE1(-11.315,-4.224) BE2(-10.665,-4.224) BE3(-10.015,-4.224) BE35(10.015,-4.383) BE36(10.665,-4.383) BE37(11.315,-4.383) BF2(-10.99,-4.882) BF35(10.34,-5.034) BF36(10.99,-5.034) BG1(-11.315,-5.539) BG2(-10.665,-5.539) BG3(-10.015,-5.539) BG35(10.015,-5.685) BG36(10.665,-5.685) BG37(11.315,-5.685) BH3(-10.34,-6.102) BH36(10.895,-6.293) BJ1(-11.315,-6.665) BJ2(-10.665,-6.665) BJ3(-10.015,-6.665) BJ35(10.015,-6.9) BJ36(10.665,-6.9) BJ37(11.315,-6.9) BK2(-10.99,-7.322) BK35(10.34,-7.551) BK36(10.99,-7.551) BL1(-11.315,-7.98) BL2(-10.665,-7.98) BL3(-10.015,-7.98) BL35(10.015,-8.202) BL36(10.665,-8.202) BL37(11.315,-8.202) BM3(-10.34,-8.543) BM36(10.895,-8.809) BN1(-11.315,-9.106) BN2(-10.665,-9.106) BN3(-10.015,-9.106) BN35(10.015,-9.417) BN36(10.665,-9.417) BN37(11.315,-9.417) BP2(-10.99,-9.763) BP35(10.34,-10.068) BP36(10.99,-10.068) BR1(-11.315,-10.421) BR2(-10.665,-10.421) BR3(-10.015,-10.421) BR35(10.015,-10.719) BR36(10.665,-10.719) BR37(11.315,-10.719) BT3(-10.34,-10.984) BT36(10.895,-11.327) BU1(-11.315,-11.547) BU2(-10.665,-11.547) BU3(-10.015,-11.547) BU35(10.015,-11.934) BU36(10.665,-11.934) BU37(11.315,-11.934) BV2(-10.99,-12.204) BV35(10.34,-12.585) BV36(10.99,-12.585) BW1(-11.315,-12.861) BW2(-10.665,-12.861) BW3(-10.015,-12.861) BW35(10.015,-13.236) BW36(10.665,-13.236) BW37(11.315,-13.236) BY3(-10.34,-13.424) BY36(10.895,-13.844) CA1(-11.315,-13.988) CA2(-10.665,-13.988) CA3(-10.015,-13.988) CA35(10.015,-14.451) CA36(10.665,-14.451) CA37(11.315,-14.451) CB2(-10.99,-14.645) CB35(10.34,-15.102) CB36(10.99,-15.102) CC1(-11.315,-15.302) CC2(-10.665,-15.302) CC3(-10.015,-15.302) CC35(10.015,-15.753) CC36(10.665,-15.753) CC37(11.315,-15.753) CD3(-10.34,-15.865) CE1(-11.315,-16.428) CE2(-10.665,-16.428) CE3(-10.015,-16.428) CE36(10.895,-16.36) CF2(-10.99,-17.086) CF35(10.015,-16.968) CF36(10.665,-16.968) CF37(11.315,-16.968) CG1(-11.315,-17.743) CG2(-10.665,-17.743) CG3(-10.015,-17.743) CG35(10.34,-17.619) CG36(10.99,-17.619) CH3(-10.34,-18.306) CH35(10.015,-18.27) CH36(10.665,-18.27) CH37(11.315,-18.27) CJ1(-11.315,-18.869) CJ2(-10.665,-18.869) CJ3(-10.015,-18.869) CJ36(10.895,-18.878) CK2(-10.485,-19.555) G2(-10.665,18.869) G3(-10.015,18.869) G36(10.895,18.878) H3(-10.34,18.306) H35(10.015,18.27) H36(10.665,18.27) H37(11.315,18.27) J1(-11.315,17.743) J2(-10.665,17.743) J3(-10.015,17.743) J35(10.34,17.619) J36(10.99,17.619) K2(-10.99,17.086) K35(10.015,16.968) K36(10.665,16.968) K37(11.315,16.968) L1(-11.315,16.428) L2(-10.665,16.428) L3(-10.015,16.428) L36(10.895,16.36) M3(-10.34,15.865) N1(-11.315,15.302) N2(-10.665,15.302) N3(-10.015,15.302) N35(10.015,15.753) N36(10.665,15.753) N37(11.315,15.753) P2(-10.99,14.645) P35(10.34,15.102) P36(10.99,15.102) R1(-11.315,13.988) R2(-10.665,13.988) R3(-10.015,13.988) R35(10.015,14.451) R36(10.665,14.451) R37(11.315,14.451) T3(-10.34,13.424) T36(10.895,13.844) U1(-11.315,12.861) U2(-10.665,12.861) U3(-10.015,12.861) U35(10.015,13.236) U36(10.665,13.236) U37(11.315,13.236) V2(-10.99,12.204) V35(10.34,12.585) V36(10.99,12.585) W1(-11.315,11.547) W2(-10.665,11.547) W3(-10.015,11.547) W35(10.015,11.934) W36(10.665,11.934) W37(11.315,11.934) Y3(-10.34,10.984) Y36(10.895,11.327)
