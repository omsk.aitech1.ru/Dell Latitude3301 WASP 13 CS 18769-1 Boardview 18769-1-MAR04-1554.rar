# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CCD_USB20_P: length 68.4
  L8 w0.089: v2(109.29,71.3) 109.29,71.32 109.05,71.56 109.05,72.2 108.29,72.95 97.27,72.95 95.61,74.61 94.87,74.61 92.94,72.69 90.85,72.69 90.55,72.99 84.15,72.99 84.06,73.08 84.06,73.67 83.86,73.87 83.41,73.87 83.21,73.67 83.21,73.08 83.12,72.99 82.82,72.99 82.74,73.08 82.74,73.67 82.54,73.87 82.08,73.87 81.88,73.67 81.88,73.08 81.8,72.99 80.63,72.99 80,73.63 66.25,73.63 65.6,74.28 v2(65.6,74.83)
  BOTTOM w0.083: CPU1.CC2 105.72,65.43 105.72,65.8 105.82,65.9 105.82,65.92
  BOTTOM w0.102: EL5501.4 57.57,73.59 61.19,73.59 61.82,72.96 63.72,72.96 64.82,74.06 65.18,74.06 65.42,74.31 65.42,74.65 65.41,74.65 v2(65.6,74.83) ; v2(109.29,71.3) 109.06,71.07 109.06,70.31 108.67,69.92 107.31,69.92 106.75,69.36 106.7,69.36 106.11,68.77 106.11,66.62 106.03,66.54 106.03,66.12 105.82,65.92
CD_WP_REV#: length 5.3
  BOTTOM w0.102: U3301.12 5.9,13.6 5.14,14.36 5.01,14.36 4.32,15.05 4,15.05 3.83,15.22 2.87,15.22 2.68,15.41 2.07,15.41 R3324.1
CFG3: length 14.5
  BOTTOM w0.102: R1517.1 65.17,69.05 66.09,69.05 v1(66.64,68.5) 67.89,67.25 73.55,67.25 74.31,66.49 75.37,66.49 75.9,65.96 75.9,64.7 76.16,64.44 CPU1.R3
CFG4: length 14.5
  BOTTOM w0.102: R1518.1 62.18,70 62.18,69.03 63.13,68.07 63.13,67.54 64.01,66.66 70.58,66.66 72.11,65.13 72.11,64.1 72.41,63.8 CPU1.J4
CFG_RCOMP: length 1.4
  TOP w0.508: v2(80.46,62.55) 80.5,62.51 R601.2
  BOTTOM w0.254: CPU1.AB5 80.2,62.83 80.46,62.56 v2(80.46,62.55)
CHG_AMBER_LED#: length 64.8
  TOP w0.127: v2(16.11,71.47) 16.07,71.52 v1(15.53,71.52) 15.53,71.18 R6426.2
  L3 w0.127: v2(16.11,71.47) 14.82,71.47 13.52,70.17 13.52,65.42 13.09,65 13.09,52.9 13.52,52.48 13.52,51.22 12.63,50.34 12.1,50.34 11.13,49.37 11.13,47.77 11.48,47.42 11.48,44.42 13.11,42.79 13.11,41.32 14.67,39.76 14.67,31.23 12.75,29.31 12.75,28.94 11.77,27.96 11.77,22.15 12.19,21.73 v3(13.61,21.73)
  BOTTOM w0.127: v2(16.11,71.47) 15.35,71.47 15.01,71.81 Q6404.1 ; v2(16.11,71.47) 15.86,71.72 15.86,73.02 15.5,73.39 R6421.1 ; v2(16.11,71.47) 16.11,70.82 Q6407.E ; v3(13.61,21.73) 13.47,21.6 Q2416.3
CHG_AMBER_LED_R#: length 10.8
  BOTTOM w0.127: Q6402.B 7.2,72.67 7.2,73.26 7.47,73.54 11.72,73.54 12.25,73 12.33,73 v1(12.71,72.63) 12.71,72.5 13.03,72.18 Q6404.6 13.61,71.81 14.01,72.21 15.07,72.21 R6421.2
CLK_ITE8010: length 11.8
  TOP w0.127: 190.03,5.17 192.48,5.17 193.23,5.92 193.23,8.69 194.02,9.48 194.24,9.48 194.36,9.61 194.36,9.65 v2(194.37,9.65) ; 190.03,5.17 189.19,5.17 188.73,5.63 R6602.2 ; 190.03,5.17 v1(190.03,5.34)
  BOTTOM w0.127: IO2.4 195.62,8.5 194.46,9.66 194.37,9.66 v2(194.37,9.65)
CLK_PCIE_PEG_REQ#: length 53.7
  TOP w0.102: Q7601.D 139.09,55.96 139.59,55.46 v2(139.59,55.23) ; RN1813.5 119.37,37.32 118.48,38.21 ; 118.48,38.21 118.85,38.58 120.76,38.58 123.35,41.17 123.35,42.36 125.34,44.34 125.34,45.57 127.75,47.98 v1(127.75,48.63) 127.75,49.75 v2(128.19,50.19) ; 118.48,38.21 115.86,38.21 113.29,40.78 113.29,41.72 111.01,43.99 108.93,43.99 108.52,44.4 108.52,44.81 108.91,45.21 108.91,45.54 108.42,46.03 108.42,46.33 v2(107.91,46.84)
  L6 w0.102: v2(139.59,55.23) 139.59,55.16 139.41,54.99 139.4,54.99 139.15,54.73 139.15,54.72 139.08,54.66 139.08,53.59 136.08,50.59 136.08,50.56 135.83,50.3 135.79,50.3 135.39,49.9 134.63,49.9 134.62,49.89 134.5,49.89 134.25,49.63 132.45,49.63 131.94,50.15 128.4,50.15 128.35,50.19 v2(128.19,50.19)
  BOTTOM w0.102: CPU1.CF32 107.67,45.89 107.91,46.13 v2(107.91,46.84)
CLK_TP_SIO: length 8.9
  TOP w0.127: R2408.2 27.1,9.15 R2407.1 27.95,8.64 v1(27.23,7.92) v2(26.56,7.24)
  BOTTOM w0.127: v2(26.56,7.24) 26.18,7.62 26.18,10.94 25.7,11.42 25.7,11.53 25.77,11.6 U2401.78
CLK_TP_SIO_I2C_DAT: length 136.1
  TOP w0.127: RN6501.3 v1(127.95,4.27) 128.37,4.68 128.47,4.68 128.79,4.99 128.95,4.99 129.59,5.64 v2(129.59,5.86) 129.31,6.14 129.31,6.25 128.81,6.76 128.14,6.76 EC6502.1 127.06,7.02 RN6502.2
  L8 w0.127: v2(14.39,13.8) 14.39,13.77 14.67,14.05 15.12,14.05 15.48,13.7 15.48,10.7 16.17,10.01 17.82,10.01 20.07,7.75 24.37,7.75 25.77,9.16 26.8,9.16 28.84,7.12 36.88,7.12 37.62,7.86 43.62,7.86 46.11,10.34 59.41,10.34 59.54,10.48 70.31,10.48 70.62,10.17 81.8,10.17 81.82,10.19 82.19,10.19 82.21,10.17 83.45,10.17 83.82,9.8 86.89,9.8 87.05,9.64 102.03,9.64 103.33,8.34 118.67,8.34 120.05,6.96 121.14,6.96 121.56,6.55 125.57,6.55 126.5,5.62 129.05,5.62 129.29,5.86 v2(129.59,5.86)
  BOTTOM w0.127: v2(14.39,13.8) 14.61,14.03 15.2,14.03 15.8,13.43 16.11,13.4 17.06,12.45 U2401.96
CLKIN_XTAL_LCP: length 100.3
  TOP w0.089: 165.97,26.11 165.78,26.31 v3(165.78,26.62) ; 165.97,26.11 166.06,26.03 166.82,26.03 R6118.2 ; 165.97,26.11 v1(165.96,26.11)
  L3 w0.076: v3(165.78,26.62) 165.78,27.11 167.27,28.6 167.27,37.43 163.55,41.14 163.55,45.71 161.79,47.48 161.79,48.6 160.01,50.37 160.01,50.74 159.78,50.97 156.8,50.97 154.91,52.86 153.76,52.86 152.91,53.72 151.54,53.72 145.26,60 145.26,60.65 144.54,61.37 144.54,63.33 141.13,66.74 141.13,69.07 136.85,73.35 136.85,74.37 135.54,75.68 133.22,75.68 128.05,70.51 126.86,70.51 126.6,70.24 122.69,70.24 120.86,72.07 118.66,72.07 v2(118.65,72.08)
  BOTTOM w0.089: WLAN1.64 166.73,15.55 166.48,15.8 166.48,18.84 166.48,18.87 166.48,25.92 v3(165.78,26.62) ; v2(118.65,72.08) 118.6,72.13 R6124.2
CLKIN_XTAL_LCP_R: length 11.8
  BOTTOM w0.127: R6124.1 117.04,72.13 v1(116.74,71.83) 116.74,70.62 115.7,69.57 115.7,67.83 112.6,64.73 112.22,64.73 112.03,64.55 111.71,64.55 111.7,64.54 CPU1.CM3
CNV_BRI_DT: length 90.6
  TOP w0.089: R6123.2 167.34,23.24 167.5,23.08 169.04,23.08 v2(169.56,22.56)
  L6 w0.089: v2(110.04,53.9) 111.57,53.9 112.84,52.63 113.19,52.63 113.2,52.65 115.68,52.65 115.91,52.88 119.64,52.88 120.6,51.91 121.72,51.91 122.02,52.22 124.77,52.22 125.08,51.91 126.12,51.91 126.59,52.38 127.48,52.38 127.84,52.75 130.72,52.75 131.57,51.89 133.53,51.89 133.91,51.51 135.24,51.51 135.65,51.1 v2(135.65,50.74)
  L8 w0.076: v2(135.65,50.74) 135.62,50.7 135.62,49.57 137.45,47.75 137.53,47.75 137.6,47.68 137.97,47.68 138.17,47.48 140.46,47.48 140.94,47.96 143.34,47.96 143.65,48.28 146.16,48.28 146.48,47.96 148.82,47.96 149.14,48.28 151.75,48.28 151.78,48.31 152.49,48.31 152.54,48.25 153.35,48.25 153.64,47.96 153.97,47.96 159.76,42.17 159.94,41.99 159.94,38.94 157.6,36.6 157.6,34.33 159.38,32.55 159.38,30.79 161.56,28.62 163.38,28.62 164.99,27.01 165.95,27.01 166.96,26 166.96,25.05 169.46,22.56 v2(169.56,22.56)
  BOTTOM w0.089: R6111.1 137.04,51.14 v1(136.06,51.14) v2(135.65,50.74) ; v2(110.04,53.9) 109.94,53.9 109.42,53.39 CPU1.CJ20
CNV_BRI_DT_R: length 57.3
  TOP w0.089: v3(139.4,51.42) 139.82,51 v1(139.84,51)
  L8 w0.076: v3(139.4,51.42) 139.4,51.42 139.4,51.34 139.85,50.89 139.96,50.89 140.26,50.59 140.26,50.53 140.67,50.12 144.05,50.12 144.66,50.74 147.67,50.74 147.75,50.81 148.62,50.81 148.7,50.74 150.44,50.74 151.33,49.85 154.03,49.85 155.9,47.97 156.79,47.97 162.62,42.14 162.62,39.68 163.26,39.04 163.46,38.84 163.46,36.4 163.47,36.39 163.47,34.49 162.69,33.71 162.69,31.91 164.85,29.75 166.15,29.75 167.61,28.29 167.61,27.67 168.23,27.05 168.23,25.63 168.81,25.05 170.09,25.05 170.7,24.43 170.7,24.42 170.7,23.96 v3(170.36,23.61)
  BOTTOM w0.089: R6111.2 138.18,51.42 v3(139.4,51.42) ; WLAN1.36 168.97,22.55 169.14,22.72 169.14,22.73 169.39,22.98 169.4,22.98 169.48,23.06 169.78,23.06 169.93,23.22 169.94,23.22 170.17,23.45 170.17,23.45 170.33,23.61 v3(170.36,23.61)
CNV_BRI_RSP: length 84.4
  TOP w0.089: R6102.1 169,26.89 v2(169.36,26.52)
  L8 w0.076: v3(135.61,55.45) 135.81,55.45 138.61,52.66 139.34,52.66 139.45,52.56 140.94,52.56 141.75,51.75 147.54,51.75 148.13,52.34 150.34,52.34 150.53,52.16 151.61,51.08 152.35,51.08 152.68,50.74 153.01,50.74 153.6,51.33 155.2,51.33 158.84,47.69 158.84,47.46 159.18,47.12 159.26,47.12 163.56,42.82 163.56,40.07 164.95,38.69 164.95,34.64 163.63,33.32 163.63,32.3 165.24,30.69 166.62,30.69 168.6,28.71 168.65,28.71 169.36,28 v2(169.36,26.52)
  BOTTOM w0.089: CPU1.CK20 110.37,53.39 110.46,53.3 112.62,53.3 112.89,53.57 113.62,53.57 115.07,55.02 120.94,55.02 121.23,54.74 124.8,54.74 125.83,55.76 R6121.2 127.37,55.98 128.18,55.98 128.5,56.3 130.18,56.3 130.8,55.68 v1(131.49,55.68) 135.39,55.68 v3(135.61,55.45)
CNV_BRI_RSP_R: length 4.2
  TOP w0.089: R6102.2 167.95,26.28 v1(168.65,26.28) 168.77,26.28 168.96,26.08 168.97,26.08 169.21,25.83 169.21,25.83 v3(169.41,25.63)
  BOTTOM w0.089: v3(169.41,25.63) 169.21,25.83 169.21,25.83 168.97,26.08 168.61,26.08 168.58,26.05 WLAN1.22
CNV_COEX3: length 37.9
  TOP w0.102: 170.74,22.26 171.04,22.56 v2(171.69,22.56) ; 170.74,22.26 170.7,22.21 R6109.1 ; 170.74,22.26 v1(170.74,22.26)
  L5 w0.102: v2(171.69,22.56) 172.32,21.92 173.46,21.92 173.66,22.12 186.27,22.12 186.35,22.04 189.15,22.04 193.02,18.17 193.02,12.99 193,12.97 193,11.86 193.02,11.84 193.02,11.19 193.81,10.39 v2(193.81,9.96)
  BOTTOM w0.102: IO2.10 195.5,7.3 194.33,8.47 194.22,8.47 193.71,8.98 193.71,9.63 193.7,9.64 193.7,9.84 v2(193.81,9.96)
CNV_MFUART2_RXD: length 45.2
  TOP w0.102: R6107.1 170.69,19.21 170.97,19.48 171.32,19.48 v2(171.65,19.15)
  L3 w0.089: v2(171.65,19.15) 171.3,19.5 171.09,19.5 170.89,19.71 170.89,20.32 171.23,20.66 178.9,20.66 180.74,22.49 186.01,22.49 186.57,23.05 189.82,23.05 190.44,22.42 190.44,21.46 192.39,19.52 195.81,19.52 196.51,18.82 196.51,9.18 196.43,9.09 196.43,7.35 196.6,7.19 196.73,7.19 v2(196.89,7.35)
  BOTTOM w0.102: IO2.12 196.37,6.9 196.42,6.85 196.53,6.85 196.89,7.21 v2(196.89,7.35)
CNV_MFUART2_TXD: length 44.3
  TOP w0.102: R6108.1 170.97,19.71 171.43,19.71 v2(171.65,19.94)
  L3 w0.089: v2(196.92,6.62) 196.64,6.88 196.63,6.89 196.52,7 196.52,7 196.24,7.27 196.24,9.17 196.32,9.26 196.32,18.74 195.73,19.33 192.31,19.33 190.25,21.38 190.25,22.34 189.74,22.86 186.65,22.86 186.09,22.3 180.82,22.3 178.98,20.46 171.31,20.46 171.08,20.24 171.08,19.78 171.17,19.7 171.3,19.7 171.41,19.7 171.51,19.79 v2(171.65,19.94)
  BOTTOM w0.102: v2(196.92,6.62) 196.47,6.62 196.35,6.5 IO2.14
CNV_RGI_DT: length 90.5
  TOP w0.089: v2(168.79,25.66) 168.38,25.25 R1515.2
  L6 w0.089: v2(135.03,52.29) 134.79,52.53 133.9,52.53 133.27,53.16 131.32,53.16 131.02,53.46 127.02,53.46 126.71,53.14 126.05,53.14 125.24,53.95 124.99,53.95 124.99,53.96 123.76,53.96 123.24,54.47 121.66,54.47 121.14,53.96 120.79,53.96 120.12,54.62 113.96,54.62 113.94,54.64 112.34,54.64 112.08,54.9 111,54.9 110.53,55.37 109.85,55.37 109.4,54.91 109.11,54.91 v2(108.08,53.89)
  L8 w0.076: v2(135.03,52.29) 136,52.29 136.37,51.92 140.64,51.92 142.13,50.43 143.82,50.43 144.43,51.04 147.55,51.04 147.62,51.11 148.75,51.11 148.82,51.04 150.75,51.04 151.64,50.15 154.99,50.15 157.16,47.99 157.21,47.99 162.92,42.27 162.92,39.81 163.78,38.96 163.78,37.24 163.78,37.24 163.78,34.37 162.99,33.58 162.99,32.04 164.97,30.06 166.28,30.06 167.92,28.42 167.92,27.79 168.58,27.12 168.58,25.86 v2(168.79,25.66)
  BOTTOM w0.089: v2(108.08,53.89) 107.91,54.06 CPU1.CG19 ; v2(135.03,52.29) 134.94,52.39 134.51,52.39 v1(134.42,52.29) 134.42,51.39 134.65,51.15 134.65,50.25 134.94,49.97 135.54,49.97 135.98,50.41 137.05,50.41 R6112.1
CNV_RGI_DT_R: length 55.4
  L8 w0.076: v3(139.4,50.7) 140.28,49.82 144.34,49.82 144.95,50.43 147.8,50.43 147.87,50.51 148.49,50.51 148.57,50.43 150.31,50.43 151.47,49.27 154.17,49.27 155.9,47.55 156.78,47.55 162.08,42.25 162.08,37.36 163.17,36.27 163.17,34.76 162.38,33.97 162.38,31.78 164.79,29.38 166.09,29.38 167.26,28.21 167.26,27.42 167.92,26.76 167.92,25.5 168.72,24.7 169.88,24.7 v3(170.31,24.27)
  BOTTOM w0.089: R6112.2 138.67,50.46 138.78,50.35 v1(138.84,50.35) 139.05,50.35 v3(139.4,50.7) ; WLAN1.32 168.25,23.55 169.4,24.7 169.85,24.7 170.29,24.27 v3(170.31,24.27)
CNV_RGI_RSP: length 88.8
  TOP w0.089: R6101.1 169.48,24.51 v3(169.68,24.3) ; v1(126.3,52.75) 126.11,52.94 v3(125.69,52.94) 125.69,53.66 R6122.2
  L6 w0.089: v2(108.72,53.92) 109.14,54.34 112.13,54.34 112.8,53.68 113.88,53.68 114.54,53.01 115.54,53.01 116.43,53.9 119.12,53.9 120.04,52.98 123.69,52.98 124.02,52.65 125.41,52.65 v3(125.69,52.94) 125.87,52.76 125.92,52.76 126.06,52.62 126.33,52.62 126.44,52.73 127.33,52.73 127.7,53.1 130.87,53.1 131.72,52.25 133.68,52.25 134.06,51.87 v2(135.5,51.87)
  L8 w0.076: v2(135.5,51.87) 136.09,51.27 136.09,50.58 135.92,50.42 135.92,49.7 137.35,48.27 137.81,48.27 138.3,47.78 140.33,47.78 140.82,48.26 143.21,48.26 143.53,48.58 143.53,48.58 143.59,48.64 153.73,48.64 157.84,44.52 158.91,44.52 161.05,42.38 161.05,36.77 161.77,36.05 161.77,34.69 161.21,34.13 161.21,31.22 162.57,29.87 163.59,29.87 164.61,28.84 165.4,28.84 165.83,28.41 166.07,28.41 166.31,28.17 166.31,27.94 167.62,26.63 167.62,25.33 168.64,24.3 v3(169.68,24.3)
  BOTTOM w0.089: CPU1.CH19 108.56,54.07 108.7,53.94 108.76,53.94 108.76,53.92 v2(108.72,53.92)
CNV_RGI_RSP_R: length 4.2
  TOP w0.089: v3(169.77,23.62) v1(168.99,23.62) 168.13,23.62 R6101.2
  BOTTOM w0.089: v3(169.77,23.62) 169.32,23.62 168.76,23.05 WLAN1.34
CNV_WR_CLK_DN: length 87.2
  L8 w0.089: v2(115.01,46.87) 115.03,46.87 115.32,46.58 115.86,46.58 116.06,46.38 116.06,45.37 116.15,45.28 116.33,45.28 116.42,45.37 116.42,46.38 116.62,46.58 119.4,46.58 121.81,44.18 121.81,40.08 123.74,38.15 123.74,36.34 124.7,35.38 125.23,35.38 126.13,34.48 126.13,30.86 126.84,30.15 126.84,29.49 125.84,28.49 125.84,28.07 125.93,27.98 127.02,27.98 127.22,27.78 127.22,27.44 127.02,27.24 125.93,27.24 125.84,27.15 125.84,26.11 127.47,24.48 134.3,24.48 134.85,23.93 134.85,23.42 136.68,21.59 149.6,21.59 150.26,20.93 152.46,20.93 152.66,20.73 152.66,19.29 152.75,19.2 152.93,19.2 153.02,19.29 153.02,20.73 153.22,20.93 161.93,20.93 v2(162.36,20.5)
  BOTTOM w0.076: CPU1.CN31 112.03,46.71 112.19,46.87 112.24,46.87 112.24,46.87 112.42,46.87 112.61,46.87 112.81,46.66 114.59,46.66 114.59,46.66 114.65,46.66 114.65,46.66 114.78,46.66 115,46.88 115,46.87 v2(115.01,46.87)
  BOTTOM w0.102: WLAN1.21 160.97,26.3 161.07,26.19 161.74,26.19 162.15,25.79 162.15,20.72 v2(162.36,20.5)
CNV_WR_CLK_DP: length 87
  L8 w0.089: v2(115.02,46.07) 115.01,46.08 115.01,46.3 115.09,46.39 115.78,46.39 115.87,46.3 115.87,45.29 116.07,45.09 116.41,45.09 116.61,45.29 116.61,46.3 116.7,46.39 119.33,46.39 121.62,44.1 121.62,40 123.55,38.07 123.55,36.26 124.62,35.19 125.15,35.19 125.94,34.4 125.94,30.78 126.65,30.07 126.65,29.57 125.65,28.57 125.65,27.99 125.85,27.79 126.94,27.79 127.03,27.7 127.03,27.52 126.94,27.43 125.85,27.43 125.65,27.23 125.65,26.03 127.39,24.29 134.22,24.29 134.66,23.85 134.66,23.34 136.6,21.4 149.52,21.4 150.18,20.74 152.38,20.74 152.47,20.65 152.47,19.21 152.67,19.01 153.01,19.01 153.21,19.21 153.21,20.65 153.3,20.74 160.92,20.74 161.08,20.59 161.08,20.07 161.15,19.99 161.48,19.99 161.57,20.08 v2(161.57,20.5)
  BOTTOM w0.076: CPU1.CP31 112.42,46.69 112.53,46.69 112.74,46.48 114.52,46.48 114.52,46.48 114.73,46.48 114.73,46.48 114.79,46.48 115.02,46.26 v2(115.02,46.07)
  BOTTOM w0.102: v2(161.57,20.5) 161.53,20.5 161.33,20.7 161.33,20.88 161.43,20.99 161.76,20.99 161.92,21.14 161.92,25.69 161.65,25.96 161.07,25.96 160.91,25.8 WLAN1.23
CNV_WR_DN0: length 86.8
  L8 w0.089: v2(116.26,47.86) 116.51,47.61 119.18,47.61 122.45,44.33 122.45,40.74 124.88,38.31 124.88,37.69 125.62,36.95 125.62,36.67 125.23,36.28 125.23,36.15 125.35,36.03 125.48,36.03 125.87,36.42 126.15,36.42 126.39,36.18 126.39,35.89 126,35.5 126,35.38 126.13,35.25 126.25,35.25 126.64,35.64 126.93,35.64 127.36,35.21 127.36,34.02 127.16,33.82 126.76,33.82 126.67,33.73 126.67,33.56 126.76,33.47 127.16,33.47 127.36,33.27 127.36,32.58 127.16,32.38 126.82,32.38 126.73,32.29 126.73,32.11 126.82,32.03 127.16,32.03 127.36,31.82 127.36,30.41 127.39,30.37 127.39,28.75 127.65,28.48 127.95,28.48 128.31,28.12 128.31,25.81 128.93,25.19 134.89,25.19 137.92,22.16 149.86,22.16 150.54,21.47 162.16,21.47 162.52,21.84 163.21,21.84 163.9,21.16 163.9,20.77 164.12,20.55 v2(164.17,20.55)
  BOTTOM w0.076: CPU1.CR30 112.54,47.22 112.76,47.22 112.9,47.08 114.4,47.08 114.67,47.34 114.68,47.34 114.96,47.63 115.11,47.63
  BOTTOM w0.102: v2(164.17,20.55) 163.77,20.95 163.77,21.92 162.97,22.72 162.97,23.61 163.48,24.13 163.48,26.27 162.1,27.66 160.93,27.66 160.76,27.83 160.02,27.83 WLAN1.15 ; v2(116.26,47.86) 116.08,47.68 115.58,47.68 115.58,47.67 115.24,47.67 115.24,47.68 115.18,47.68 115.17,47.67 115.16,47.67 115.11,47.63
CNV_WR_DN1: length 86.6
  L8 w0.089: v2(165.05,21.52) 165.05,21.59 164.88,21.76 164.88,21.92 164.41,22.39 162.3,22.39 161.93,22.02 160.02,22.02 159.93,22.11 159.93,22.41 159.73,22.61 159.4,22.61 159.2,22.41 159.2,22.11 159.11,22.02 151.33,22.02 150.6,22.75 138.11,22.75 135.02,25.84 129.69,25.84 128.98,26.55 128.98,28.44 127.98,29.44 127.98,35.36 126.62,36.72 126.62,38.26 124.49,40.39 123.84,40.39 123,41.24 123,44.63 119.47,48.15 119.41,48.15 118.95,48.15 118.95,48.15 118.45,48.15 117.85,48.76 115.22,48.76 114.83,48.37 114.57,48.37 v2(114.5,48.3)
  BOTTOM w0.076: CPU1.CM30 110.82,47.56 111.46,47.56 111.55,47.66 111.91,47.66 111.97,47.64 112.16,47.64 112.31,47.73 112.79,47.73 113.07,47.45 113.27,47.45 113.6,47.78
  BOTTOM w0.102: WLAN1.9 160.02,29.33 161.92,29.33 162.64,28.61 162.81,28.61 164.13,27.29 164.13,24.52 164.49,24.15 164.49,22.06 165.05,21.51 v2(165.05,21.52) ; 113.6,47.78 114.04,48.22 114.39,48.22 114.47,48.3 v2(114.5,48.3)
CNV_WR_DP0: length 86.8
  L8 w0.089: v2(116.27,47.05) 116.26,47.05 116.63,47.41 119.1,47.41 122.26,44.26 122.26,40.66 124.69,38.23 124.69,37.61 125.43,36.87 125.43,36.75 125.04,36.36 125.04,36.07 125.27,35.84 125.56,35.84 125.95,36.22 126.07,36.22 126.2,36.1 126.2,35.97 125.81,35.58 125.81,35.3 126.05,35.06 126.33,35.06 126.72,35.45 126.85,35.45 127.17,35.13 127.17,34.1 127.08,34.01 126.68,34.01 126.48,33.81 126.48,33.48 126.68,33.28 127.08,33.28 127.17,33.19 127.17,32.66 127.08,32.57 126.74,32.57 126.54,32.37 126.54,32.03 126.74,31.83 127.08,31.83 127.17,31.75 127.17,30.33 127.2,30.3 127.2,28.67 127.58,28.29 127.87,28.29 128.12,28.04 128.12,25.74 128.85,25 134.82,25 137.84,21.97 149.78,21.97 150.47,21.28 162.23,21.28 162.6,21.65 163.13,21.65 163.71,21.08 163.71,20.78 163.47,20.55 v2(163.38,20.55)
  BOTTOM w0.076: 115.25,47.45 115.24,47.44 115.08,47.44 115.02,47.44 114.98,47.4 114.75,47.17 114.74,47.17 114.48,46.9 112.83,46.9 112.75,46.98 112.73,47 112.69,47.03 112.41,47.03 CPU1.CP30
  BOTTOM w0.102: v2(163.38,20.55) 163.54,20.71 163.54,21.82 162.74,22.63 162.74,23.71 163.26,24.23 163.26,26.17 162,27.43 160.83,27.43 WLAN1.17 ; v2(116.27,47.05) 116.26,47.05 115.86,47.45 115.68,47.45 115.68,47.45 115.25,47.45
CNV_WR_DP1: length 86.6
  L8 w0.089: v2(114.35,47.65) 114.35,47.3 114.49,47.16 114.7,47.16 114.87,47.33 114.87,48.07 114.92,48.12 114.92,48.19 115.01,48.28 115.3,48.57 117.77,48.57 118.37,47.96 119.03,47.96 119.03,47.96 119.33,47.96 119.33,47.96 119.39,47.96 122.8,44.55 122.8,41.16 123.76,40.2 124.41,40.2 126.43,38.18 126.43,36.64 127.79,35.28 127.79,29.36 128.79,28.36 128.79,26.47 129.61,25.65 134.94,25.65 138.03,22.56 150.52,22.56 151.25,21.83 159.19,21.83 159.39,22.03 159.39,22.33 159.47,22.42 159.65,22.42 159.74,22.33 159.74,22.03 159.94,21.83 162.01,21.83 162.38,22.2 164.34,22.2 164.69,21.85 164.69,21.75 164.45,21.51 164.27,21.51 v2(164.27,21.52)
  BOTTOM w0.076: CPU1.CN30 111.29,47.17 111.4,47.17 111.47,47.25 111.47,47.34 111.62,47.49 111.89,47.49 111.96,47.48 112.2,47.48 112.35,47.56 112.71,47.56 112.99,47.28 113.38,47.28 113.66,47.56
  BOTTOM w0.102: WLAN1.11 160.91,28.8 161.21,29.1 161.83,29.1 162.55,28.38 162.71,28.38 163.9,27.19 163.9,24.42 164.27,24.06 v2(164.27,21.52) ; 113.66,47.56 113.7,47.56 113.83,47.69 114.3,47.69 114.33,47.65 v2(114.35,47.65)
CNV_WT_CLK_DN: length 88.6
  L8 w0.089: v2(162.51,12.87) 162.2,12.56 162.2,12.24 161.63,11.66 159.93,11.66 159.14,10.87 158.85,10.87 158.6,10.62 158.6,10.33 158.13,9.86 156.4,9.86 155.14,11.12 153.66,11.12 153.16,10.62 151.13,10.62 147.73,7.22 139.79,7.22 138.09,8.93 128.13,8.93 126.35,10.71 126.35,14.57 127.06,15.28 127.06,22.3 122.91,26.45 122.91,33.88 121.91,34.88 121.91,36.87 119.69,39.09 117.22,39.09 114.86,41.45 113.76,41.45 113.74,41.43 113.74,41.42 v2(113.73,41.42)
  BOTTOM w0.076: CPU1.CP34 112.17,44.81 112.23,44.88 112.25,44.88 112.26,44.88 112.27,44.88 112.4,44.93 112.68,44.93 112.81,44.8 112.81,43.72 112.96,43.56 112.96,43.54 112.98,43.53 112.98,43.42 113.04,43.35
  BOTTOM w0.102: 113.04,43.35 113.41,42.98 113.41,42.15 113.67,41.89 113.67,41.49 113.74,41.43 113.74,41.42 v2(113.73,41.42) ; WLAN1.71 160.02,13.83 160.94,13.83 161.05,13.72 161.26,13.72 161.51,13.98 162.21,13.98 162.45,13.74 162.45,12.94 v2(162.51,12.87)
CNV_WT_CLK_DP: length 88.6
  L8 w0.089: v2(161.72,12.87) 162.01,12.59 162.01,12.32 161.55,11.85 159.85,11.85 159.06,11.06 158.78,11.06 158.41,10.7 158.41,10.41 158.05,10.05 156.48,10.05 155.22,11.31 153.58,11.31 153.08,10.81 151.05,10.81 147.65,7.41 139.87,7.41 138.17,9.12 128.21,9.12 126.54,10.78 126.54,14.49 127.25,15.21 127.25,22.38 123.1,26.53 123.1,33.96 122.1,34.96 122.1,36.95 119.76,39.28 117.3,39.28 114.93,41.64 114.41,41.64 v2(114.15,41.9)
  BOTTOM w0.076: CPU1.CN34 111.58,45.11 111.7,45.1 111.85,45.1 111.91,45.04 112.17,45.04 112.22,45.06 112.23,45.06 112.37,45.11 112.75,45.11 112.98,44.88 112.98,43.79 113.14,43.63 113.14,43.62 113.16,43.6 113.16,43.56 113.21,43.51
  BOTTOM w0.102: v2(114.15,41.9) 114.17,41.9 114.17,41.92 114.15,41.95 113.94,41.95 113.64,42.24 113.64,43.08 113.21,43.51 ; WLAN1.73 160.02,13.33 160.94,13.33 161.1,13.49 161.35,13.49 161.61,13.75 162.12,13.75 162.22,13.65 162.22,13.37 v2(161.72,12.87)
CNV_WT_DN0: length 89.2
  L8 w0.089: v2(114.36,45.22) 114.36,44.87 113.77,44.28 113.77,43.77 113.61,43.61 113.61,42.92 113.98,42.54 114.62,42.54 117.52,39.64 119.62,39.64 119.91,39.64 122.45,37.1 122.45,35.11 123.61,33.95 123.61,26.52 127.61,22.53 127.61,15.06 126.9,14.35 126.9,10.96 126.91,10.95 126.91,10.92 128.35,9.48 140.78,9.48 142.49,7.77 145.87,7.77 147.49,9.39 148.87,9.39 149.82,10.34 149.82,11.52 150.19,11.89 153.17,11.89 153.24,11.83 153.75,11.83 153.85,11.92 155.64,11.92 156.32,12.6 156.78,12.6 156.98,12.8 156.98,13.29 157.07,13.38 157.25,13.38 157.33,13.29 157.33,12.6 157.65,12.28 158.26,12.28 158.74,12.76 158.74,14.91 158.72,14.93 158.19,15.46 v2(158.12,15.46)
  BOTTOM w0.076: CPU1.CN32 111.11,45.94 111.11,45.81 111.19,45.73 111.33,45.75 111.42,45.82 111.52,46.04 111.59,46.12 111.63,46.15 111.7,46.17 111.83,46.17 111.84,46.18 111.9,46.18 111.97,46.15 112.03,46.15 112.12,46.14 112.23,46.14 112.41,46.17 112.54,46.17 112.58,46.16 112.81,46.01 112.92,46.01
  BOTTOM w0.102: v2(158.12,15.46) 158.12,15.46 158.12,15.47 158.4,15.19 158.96,15.19 159.09,15.33 159.91,15.33 WLAN1.65 ; v2(114.36,45.22) 114.03,45.55 114.03,45.74 113.79,45.97 113.77,45.97 113.75,46 112.94,46 112.92,46.01
CNV_WT_DN1: length 88.3
  L8 w0.089: v2(162.76,15.84) 162.46,15.55 162.46,14.71 162,14.24 160.38,14.24 158.73,15.89 157.51,15.89 156.11,14.49 156.11,13.4 155.91,13.2 153.33,13.2 152.57,12.44 149.9,12.44 149.48,12.02 148.08,12.02 145.16,9.1 142.27,9.1 141.34,10.02 128.6,10.02 127.44,11.19 127.44,14.12 128.15,14.83 128.15,22.75 125.1,25.81 125.1,33.24 123,35.34 123,37.32 120.14,40.18 119.39,40.18 117.75,40.18 114.68,43.26 114.68,43.34 114.5,43.52 114.38,43.52 114.22,43.36 114.22,43.35 v2(114.22,43.35)
  BOTTOM w0.076: 113.86,43.83 113.85,43.84 113.85,43.89 113.83,43.91 113.83,43.93 113.7,44.06 113.7,44.28 113.7,44.47 113.7,44.68 113.04,45.33 112.12,45.33 CPU1.CP33
  BOTTOM w0.102: 113.86,43.83 113.95,43.74 114.22,43.47 114.22,43.37 114.22,43.36 114.22,43.35 v2(114.22,43.35) ; WLAN1.59 160.02,16.83 162.02,16.83 162.76,16.09 v2(162.76,15.84)
CNV_WT_DP0: length 89.2
  L8 w0.089: v2(158.12,14.68) 158.12,14.77 158.21,14.86 158.46,14.86 158.55,14.77 158.55,12.84 158.18,12.47 157.73,12.47 157.52,12.68 157.52,13.37 157.32,13.57 156.99,13.57 156.79,13.36 156.79,12.88 156.7,12.79 156.25,12.79 155.56,12.11 153.77,12.11 153.67,12.02 153.32,12.02 153.25,12.08 150.11,12.08 149.63,11.6 149.63,10.42 148.79,9.58 147.41,9.58 145.79,7.96 142.57,7.96 140.86,9.67 128.43,9.67 127.1,11 127.1,11.03 127.09,11.04 127.09,14.27 127.8,14.98 127.8,22.61 123.8,26.6 123.8,34.03 122.64,35.19 122.64,37.18 119.99,39.83 119.54,39.83 117.6,39.83 114.69,42.73 114.06,42.73 113.8,43 113.8,43.53 113.96,43.69 113.96,44.2 114.5,44.74 114.56,44.74 114.86,45.04 114.86,45.51 114.47,45.9 v2(114.4,45.9)
  BOTTOM w0.076: CPU1.CM32 110.9,46.31 111.48,46.35 111.76,46.35 111.76,46.35 111.93,46.35 112,46.33 112.04,46.33 112.13,46.32 112.22,46.32 112.4,46.35 112.6,46.35 112.62,46.34 112.66,46.33 112.66,46.33 112.85,46.2 112.93,46.2 113,46.2 113.02,46.21 113.03,46.21
  BOTTOM w0.102: v2(158.12,14.68) 158.4,14.96 158.96,14.96 159.09,14.83 159.91,14.83 WLAN1.67 ; v2(114.4,45.9) 114.19,45.9 113.88,46.21 113.03,46.21
CNV_WT_DP1: length 88.3
  L8 w0.089: v2(114.39,43.97) 114.4,43.97 114.63,43.73 114.63,43.66 114.87,43.42 114.87,43.33 117.83,40.37 119.31,40.37 120.22,40.37 123.19,37.4 123.19,35.42 125.29,33.31 125.29,25.88 128.34,22.83 128.34,14.75 127.63,14.04 127.63,11.27 128.68,10.21 141.42,10.21 142.35,9.29 145.08,9.29 148,12.21 149.4,12.21 149.82,12.63 152.49,12.63 153.26,13.39 155.83,13.39 155.92,13.48 155.92,14.57 157.43,16.08 158.8,16.08 160.45,14.43 161.92,14.43 162.27,14.78 162.27,15.72 v2(162.12,15.86)
  BOTTOM w0.076: 114.02,43.99 113.88,44.14 113.88,44.28 113.88,44.47 113.88,44.75 113.11,45.51 112.41,45.51 112.29,45.63 112,45.63 CPU1.CN33
  BOTTOM w0.102: v2(114.39,43.97) 114.05,43.97 114.02,43.99 ; v2(162.12,15.86) 162.22,15.86 162.33,15.97 162.33,16.09 162.34,16.09 162.34,16.19 161.93,16.6 161.09,16.6 160.79,16.3 WLAN1.61
CNV_WT_RCOMP: length 17.6
  TOP w0.089: v2(113.63,45.57) 113.63,45.72 114.58,46.68 114.58,47.04 115.19,47.65 115.59,47.65 115.84,47.9 115.84,48.03 116.08,48.28 116.56,48.28 117.4,47.44 121.31,47.44 122.85,45.9 123.49,45.9 123.51,45.92 123.86,45.92 123.88,45.9 124.44,45.9 125.35,46.81 v1(125.35,46.99) 125.35,47.84 R2101.2
  BOTTOM w0.089: v2(113.63,45.57) 113.47,45.72 112.63,45.72 CPU1.CR32 112.44,45.91 CPU1.CP32
CPU_DP1_CTRL_CLK: length 113.1
  TOP w0.127: v1(16.5,54.71) 16.5,54.94 16.79,55.23 RN401.3 16.84,55.52 18.52,55.52 18.65,55.39 v3(18.64,55.39)
  L8 w0.076: v2(105.39,59.82) 105.39,60.31 104.89,60.81 104.89,62.79 104.83,62.86 104.83,63.1 104.82,63.1 104.82,63.31 104.84,63.32 104.8,63.35
  L8 w0.127: 104.8,63.35 103.84,64.32 103.73,64.32 96.81,64.32 95.97,65.16 87.06,65.16 86.69,65.54 86.32,65.54 85.47,64.7 78.09,64.7 76.65,66.14 76.65,66.4 73.37,69.68 71.17,69.68 68.83,67.35 65.28,67.35 60.98,63.05 54.77,63.05 51,66.82 50.08,66.82 49.17,67.73 45.54,67.73 45.49,67.68 44.91,67.68 44.86,67.73 40.46,67.73 39.06,66.33 39.06,65.58 38.64,65.16 36.28,65.16 35.3,64.18 32.86,64.18 32.14,63.46 32.14,59.63 29.43,56.91 22.07,56.91 20.64,55.48 19.55,55.48 19.49,55.48 19.34,55.63 18.9,55.63 18.75,55.48 18.75,55.48 18.66,55.39 v3(18.64,55.39)
  BOTTOM w0.127: CPU1.CC8 105.39,60.41 v2(105.39,59.82) ; Q5702.1 16.29,54.98 16.89,55.58 18.47,55.58 18.66,55.4 18.66,55.39 v3(18.64,55.39)
CPU_DP1_CTRL_DATA: length 116.3
  TOP w0.127: RN401.4 16.96,56.08 v1(17.82,56.08) 17.87,56.03 v3(18.67,56.03)
  L8 w0.076: 104.98,63.53 105,63.51 105,63.25 104.99,63.24 104.99,63.17 104.99,62.93 105.06,62.86 105.06,60.88 106.09,59.84 106.09,59.78 v2(106.09,59.78)
  L8 w0.127: v3(18.67,56.03) 18.81,55.89 19.45,55.89 19.6,55.73 20.53,55.73 21.97,57.17 29.32,57.17 31.89,59.74 31.89,63.57 32.76,64.43 35.2,64.43 36.18,65.41 38.54,65.41 38.81,65.68 38.81,66.44 40.36,67.99 44.96,67.99 45.02,67.94 45.38,67.94 45.43,67.99 49.27,67.99 50.19,67.07 51.1,67.07 54.88,63.3 60.87,63.3 65.17,67.6 68.73,67.6 71.06,69.94 73.48,69.94 76.9,66.51 76.9,66.25 78.2,64.95 85.37,64.95 86.21,65.79 86.79,65.79 87.17,65.42 96.07,65.42 96.92,64.57 103.94,64.57 104.98,63.53
  BOTTOM w0.127: CPU1.CC9 105.85,60.02 v2(106.09,59.78) ; v3(18.67,56.03) 18.48,55.84 16.93,55.84 16.72,56.05 16.72,57.32 15.76,58.27 15.24,58.27 14.81,57.84 Q5702.4
CPU_DP2_CTRL_CLK: length 6.4
  BOTTOM w0.127: CPU1.CH4 108.74,64.18 108.74,65.2 108.65,65.29 108.65,65.63 109.4,66.39 109.4,68.7 109.78,69.07 110.33,69.07 RN403.3
CPU_DP2_CTRL_DATA: length 6.4
  BOTTOM w0.127: 109.15,68.49 109.15,66.5 108.39,65.74 108.39,65.19 108.46,65.12 CPU1.CH3 ; 109.15,68.49 v1(108.98,68.49) ; 109.15,68.49 109.15,68.8 109.67,69.33 109.69,69.33 110.07,69.7 RN403.4
CPU_DP_HPD_P: length 3.6
  BOTTOM w0.102: 129.81,63.76 v1(129.82,63.76) ; 129.81,63.76 129.86,63.81 129.86,64.5 129.49,64.86 RN405.3 ; 129.81,63.76 129.63,63.58 Q401.2 Q401.3
CPU_I2C_SCL_ISH0: length 160
  TOP w0.127: v2(193.17,28.72) 193.43,28.99 U7002.1 ; v2(108.82,52.93) 108.82,52.71 109.13,52.41 v1(110.8,52.41) 111,52.41 111.21,52.61 RN2007.2 ; v2(158.91,3.64) 158.71,3.84 158.71,4.43 158.05,5.09 158.05,10.01 158.28,10.25 158.28,11.31 161.01,14.03 161.01,18.76 161.23,18.98 161.66,18.98 v2(162.2,19.53)
  L3 w0.127: v2(108.82,52.93) 109.27,52.48 109.42,52.48 109.67,52.22 111.51,52.22 115.06,48.68 117.54,48.68 117.89,48.33 117.89,48.27 117.95,48.21 117.95,47.6 115.53,45.17 115.53,41.65 120.52,36.66 120.52,34.65 120.26,34.39 120.26,31.3 119.51,30.55 119.51,28.34 119.36,28.19 119.28,28.11 119.28,27.13 119.36,27.05 119.36,24.19 119.81,23.74 119.81,23.29 119.43,22.91 119.43,21.45 118.29,20.32 118.29,18.56 119.59,17.26 119.59,13.86 120.29,13.17 120.29,5.7 122.75,3.23 129.97,3.23 130.13,3.4 135.32,3.4 135.57,3.65 137.61,3.65 138.52,4.55 143.04,4.55 143.97,3.61 147.22,3.61 147.37,3.46 149.91,3.46 150.81,2.56 155.23,2.56 155.51,2.85 158.22,2.85 158.61,3.24 158.61,3.32 v2(158.91,3.64) ; v2(162.2,19.53) 162.39,19.34 164.3,19.34 164.52,19.55 165.88,19.55 167.74,21.41 178.45,21.41 180.27,23.23 185.7,23.23 186.82,24.35 189.15,24.35 189.56,24.77 190.86,24.77 193.71,27.62 193.71,28.17 v2(193.17,28.72)
  BOTTOM w0.127: v2(108.82,52.93) 108.82,53.05 108.56,53.31 CPU1.CH20
CPU_I2C_SCL_P0: length 87.3
  TOP w0.127: v2(125.59,11.99) v1(125.59,12.55)
  L6 w0.127: v2(113.72,59.12) 113.72,59.52 113.96,59.75 113.96,61.01 115.13,62.19 115.54,62.19 116.53,63.19 118.5,63.19 122.64,67.33 124.97,67.33 125.69,68.05 125.69,69.97 123.39,72.26 123.39,74.42 122.93,74.88 v2(122.93,75.16)
  L8 w0.127: v2(113.72,59.12) 112.42,57.81 112.42,48.94 112.75,48.61 112.75,41.72 113.24,41.23 113.24,41.22 113.53,40.93 113.54,40.93 114.31,40.16 115.87,38.6 118.94,38.6 121.42,36.13 121.42,34.68 122.42,33.68 122.42,25.1 126.54,20.98 126.54,15.46 125.86,14.78 125.86,12.25 v2(125.59,11.99)
  BOTTOM w0.076: v2(113.72,59.12) 113.53,58.92 113.37,58.92 113.27,58.82 112.92,58.82 112.7,59.04 112.33,59.04 arc(112.32,59.04) 112.31,59.04 arc(112.28,59.01) 112.23,59 arc(112.22,59) 112.21,59 112.08,59 arc(112,59.02) 111.92,59.07 111.74,59.25 CPU1.CN11
  BOTTOM w0.127: Q6504.1 125.2,11.83 125.36,11.99 v2(125.59,11.99) 125.79,12.19 R6505.1 ; CN1.9 123.45,75.91 122.95,75.41 122.95,75.16 v2(122.93,75.16)
CPU_I2C_SCL_P1: length 85.7
  TOP w0.127: v2(109.48,59.1) 109.52,59.14 ED5504.1 ; v1(55.44,76.69) 55.13,77 v2(55.13,77.22) 54.83,77.52 54.83,77.92 54.55,78.19 51.09,78.19 50.49,78.79 R5517.2 49.75,79.31 R5521.2
  L5 w0.127: v2(55.13,77.22) 55.57,77.67 58.06,77.67 63.44,72.29 63.97,72.29 64.02,72.24 64.28,72.24 64.37,72.15 65.56,72.15 65.65,72.24 77,72.24 77.05,72.29 77.09,72.29 78.05,73.25 93.56,73.25 94.74,74.44 95.4,74.44 97.7,72.14 112.19,72.14 112.39,71.93 112.39,71.91 v2(112.4,71.91)
  L6 w0.127: v2(109.48,59.1) 110.16,59.77 110.5,59.77 112.4,61.67 112.4,65.1 113.49,66.19 113.49,70.08 112.65,70.92 112.65,71.67 112.39,71.93 112.39,71.91 v2(112.4,71.91)
  BOTTOM w0.127: v2(109.48,59.1) 109.39,59 109.39,58.75 CPU1.CJ12
CPU_I2C_SCL_TP: length 15.8
  TOP w0.127: RN6502.4 125.78,6.39 125.65,6.52 125.2,6.52 124.88,6.2 124.88,6.19 124.75,6.07 v2(124.75,5.97) 124.75,5.83 124.48,5.56 123.93,5.56 123.66,5.83 123.66,6.64 123.53,6.77 122.87,6.77 RN6503.3
  BOTTOM w0.127: Q6504.6 125.93,12.83 125.93,12.84 126.05,12.84 R6505.2 126.49,13.05 126.81,12.73 126.81,10.9 AFTP6534.1 126.51,10.6 125.65,10.6 124.73,9.68 124.73,8.37 125.1,8 TPAD1.6 125.1,6.9 124.75,6.55 v2(124.75,5.97)
CPU_I2C_SCL_TS: length 3.8
  TOP w0.127: v1(50.6,81.46) 50.56,81.41 50.54,81.41 50.03,80.9 v2(50.03,80.88) 49.72,80.57 R5521.1
  BOTTOM w0.127: v2(50.03,80.88) 49.87,80.73 49.87,79.29 50,79.16 LCD1.29
CPU_I2C_SDA_ISH0: length 159.7
  TOP w0.127: v2(195.21,28.76) 195.05,28.92 U7002.4 195.9,29.49 v1(195.93,29.52) ; RN2007.1 110.88,54.05 110.3,53.46 109.96,53.46 v3(109.43,52.93) ; v2(158.28,3.63) 158.46,3.81 158.46,4.33 157.8,4.99 157.8,10.12 158.03,10.35 158.03,11.41 160.75,14.14 160.75,18.86 161.44,19.54 v2(161.45,19.54)
  L3 w0.127: v3(109.43,52.93) 109.45,52.93 109.54,52.85 109.54,52.72 109.78,52.48 111.62,52.48 115.16,48.93 117.65,48.93 118.15,48.44 118.15,48.37 118.2,48.31 118.2,47.49 115.78,45.07 115.78,41.75 120.77,36.77 120.77,34.54 120.51,34.29 120.51,31.2 119.76,30.44 119.76,28.23 119.62,28.09 119.54,28.01 119.54,27.24 119.62,27.16 119.62,24.29 120.06,23.85 120.06,23.19 119.68,22.8 119.68,21.34 118.55,20.21 118.55,18.67 119.85,17.37 119.85,13.97 120.54,13.27 120.54,5.8 122.86,3.48 129.86,3.48 130.03,3.65 135.21,3.65 135.46,3.9 137.51,3.9 138.41,4.8 143.14,4.8 144.08,3.87 147.32,3.87 147.48,3.71 150.02,3.71 150.92,2.82 155.12,2.82 155.41,3.1 158.11,3.1 158.35,3.34 158.35,3.55 v2(158.28,3.63) ; v2(161.45,19.54) 161.91,19.08 164.41,19.08 164.62,19.3 165.98,19.3 167.84,21.16 178.55,21.16 180.38,22.98 185.81,22.98 186.93,24.1 189.25,24.1 189.67,24.52 190.97,24.52 193.89,27.44 193.89,27.44 v2(195.21,28.76)
  BOTTOM w0.127: CPU1.CK22 109.43,52.78 v3(109.43,52.93)
CPU_I2C_SDA_P0: length 91.8
  L6 w0.127: v2(123.57,75.11) 123.64,75.03 123.64,72.37 125.94,70.07 125.94,67.94 125.07,67.07 122.74,67.07 118.61,62.93 116.64,62.93 115.64,61.94 115.24,61.94 114.21,60.91 114.21,59.27 v2(114.36,59.12)
  L8 w0.127: v2(114.36,59.12) 113.84,59.63 112.92,59.63 112.17,58.88 112.17,48.83 112.5,48.5 112.5,41.83 112.5,41.61 112.99,41.12 112.99,41.11 113.42,40.68 113.43,40.68 114.13,39.98 115.76,38.35 118.84,38.35 121.16,36.02 121.16,34.58 122.17,33.57 122.17,24.99 126.29,20.87 126.29,15.88 125.61,15.2 125.61,13.99 123.66,12.05 v2(123.45,12.05)
  BOTTOM w0.076: v2(114.36,59.12) 114.35,59.12 114.31,59.07 114.23,59.07 113.89,58.72 113.42,58.72 113.34,58.64 112.85,58.64 112.63,58.86 112.41,58.86 112.4,58.86 112.35,58.86 112.29,58.84 112.28,58.82 112.05,58.82 112.04,58.82 111.96,58.84 arc(111.93,58.85) 111.91,58.85 111.9,58.85 arc(111.88,58.86) 111.86,58.86 111.48,58.86 111.09,59.25 CPU1.CM11
  BOTTOM w0.127: v2(123.45,12.05) 123.53,12.05 123.9,12.41 Q6504.4 123.03,12.83 R6506.1 122.56,12.59 v1(121.95,13.2) ; v2(123.57,75.11) 123.45,74.99 CN1.10
CPU_I2C_SDA_P1: length 86.4
  TOP w0.127: v2(54.49,77.22) 54.47,77.22 54.55,77.3 54.55,77.81 54.42,77.94 53.35,77.94 ; 53.35,77.94 v1(53.35,77.73) ; 53.35,77.94 51.93,77.94 ED5503.1 51.1,77.82 50.36,78.56 49.27,78.56 R5518.2 48.93,78.85 R5522.2
  L5 w0.127: v2(54.49,77.22) 54.5,77.22 55.19,77.92 58.17,77.92 63.54,72.55 64.07,72.55 64.12,72.5 64.39,72.5 64.48,72.41 65.46,72.41 65.55,72.5 76.9,72.5 76.95,72.55 76.98,72.55 77.94,73.51 93.45,73.51 94.64,74.7 95.5,74.7 97.81,72.39 112.75,72.39 v2(113.21,71.93)
  L6 w0.127: v2(110.13,59.1) 110.19,59.1 112.65,61.57 112.65,64.99 113.75,66.08 113.75,70.18 112.9,71.03 112.9,71.63 v2(113.21,71.93)
  BOTTOM w0.127: v2(110.13,59.1) 109.86,58.83 CPU1.CK12
CPU_I2C_SDA_TP: length 13.1
  TOP w0.127: RN6502.3 125.13,7.04 v2(124.1,6.01) 123.91,6.21 123.91,6.75 123.63,7.02 122.76,7.02 122.69,6.95 122.64,6.9 121.9,6.9 121.67,6.68 RN6503.4
  BOTTOM w0.127: R6506.2 123.34,11.18 Q6504.3 123.96,11.11 123.96,9.85 AFTP6535.1 124.47,9.34 124.47,8.37 124.1,8 TPAD1.7 124.1,6.01 v2(124.1,6.01)
CPU_I2C_SDA_TS: length 3.6
  TOP w0.127: v1(49.39,81.47) 49.39,81.46 v2(49.39,80.91) 49.39,80.83 48.93,80.37 R5522.1
  BOTTOM w0.127: LCD1.28 49.62,78.84 49.62,80.68 v2(49.39,80.91)
CPU_POPIRCOMP:
  vias: v2(100.87,49.6)
CPU_SMB_ALERT#: length 10.4
  BOTTOM w0.102: R1552.1 118.02,56.05 R1551.2 117.92,56.13 117.45,55.66 114.71,55.66 v1(114.57,55.51) 113.38,55.51 113.07,55.81 110.48,55.81 110.46,55.83 110.42,55.83 110.04,56.21 109.51,56.21 109.38,56.34 CPU1.CJ15
CPU_SMB_ALERT#_P0: length 26.6
  L5 w0.102: v2(108.22,55.96) 108.65,56.39 110.07,56.39 110.15,56.31 110.51,56.31 111.4,57.2 111.4,59.94 112.85,61.38 115.52,61.38 115.78,61.12 115.78,59.88 114.31,58.4 114.31,57.94 115.04,57.2 119.87,57.2 v2(120.41,56.67)
  BOTTOM w0.102: v2(120.41,56.67) 121.04,56.67 121.22,56.49 R1504.2 121.92,57.16 R1505.1 122,57.88 R1806.1 122.09,58.21 v1(122.74,58.86) ; CPU1.CG15 107.91,56.33 108.22,56.03 v2(108.22,55.96)
CPU_SMB_ALERT#_P1: length 11.7
  L5 w0.102: v3(111.84,39.33) 111.06,40.11 111.06,42.09 110.44,42.71 107.2,43.68 107.11,43.72 v3(106.29,44.55)
  BOTTOM w0.102: v1(110.14,38.85) 110.14,39.42 R1555.1 111.17,39.73 R1837.2 111.67,39.31 111.83,39.31 v3(111.84,39.33) ; v3(106.29,44.55) 106.2,44.55 CPU1.CC34
CPU_SMB_SCL: length 3
  TOP w0.076: 109.51,57 109.66,57.16 109.78,57.16 110.07,57.45 110.34,57.45 v1(110.52,57.62) 110.73,57.83 RN1807.7
  TOP w0.089: v2(109.51,57) 109.51,57
  BOTTOM w0.127: CPU1.CK14 109.86,57.35 v2(109.51,57)
CPU_SMB_SCL_P0: length 4.8
  TOP w0.127: v1(110.97,59.75) 111.48,59.24 RN1807.5 111.17,58.92 110.83,58.58 110.59,58.58 110.59,58.58 109.19,58.58 108.88,58.27 v2(108.88,58.06)
  BOTTOM w0.127: CPU1.CH14 108.56,57.75 v2(108.88,58.06)
CPU_SMB_SCL_P1: length 204.7
  TOP w0.127: v1(135.33,53.91) 135.33,53.75 135.8,53.27 v2(135.8,53.19) 135.82,53.19 135.82,53.14 135.94,53.02 135.94,51.07 136.09,50.92 136.09,50.72 136.34,50.47 136.35,50.47 136.42,50.4 136.81,50.4 136.89,50.47 137.47,50.47 137.88,50.89 137.88,51.9 138.12,52.14 Q7901.3
  L5 w0.127: v2(117.7,23.19) 116.72,24.18 116.72,29.66 119.04,31.98 119.04,35.41 117.95,36.5 117.77,36.5 117.36,36.91 117.36,37.49 116.41,38.43 115.68,38.43 114.8,39.31 114.8,39.89 115.13,40.22 115.13,40.73 114.59,41.26 114.59,42.24 114.28,42.55 113.37,42.55 111.75,44.17 111.75,49.53 113.78,51.56 113.78,55.3 114.4,55.92 114.42,56.21 v2(114.38,56.27) ; v2(25.03,32.97) 25.19,33.12 25.4,33.12 26.03,32.5 26.03,32.4 26.47,31.96 27.04,31.96 27.89,32.81 28.77,32.81 29.03,32.55 30,31.57 40.04,31.57 41.21,30.41 41.21,29.67 40.85,29.31 40.85,27.82 42.57,26.09 42.57,23.87 47.85,18.59 47.85,18.1 v2(47.84,18.08)
  L6 w0.127: v2(135.8,53.19) 135.77,53.23 135.58,53.25 135.05,53.9 133.95,53.9 132.93,54.92 129,54.92 129,54.92 127.93,54.92 127.59,55.27 127.53,55.27 127.12,55.68 125.08,55.68 125.07,55.69 125.03,55.69 124.73,55.99 122.58,55.99 122.37,55.78 114.83,55.78 114.38,56.23 v2(114.38,56.27)
  L8 w0.127: v2(47.84,18.08) 47.84,18.06 48.15,17.74 48.15,17.65 49.09,16.71 72.92,16.71 73.66,15.97 114.7,15.97 117.51,18.78 117.51,23 v2(117.7,23.19)
  BOTTOM w0.076: 113.21,56.18 112.87,56.5 112.39,56.5 112.21,56.48 112.19,56.48 112.04,56.48 CPU1.CN15
  BOTTOM w0.089: 114.39,56.27 114.39,56.24 114.18,56.03 113.38,56.03 113.23,56.18 113.21,56.18 ; 114.39,56.27 114.39,56.29 114.44,56.34 114.44,56.46 114.69,56.71 115.23,56.71 115.39,56.87 RN1811.4 ; 114.39,56.27 v2(114.38,56.27)
  BOTTOM w0.127: v2(25.03,32.97) 24.87,33.13 23.71,33.13 23.62,33.04 21.97,33.04 21.81,32.87 21.81,32.47 R2406.2 ; v2(135.8,53.19) 135.82,53.19 135.82,53.17 135.79,53.17 135.44,53.52 134.59,53.52 132.96,51.89 132.39,51.89 131.41,50.9 130.16,50.9 128.88,49.62 128.88,48.64 127.65,47.41 127.65,47.35 126.86,46.56 126.86,45.99 126.63,45.75 125.71,45.75 125.2,45.24 Q2601.3
CPU_SMB_SCL_THM: length 20.8
  BOTTOM w0.127: Q2601.4 125.2,45.99 v1(124.23,45.03) 123.7,44.49 123.7,42.43 123.55,42.28 123.55,41.01 125.95,38.61 126.32,38.61 126.71,38.22 126.71,36.66 126.7,36.66 126.31,36.26 U2601.8 126.31,35.17 126.06,34.92 125.65,34.92 125.23,35.34 125.23,37.73 124.5,38.46 123.98,38.46 123.8,38.46 123.64,38.62 C2608.1 123.15,38.53 RN2602.3
CPU_SMB_SDA: length 4.5
  TOP w0.076: v2(108.86,56.99) 109.29,56.55 109.69,56.55 109.91,56.77 109.91,56.88 110.2,57.17 110.64,57.17
  TOP w0.089: RN1807.8 111.4,57.17 110.65,57.17 110.64,57.17
  TOP w0.127: v1(108.55,56.42) 108.55,56.59 108.86,56.89 v2(108.86,56.99)
  BOTTOM w0.127: v2(108.86,56.99) 108.86,56.9 108.56,56.61 CPU1.CH15
CPU_SMB_SDA_P0: length 5.2
  TOP w0.127: RN1807.6 110.97,58.33 110.96,58.33 110.7,58.33 110.7,58.33 110.22,58.33 110.12,58.23 110.12,57.97 109.8,57.64 109.46,57.64 109.34,57.52 v1(109.17,57.52) 108.56,57.52 108.22,57.18 v2(108.22,57)
  BOTTOM w0.127: v2(108.22,57) 107.91,57 107.41,56.5 CPU1.CF15
CPU_SMB_SDA_P1: length 199.1
  TOP w0.127: v1(136.5,54.25) 136.07,53.83 v2(136,53.83) 136.27,53.56 136.27,52.99 136.2,52.92 136.2,51.18 136.53,50.84 Q7901.6
  L5 w0.127: v2(115.01,56.23) 115.01,56.16 114.03,55.19 114.03,51.46 112,49.43 112,44.28 113.47,42.8 114.39,42.8 114.85,42.35 114.85,41.37 115.38,40.83 115.38,40.12 115.05,39.79 115.05,39.42 115.79,38.68 116.52,38.68 117.61,37.59 117.61,37.01 117.87,36.75 118.06,36.75 119.29,35.52 119.29,31.87 116.97,29.55 116.97,24.75 v2(117.7,24.01) ; v2(25,33.6) 25.23,33.38 25.51,33.38 26.29,32.6 26.29,32.5 26.57,32.22 26.94,32.22 27.78,33.06 28.87,33.06 29.28,32.65 30.11,31.83 40.14,31.83 41.46,30.51 41.46,29.56 41.1,29.2 41.1,27.92 42.83,26.2 42.83,23.98 48.36,18.45 48.36,18.38 v2(48.66,18.08)
  L6 w0.127: v2(115.01,56.23) 115.2,56.23 115.39,56.04 122.26,56.04 122.47,56.25 124.83,56.25 125.13,55.94 125.17,55.94 125.18,55.94 127.22,55.94 127.64,55.52 127.69,55.52 128.03,55.18 129.1,55.18 129.11,55.18 133.04,55.18 134.06,54.16 135.17,54.16 135.39,53.89 135.94,53.89 v2(136,53.83)
  L8 w0.127: v2(117.7,24.01) 117.7,23.82 117.26,23.38 117.26,18.88 114.6,16.22 73.77,16.22 73.02,16.97 49.19,16.97 48.47,17.69 48.47,17.87 48.66,18.06 v2(48.66,18.08)
  BOTTOM w0.076: 114.38,55.84 113.31,55.84 113.15,56 113.14,56 112.81,56.34 112.4,56.34 112.22,56.31 112.2,56.31 112.02,56.31 111.37,56.49 CPU1.CM15
  BOTTOM w0.089: 114.38,55.84 114.65,55.84 115.01,56.2 v2(115.01,56.23) 115.04,56.23 115.06,56.2 RN1811.3
  BOTTOM w0.127: Q2601.6 127.4,47.45 127.4,47.52 128.63,48.75 128.63,49.73 130.06,51.16 131.3,51.16 132.29,52.14 132.85,52.14 134.49,53.78 135.79,53.78 135.84,53.83 v2(136,53.83) ; R2405.2 21.55,32.5 21.55,32.98 21.87,33.29 23.52,33.29 23.61,33.38 24.78,33.38 v2(25,33.6)
CPU_SMB_SDA_THM: length 21.1
  BOTTOM w0.127: RN2602.4 123.04,37.86 C2609.1 123.64,38.05 123.8,38.21 123.98,38.21 124.39,38.21 124.98,37.62 124.98,35.23 125.55,34.66 126.64,34.66 126.96,34.98 U2601.7 126.96,38.32 126.42,38.86 126.05,38.86 123.8,41.12 123.8,42.17 123.95,42.33 123.95,42.96 124.21,43.22 v1(124.5,43.22) 125.47,43.22 126.5,44.24 Q2601.1
CPVEE: length 1.9
  TOP w0.203: 186.22,15.78 186.2,15.76 U2701.27
  TOP w0.305: 186.22,15.78 186.22,15.77 C2709.2
DAT_ITE8010: length 11.4
  TOP w0.127: R6601.2 188.94,4.85 189,4.91 189.24,4.92 192.59,4.92 193.48,5.81 193.48,8.59 194.12,9.23 194.23,9.23 194.36,9.09 v2(194.36,9)
  BOTTOM w0.127: IO2.6 196,8.11 195.99,8.12 195.64,8.12 194.76,9 v2(194.36,9)
DAT_TP_SIO: length 6.5
  TOP w0.127: v2(25.74,7.24) 25.74,6.72 26.02,6.43 AFTP2402.1
  BOTTOM w0.127: U2401.79 25.37,11.6 25.44,11.53 25.44,11.32 25.92,10.84 25.92,7.43 v2(25.74,7.24)
DAT_TP_SIO_I2C_CLK: length 131.9
  TOP w0.127: RN6501.4 128.37,4.94 v1(128.79,5.36) 128.81,5.38 128.81,6.01 v2(128.87,6.07) 128.22,6.07 EC6501.1 127.06,6.41 RN6502.1
  L8 w0.127: v2(14.38,14.57) 14.39,14.57 14.39,14.59 14.67,14.31 15.23,14.31 15.73,13.8 15.73,10.81 16.28,10.26 17.92,10.26 20.18,8.01 24.26,8.01 25.67,9.42 26.9,9.42 28.95,7.37 36.77,7.37 37.51,8.11 43.52,8.11 46,10.6 59.3,10.6 59.44,10.73 70.42,10.73 70.72,10.42 81.69,10.42 81.71,10.44 82.29,10.44 82.32,10.42 83.55,10.42 83.93,10.05 87,10.05 87.15,9.9 102.14,9.9 103.44,8.6 118.77,8.6 120.15,7.22 121.25,7.22 121.66,6.8 125.67,6.8 126.6,5.88 128.79,5.88 128.87,5.95 v2(128.87,6.07)
  BOTTOM w0.127: U2401.97 16.5,13.87 16.22,13.64 15.91,13.67 15.31,14.28 14.69,14.28 14.39,14.59 14.39,14.57 v2(14.38,14.57)
DBC_PANEL_EN: length 204.9
  TOP w0.102: v2(38.73,14.99) 39.68,15.94 39.68,16.69 38.47,17.9 38.18,17.9 36.21,19.87 35.9,19.87 33.91,21.86 33.91,23.42 35.32,24.83 35.32,33.96 v2(34.71,34.57) ; v2(118.82,25.53) 119.25,25.53 120.12,24.66 v1(120.12,23.34) 120.12,21.59 R2043.2
  L3 w0.102: v2(34.71,34.57) 34.71,35.95 35.95,37.18 35.95,56.6 v2(38.49,59.15) ; v2(105.23,46.19) 106.42,45 108.68,45 108.77,45.09 109.81,45.09 112.56,42.35 114.32,42.35 114.58,42.08 114.58,41.35 114.6,41.33 114.6,41.22 117.49,38.33 117.53,38.33 117.55,38.31 117.55,37.03 118.83,35.76 118.83,31.42 117.97,30.56 117.97,26.38 v2(118.82,25.53) 118.44,25.15 118.44,22.48 117.88,21.92 117.88,20.88 117.8,20.8 117.8,17.97 114.9,15.07 101.85,15.07 101.12,14.33 96.22,14.33 95.74,14.8 89.7,14.8 89.37,15.14 72.7,15.14 72.44,15.39 42.8,15.39 42.76,15.43 39.17,15.43 v2(38.73,14.99)
  L6 w0.102: v2(38.49,59.15) 39.87,60.52 39.87,64.7 39.81,64.75 39.81,65.11 39.87,65.16 39.87,67.31 37.79,69.39 37.79,70.32 36.83,71.29 36.83,78.9 37.68,79.76 37.68,80.6 38.49,81.41 40.5,81.41 41.4,80.51 v2(41.4,80.05)
  BOTTOM w0.102: v2(41.4,80.05) 41.2,79.85 LCD1.7 ; CPU1.CA31 105.08,46.19 v2(105.23,46.19)
DC_IN_OFF: length 39.7
  TOP w0.254: PQ4452.3 138.16,3.04 PR4470.2 139.14,2.05 144.05,2.05 144.39,1.72 160.12,1.72 161.65,3.25 162.12,3.25 163.13,4.26 163.59,4.26 167.36,8.03 v1(167.36,8.79) 167.36,10.15 168.55,11.34 PR4464.2
DCBATOUT_LCD_R_SEN: length 107.4
  TOP w0.127: v1(120.98,73.75) 120.67,73.44 v2(120.67,73.26)
  L5 w0.127: v2(39.04,69.73) 38.88,69.56 38.71,69.38 38.47,69.38 37.99,69.87 37.99,74.28 42.03,78.32 47.74,78.32 47.83,78.4 51.53,78.4 51.61,78.33 54.88,78.33 54.98,78.43 58.38,78.43 60.54,76.27 63.17,76.27 63.87,75.57 63.87,73.47 64.33,73 64.6,73 64.69,72.91 65.24,72.91 65.33,73 76.68,73 77.67,73.99 77.71,73.99 77.73,74.01 92.67,74.01 94.07,75.42 95.5,75.42 98.02,72.9 110.9,72.9 111.8,73.79 111.8,74.57 112.71,75.48 112.71,76.87 113.02,77.17 118.19,77.17 119.26,76.1 119.26,75.15 120.28,74.13 120.54,74.13 120.69,73.98 120.69,73.26 v2(120.67,73.26)
  BOTTOM w0.127: R6619.1 39.43,69.34 39.24,69.54 39.23,69.54 v2(39.04,69.73) ; CN1.4 122.25,74.46 122.18,74.53 122.18,74.84 121.9,75.11 121.13,75.11 120.69,74.68 120.69,73.47 120.69,73.46 120.69,73.26 v2(120.67,73.26)
DCBATOUT_VCCGT_SEN: length 117.9
  L3 w0.127: v2(62.45,84.83) 62.58,84.96 64.52,84.96 64.95,85.39 66.02,85.39 66.05,85.42 66.32,85.42 67.28,86.38 93.57,86.38 93.63,86.43 94.62,86.43 94.65,86.41 100.61,86.41 101.3,87.1 107.16,87.1 109.36,84.9 109.36,83.17 114.52,78.01 118.21,78.01 119.93,76.28 v2(119.93,75.56)
  L6 w0.127: v2(40.58,58.81) 40.81,58.53 40.8,58.35 40.8,58.11 40.38,57.69 39.98,57.69 39.64,58.03 39.64,58.49 40.13,58.98 40.13,58.99 41.19,60.04 41.19,68.62 39.97,69.84 39.97,69.86 39.95,69.88 39.95,76.4 42.37,78.81 57.18,78.81 61.4,83.04 61.4,84.89 61.58,85.07 61.95,85.07 62.19,84.83 v2(62.45,84.83)
  BOTTOM w0.127: v2(40.58,58.81) 40.35,58.58 R6610.2 ; v2(119.93,75.56) 120.1,75.72 120.1,76.14 120.12,76.16 120.12,76.18 120.38,76.44 120.58,76.44 ; CN1.1 121.85,76.37 121.92,76.3 121.92,76.19 121.82,76.09 121.44,76.09 121.09,76.44 120.58,76.44 ; v1(120.58,76.63) 120.58,76.44
DCBATOUT_VCCSA_SEN: length 34.1
  BOTTOM w0.127: 105.78,85.93 v1(105.78,86.11) ; 105.78,85.93 103.06,85.93 102.77,86.22 101.87,86.22 101.79,86.23 101.72,86.23 101.55,86.4 R6617.2 ; 105.78,85.93 107.38,85.93 108.51,84.81 108.51,83.02 113.71,77.82 120.88,77.82 122.49,79.43 122.49,80.03 122.84,80.38 124.72,80.38 125.98,79.11 125.98,78.09 125.42,77.53 125.42,76.71 CN1.19
DCBATOUT_VCORE_SEN: length 41.9
  L8 w0.127: v2(116.61,78.75) 116.64,78.75 117.04,78.35 117.04,77.93 118.52,76.45 118.52,73.04 120.04,71.52 123.53,71.52 123.95,71.93 123.95,72.22 124.27,72.55 124.29,72.55 124.55,72.81 124.55,72.83 124.68,72.96 v2(124.74,72.96)
  BOTTOM w0.127: 104.33,88.14 105.86,88.14 106.46,87.53 108.89,85.11 108.89,83.46 113.81,78.55 115.98,78.55 116.19,78.75 v2(116.61,78.75) ; 104.33,88.14 v1(104.33,88) ; 104.33,88.14 95.49,88.14 95.36,88.01 R6623.1 ; v2(124.74,72.96) 124.65,73.06 CN1.16
DCBATOUT_VDDQ_SEN: length 183.4
  TOP w0.127: v1(125.74,78.47) 125.63,78.57 v2(125.16,78.57) ; R6615.2 v2(37.07,39)
  L3 w0.127: v2(16.5,46.08) 16.43,46.01 16.25,46.01 15.93,46.33 15.93,48.99 16.67,49.73 16.67,50.29 16.66,50.29 16.66,50.66 17.23,51.23 17.23,52.32 18.29,53.37 18.29,54.62 17.84,55.06 17.84,57.07 18.77,57.99 18.77,61.16 18.72,61.21 18.72,64.01 21.15,66.44 22.32,66.44 23.67,67.79 23.67,68.46 25.46,70.25 27.1,70.25 27.76,70.9 27.76,71.44 28.51,72.19 28.51,74.92 30.49,76.91 30.8,76.91 30.8,76.91 32.37,76.91 32.58,77.12 36.05,77.12 37.84,78.91 51.47,78.91 53.41,80.86 56.39,80.86 56.6,81.07 57.13,81.07 58.82,82.76 58.82,85.6 60.03,86.81 61.31,86.81 61.36,86.76 65.33,86.76 66.53,87.96 87.55,87.96 87.64,88.04 93.24,88.04 93.26,88.05 108.68,88.05 110.14,86.59 127.13,86.59 128.26,85.46 128.26,79.7 128.1,79.54 126.33,79.54 125.44,78.66 125.24,78.66 v2(125.16,78.57)
  L5 w0.127: v2(37.07,39) 36.61,39.47 36.61,40.09 32.24,44.46 30.81,44.46 30.06,45.2 25.11,45.2 24.72,44.81 24.72,44.38 23.23,42.89 20.97,42.89 19.33,44.54 19.33,44.66 18.71,45.28 17.63,45.28 17.11,45.8 16.78,45.8 v2(16.5,46.08)
  BOTTOM w0.127: v2(125.16,78.57) 124.59,78.01 124.59,77.1 124.65,77.05 CN1.15
DDC_CLK_HDMI: length 25.4
  TOP w0.127: v2(17.13,68.51) 17.11,68.52 RN5701.2 ; v2(14.45,61.96) 14.78,62.29 ED5703.7 ED5703.4 14.78,64.05 14.38,64.44 v2(13.91,64.44)
  L3 w0.127: v2(13.91,64.44) 14.29,64.44 14.61,64.77 14.61,65.59 14.39,65.82 14.39,66.19 14.84,66.64 14.84,67.13 15.94,68.23 16.77,68.23 17,68.46 17.06,68.51 v2(17.13,68.51)
  L8 w0.127: HDMI1.15 10.4,61.6 11.06,62.26 11.06,63.56 11.29,63.78 13.5,63.78 13.91,64.19 v2(13.91,64.44)
  BOTTOM w0.127: v2(14.45,61.96) 14.06,61.96 13.93,61.83 13.93,61.18 v1(14.63,60.48) 14.63,60.35 13.93,59.66 13.93,56.58 14.55,55.96 15.89,55.96 16.11,56.18 Q5702.6
DDC_CLK_PH1: length 3
  TOP w0.127: RN5701.3 14.97,68.52 v2(14.76,68.31) 14.59,68.48 v1(14.59,68.84)
  BOTTOM w0.127: D5701.1 15.18,68.31 v2(14.76,68.31)
DDC_DATA_HDMI: length 25.4
  TOP w0.127: RN5701.1 17.13,67.85 v2(17.13,67.85) ; v2(16.28,62.11) ED5703.10 ED5703.1 16.28,64.7 v1(15.87,65.11) 14.97,66.01 v2(14.83,66.01)
  L3 w0.127: v2(17.13,67.85) 17.07,67.91 15.99,67.91 15.73,67.65 15.72,67.65 15.1,67.03 15.1,66.27 v2(14.83,66.01)
  L8 w0.127: v2(14.83,66.01) 14.83,65.15 14.48,64.79 14.48,64.05 12.53,62.1 HDMI1.16
  BOTTOM w0.127: Q5702.3 14.81,55.55 14.65,55.71 14.44,55.71 13.68,56.47 13.68,59.76 14.21,60.29 14.21,60.55 13.68,61.08 13.68,61.94 14.29,62.55 15.83,62.55 v2(16.28,62.11)
DDC_DATA_PH2: length 3.3
  TOP w0.127: v1(15.63,66.98) 15.63,67.76 RN5701.4 14.9,67.85 v2(14.72,67.67)
  BOTTOM w0.127: D5701.2 15.54,67.67 14.73,67.67 14.72,67.67 v2(14.72,67.67)
