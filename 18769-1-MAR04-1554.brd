# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_CS_PD: length 7.3
  BOTTOM w0.089: U7201.B3 28.32,64.38 28.32,64.94 28.56,65.19 28.56,65.41 29.25,66.1 29.25,66.15 29.45,66.35 U7202.1 31.62,66.35 31.86,66.1 v1(31.86,65.16) 31.86,65.11 32.05,64.93 32.58,64.93 R7228.1
SPI_HOLD_CPU: length 39
  L6 w0.089: v2(126.71,28.76) 127.17,29.22 127.17,30.16 126.71,30.62 126.71,32.32 124.72,34.31 122.16,34.31 121.54,33.7 118.87,33.7 118.55,34.02 117.92,34.02 117.86,33.96 116.23,33.96 115.68,34.51 115.68,34.64 116.04,35 116.04,35.12 115.92,35.25 115.79,35.25 115.43,34.89 115.3,34.89 115.18,35.01 115.18,35.14 115.54,35.5 115.54,35.63 115.41,35.75 115.29,35.75 114.93,35.39 114.8,35.39 113.85,36.34 110.42,36.34 110.32,36.45 110.32,36.77 110.6,37.06 110.6,37.47 110.31,37.75 109.84,37.75 109.38,37.3 109.08,37.3 108.69,37.69 108.69,38.56 109.01,38.88 v2(109.46,38.88)
  BOTTOM w0.076: 107.84,42.87 108.01,43.06 108.02,43.15 108.02,43.28 108,43.47 108,43.62 108.02,43.81 108.02,43.97 CPU1.CG34
  BOTTOM w0.089: v1(126.12,29.13) 126.34,29.13 v2(126.71,28.76) 127.05,28.76 R2503.2 ; 107.84,42.87 107.85,42.15 107.85,42.06 108.35,41.55 108.35,40.05 108.8,39.6 R1511.1 R1510.2 109.31,38.73 v2(109.46,38.88)
SPI_HOLD_PD: length 6
  TOP w0.089: R7226.1 35.13,67.29 35.59,67.75 36.7,67.75 v2(36.84,67.89)
  BOTTOM w0.089: U7202.7 35.33,67.08 35.5,66.91 36.63,66.91 v1(36.7,66.98) 36.7,67.75 v2(36.84,67.89)
SPI_HOLD_ROM: length 2.6
  BOTTOM w0.089: R2503.1 128.9,28.59 v1(128.9,28.36) 129.17,28.09 BIOS1.7
SPI_IRQ#_TPM2: length 4.7
  TOP w0.089: U9101.18 181.94,30.16 181.46,30.64 181.46,31.14 v1(181.04,31.56) 180.78,31.56 R9151.2 180.18,30.99 R9123.1 180.2,31.84 R9124.1
SPI_SI_CPU: length 97.8
  TOP w0.089: v2(177.34,24.82) 177.34,24.4 177,24.06 v1(177,24.01) ; v2(178.5,28.49) 178.83,28.82 R9133.1
  L6 w0.089: v2(107.35,39.01) 106.99,39.01 106.91,38.92 106.91,38.15 107.15,37.9 107.51,37.9 109.75,35.66 113.49,35.66 116.8,32.35 117.77,32.35 117.83,32.29 118.6,32.29 119.32,33.01 121.83,33.01 122.44,33.62 122.78,33.62 122.87,33.53 122.87,32.87 122.96,32.79 123.14,32.79 123.23,32.87 123.23,33.53 123.32,33.62 124.43,33.62 125.74,32.31 125.74,28.42 127.47,26.69 127.47,25.98 127.5,25.96 v2(127.5,25.53) 128.13,26.17 138.08,26.17 139.85,24.39 139.85,24.18 141.04,23 153.4,23 154.49,24.09 157.54,24.09 157.76,24.3 168.97,24.3 169.37,24.7 172.8,24.7 172.91,24.81 172.94,24.82 v2(177.34,24.82)
  L8 w0.076: v2(177.34,24.82) 177.34,25.9 178.5,27.06 v2(178.5,28.49)
  BOTTOM w0.076: CPU1.CF36 106.94,43.37 106.94,43.19 106.86,42.99 106.86,42.67 107.01,42.53
  BOTTOM w0.089: v2(127.5,25.53) 127.52,25.56 R2509.2 ; 107.01,42.53 107.09,42.44 107.09,41.54 106.74,41.19 R1507.1 106.74,40.13 106.36,39.74 106.36,39.12 R1506.2 107.07,38.73 v2(107.35,39.01)
SPI_SI_PD: length 11.7
  BOTTOM w0.089: U7201.B4 27.83,64.39 27.83,64.96 28.21,65.34 28.21,65.56 28.89,66.25 28.89,66.68 v1(28.97,66.75) 29.33,67.12 33.13,67.12 33.93,67.92 33.93,69.2 34.89,70.16 U7202.5
SPI_SI_ROM: length 2.3
  BOTTOM w0.089: BIOS1.5 130.31,25.56 R2509.1 129.06,25.11 v1(128.61,24.66)
SPI_SI_ROM_TPM: length 2.1
  TOP w0.089: R9133.2 181.15,28.82 v1(181.19,28.86) 181.39,28.66 U9101.21
SPI_SO_CPU: length 98.3
  TOP w0.089: v2(178.84,25.18) 179.16,25.5 R9132.1
  L6 w0.089: v2(107.35,40.31) 108.36,39.31 109.64,39.31 109.89,39.06 109.89,38.92 112.12,36.69 113.99,36.69 114.36,36.31 117.83,36.31 118.58,35.56 118.58,34.89 119.42,34.04 121.4,34.04 122.01,34.65 125.61,34.65 126.89,33.37 126.89,32.62 127.05,32.46 127.05,30.76 130.77,27.04 133.97,27.04 134.16,26.85 137.53,26.85 137.92,27.24 138.56,27.24 v3(139.03,26.77) 139.03,26.15 139.31,25.87 139.31,25.42 140.19,24.53 140.19,24.32 141.18,23.34 148.63,23.34 148.72,23.43 148.72,24.17 148.81,24.26 149.1,24.26 149.19,24.17 149.19,23.43 149.28,23.34 153.25,23.34 154.34,24.43 157.4,24.43 157.61,24.64 163.28,24.64 164.26,25.62 166.3,25.62 166.39,25.53 166.39,24.73 166.48,24.64 166.77,24.64 166.86,24.73 166.86,25.53 166.95,25.62 168.04,25.62 168.58,25.09 170.88,25.09 170.97,25.18 170.97,26.55 171.06,26.64 171.35,26.64 171.44,26.55 171.44,25.18 171.53,25.09 172.7,25.09 172.74,25.13 172.9,25.16 173.05,25.22 173.08,25.24 176.12,25.24 176.21,25.33 176.21,26.53 176.3,26.63 176.58,26.63 176.58,26.63 176.59,26.63 176.68,26.54 176.68,25.33 176.76,25.24 177.11,25.24 177.2,25.33 177.2,25.47 177.29,25.56 177.58,25.56 177.67,25.47 177.67,25.33 177.76,25.24 178.78,25.24 v2(178.84,25.18)
  BOTTOM w0.089: v3(139.03,26.77) 139.48,27.23 v1(140.02,27.23) 139.64,27.61 R2506.1 ; CPU1.CF37 107.12,42.68 107.27,42.53 107.27,41.07 107.35,40.99 v2(107.35,40.31)
SPI_SO_PD: length 9.6
  TOP w0.089: v2(32.32,67.54) v1(31.55,66.77) 31.55,66.36 32.17,65.74 R7230.1
  BOTTOM w0.089: U7201.A4 27.58,64.96 28.03,65.41 28.03,65.69 28.61,66.27 28.61,67.21 29.02,67.62 U7202.2 32.25,67.62 v2(32.32,67.54)
SPI_SO_ROM: length 2.8
  BOTTOM w0.089: BIOS1.2 138.15,28.09 138.22,28.17 138.34,28.17 v1(138.6,28.42) 139.14,28.96 R2506.2
SPI_SO_ROM_TPM: length 2.7
  TOP w0.089: U9101.24 182.11,26.49 v1(181.46,25.85) 181.11,25.5 R9132.2
SPI_WP_CPU: length 49.5
  L6 w0.089: v2(138.38,26.82) 138.07,26.51 134.01,26.51 133.83,26.69 130.63,26.69 129.04,28.29 126.58,28.29 126.28,28.58 126.28,29.35 126.65,29.72 126.65,30.19 126.36,30.48 126.36,32.18 124.58,33.97 122.3,33.97 121.69,33.36 119.17,33.36 118.99,33.17 118.2,33.17 117.75,33.62 116.09,33.62 113.71,36 109.89,36 107.57,38.32 v2(107.33,38.32)
  BOTTOM w0.076: 107.37,43.21 107.37,44.59 CPU1.CF34
  BOTTOM w0.089: v2(107.33,38.32) 107.56,38.32 R1508.2 108.37,39.14 108.37,39.78 107.96,40.19 R1509.1 107.96,40.75 107.45,41.26 107.45,43.14 107.37,43.21 ; v1(139.64,26.07) 139.03,25.46 R2507.1 138.48,25.88 138.48,26.08 138.38,26.19 v2(138.38,26.82)
SPI_WP_PD: length 6.4
  TOP w0.089: R7225.1 32.55,66.53 33.47,67.44 33.47,67.81 v1(33,68.28) 33,68.42 v2(33.47,68.89)
  BOTTOM w0.089: v2(33.47,68.89) 33.36,68.78 31.4,68.78 31.28,68.89 U7202.3
SPI_WP_ROM: length 4.1
  BOTTOM w0.089: R2507.2 138.91,24.35 v1(137.98,24.35) 137.98,24.95 138.13,25.1 138.13,25.95 137.26,26.82 BIOS1.3
SPK_ID: length 14.3
  BOTTOM w0.102: CPU1.CR14 112.52,57.43 114.48,57.43 114.6,57.31 114.63,57.31 115.13,57.31 115.5,57.68 116.47,57.68 116.55,57.76 120.43,57.76 v1(123.39,60.72) 124.79,60.72 R2110.2
SPKR: length 110.4
  TOP w0.203: R1501.1 124.85,37.54 124.68,37.71 v2(124.26,37.71)
  TOP w0.254: R2741.1 167.74,4.9 v2(167.42,5.21)
  L6 w0.254: 124.26,37.73 123.11,37.73 122.08,38.76 116.3,38.76 116.19,38.64 115.77,38.64 115.65,38.76 115.56,38.76 115.1,39.22 112.79,39.22 110.83,41.18 110.83,42.04 109.97,42.9 106.5,42.9 106,42.41 106,41.99 106.44,41.55 v2(106.52,41.55) ; 124.26,37.73 v2(124.26,37.71) ; 124.26,37.73 124.76,37.73 125.29,37.2 126.66,37.2 128.86,35 129.8,35 134.47,30.33 137.23,30.33 139.78,27.78 139.78,27.74 140.23,27.28 140.23,25.87 140.9,25.2 153.5,25.2 155.33,27.03 160.1,27.03 160.65,26.49 162.14,26.49 162.39,26.73 164.75,26.73 165.12,27.1 165.98,27.1 166,27.09 169.54,27.09 170.05,27.59 172.46,27.59 v2(172.83,27.96)
  BOTTOM w0.076: v2(106.52,41.55) 106.92,41.96 106.92,42.36 106.74,42.54 106.74,42.56 106.69,42.61 106.69,43 106.74,43.14 106.74,43.14 106.76,43.2 106.76,43.58 106.8,43.61 106.8,43.93 107.06,44.19 CPU1.CF35
  BOTTOM w0.254: v2(172.83,27.96) 174.72,26.07 174.72,17.05 172.61,14.94 172.13,14.94 171.74,14.55 171.74,14.54 170.57,13.37 170.57,11.32 v1(167.49,8.23) 167.2,7.94 167.2,5.44 v2(167.42,5.21)
SRTC_RST#: length 31.5
  TOP w0.102: v2(118.73,26.55) C1805.1 117.78,26.55 RN1801.3
  L6 w0.102: v2(102.92,36.39) 102.29,35.76 102.29,34.28 104.31,32.26 112.62,32.26 114.83,30.05 114.94,30.05 115.33,29.66 115.33,29.57 118.35,26.55 v2(118.73,26.55)
  BOTTOM w0.102: v2(102.92,36.39) 102.54,36.39 101.36,37.57 101.36,39.43 v1(101.32,39.47) 101.32,39.86 101.19,40 101.19,41.44 101.16,41.47 101.16,41.55 100.79,41.91 100.79,42.82 CPU1.BR37
SSD_CLK_CPU_N: length 101.8
  L3 w0.089: v2(92.04,69.19) 91.81,68.98 91.8,68.94 91.8,68.85 92.47,68.19 92.47,66.31 92.89,65.89 94.78,65.89 95.01,65.67 95.01,64.95 94.78,64.71 93.48,64.71 93.39,64.62 93.39,63.8 93.08,63.5 93.08,61.57 93.01,61.49 93.01,60.95 93.23,60.73 94.25,60.73 96.06,58.92 96.97,58.92 97.21,58.67 97.21,58.18 97.01,57.98 95.95,57.98 95.86,57.89 95.86,57.71 95.95,57.62 97.73,57.62 97.88,57.77 97.88,58.64 98.08,58.84 98.55,58.84 98.75,58.64 98.75,57.17 98.45,56.87 98.45,55.14 98.79,54.79 99.51,54.79 100.04,55.32 100.04,58.36 100.4,58.72 103.65,58.72 105.04,57.32 105.04,56.32 105.25,56.11 106.35,56.11 106.7,55.77 106.7,54.75 106.92,54.53 108.39,54.53 108.53,54.67 109.56,54.67 109.7,54.53 110.53,54.53 110.83,54.22 110.96,54.22 111.07,54.34 111.36,54.34 111.6,54.1 111.6,53.82 111.19,53.42 111.19,53.29 111.32,53.16 111.44,53.16 111.85,53.57 112.13,53.57 112.37,53.33 112.37,53.05 112.25,52.93 112.25,52.8 112.63,52.43 114.03,52.43 114.62,51.85 114.62,51.56 114.21,51.16 114.21,51.03 114.34,50.91 114.46,50.91 114.87,51.31 115.15,51.31 116.02,50.45 116.37,50.45 116.46,50.54 116.46,51.14 116.66,51.34 117,51.34 117.2,51.14 117.2,50.54 117.29,50.45 119.18,50.45 119.7,49.93 119.7,47.78 119.79,47.69 120.89,47.69 121.09,47.49 121.09,47.15 120.89,46.95 119.18,46.95 119.03,46.81 119.03,46.17 119.29,45.92 120.13,45.92 120.52,46.31 120.81,46.31 121.04,46.07 121.04,45.78 120.66,45.4 120.66,45.27 121.75,44.18 121.75,40.46 121.55,40.26 119.56,40.26 119.47,40.16 119.47,39.99 119.56,39.9 121.55,39.9 121.75,39.7 121.75,39.37 121.55,39.17 120.95,39.17 120.87,39.08 120.87,38.9 120.95,38.81 121.55,38.81 121.75,38.61 121.75,37.27 121.82,37.2 121.82,34.11 121.56,33.85 121.56,29.39 121.28,29.11 120.97,29.11 120.88,29.02 120.88,28.91 v2(120.69,28.72)
  BOTTOM w0.102: v2(92.04,69.19) 92.01,69.19 91.58,68.76 91.35,68.76 91.2,68.61 91.2,66.62 91.89,65.93 91.89,65.57 CPU1.BA1 ; SSD1.53 121.61,28.89 121.49,29.01 120.98,29.01 v2(120.69,28.72)
SSD_CLK_CPU_P: length 101.8
  L3 w0.089: v2(91.4,69.22) 91.61,69 91.61,68.78 92.28,68.11 92.28,66.24 92.81,65.7 94.71,65.7 94.82,65.59 94.82,65.03 94.7,64.9 93.4,64.9 93.2,64.7 93.2,63.88 92.89,63.58 92.89,61.65 92.82,61.57 92.82,60.87 93.15,60.54 94.17,60.54 95.99,58.73 96.89,58.73 97.02,58.6 97.02,58.25 96.93,58.17 95.87,58.17 95.67,57.97 95.67,57.63 95.87,57.43 97.81,57.43 98.07,57.69 98.07,58.56 98.16,58.65 98.47,58.65 98.56,58.56 98.56,57.25 98.26,56.95 98.26,55.06 98.71,54.6 99.59,54.6 100.23,55.24 100.23,58.28 100.48,58.53 103.57,58.53 104.85,57.24 104.85,56.24 105.17,55.92 106.27,55.92 106.51,55.69 106.51,54.67 106.84,54.34 108.47,54.34 108.61,54.48 109.48,54.48 109.62,54.34 110.45,54.34 110.75,54.03 111.04,54.03 111.15,54.15 111.28,54.15 111.41,54.02 111.41,53.9 111,53.5 111,53.21 111.24,52.97 111.52,52.97 111.93,53.38 112.05,53.38 112.18,53.25 112.18,53.13 112.06,53.01 112.06,52.73 112.55,52.24 113.95,52.24 114.43,51.77 114.43,51.64 114.02,51.24 114.02,50.95 114.26,50.72 114.54,50.72 114.95,51.12 115.07,51.12 115.94,50.26 116.45,50.26 116.65,50.46 116.65,51.06 116.74,51.15 116.92,51.15 117.01,51.06 117.01,50.46 117.21,50.26 119.1,50.26 119.51,49.85 119.51,47.7 119.71,47.5 120.81,47.5 120.9,47.41 120.9,47.23 120.81,47.14 119.1,47.14 118.84,46.88 118.84,46.09 119.21,45.73 120.21,45.73 120.6,46.12 120.73,46.12 120.85,45.99 120.85,45.86 120.46,45.48 120.46,45.19 121.56,44.1 121.56,40.54 121.47,40.45 119.49,40.45 119.28,40.24 119.28,39.91 119.48,39.71 121.47,39.71 121.56,39.62 121.56,39.45 121.47,39.36 120.88,39.36 120.68,39.16 120.68,38.82 120.88,38.62 121.47,38.62 121.56,38.53 121.56,37.19 121.63,37.12 121.63,34.19 121.37,33.93 121.37,29.47 121.2,29.3 120.88,29.3 v2(120.69,29.49)
  BOTTOM w0.102: CPU1.BA2 91.66,65.33 91.66,65.84 90.97,66.52 90.97,68.71 91.26,68.99 91.3,68.99 91.4,69.09 v2(91.4,69.22) ; v2(120.69,29.49) 120.94,29.24 121.49,29.24 121.64,29.39 SSD1.55
SSD_CLKREQ_CPU_N: length 34.2
  TOP w0.102: v2(107.02,47.51) 107.51,47.02 107.51,46.67 107.93,46.25 107.93,44.64 108.78,43.79 110.95,43.79 113.09,41.65 113.09,40.83 113.1,40.81 113.1,40.7 115.8,38 117.27,38 118.06,37.22 ; RN1813.6 v1(119.63,36.73) 119.53,36.73 118.78,37.48 118.31,37.48 118.06,37.22 ; 118.06,37.22 v2(118.06,37.2)
  L8 w0.102: v2(118.89,29.89) 119.35,30.36 119.35,35.53 118.06,36.83 v2(118.06,37.2)
  BOTTOM w0.102: CPU1.CE30 106.69,47.19 v2(107.02,47.51) ; v2(118.89,29.89) 118.21,29.89 116.96,28.64 SSD1.52
SSD_DEVSLP: length 82.2
  TOP w0.102: v2(128.18,49.55) 128.18,48.13 125.54,45.48 125.54,44.26 123.56,42.27 123.56,36.71 126.08,34.19 126.08,31.43 125.08,30.43 124.35,30.43 123.45,31.34 123.47,31.36 123.47,32.12 123.43,32.16 123.43,32.83 122.61,33.65 119.77,33.65 119.08,34.33 118.5,34.33 117.67,33.5 117.67,32.89 117.16,32.38 117.16,31.65 117.89,30.93 R6303.2 117.81,30.84 117.07,30.1 R6301.1 116.3,30.01 R6304.1
  L5 w0.102: v2(128.18,49.55) 129.17,50.54 129.17,54.19 129.22,54.24 129.22,54.92 128.52,55.62 128.52,56.84 127.81,57.55 127.81,57.91 128.06,58.16 128.67,58.16 128.9,57.93 130.26,57.93 131.64,59.31 132.43,59.31 133.48,58.26 133.8,58.26 v2(134.27,57.79)
  BOTTOM w0.076: 113.53,60.67 112.29,60.67 112.28,60.68 arc(112.24,60.72) 112.18,60.75 112.14,60.79 arc(112.07,60.84) 111.99,60.86 110.87,60.86 CPU1.CM8
  BOTTOM w0.102: 113.53,60.67 114.02,60.67 115.04,61.69 116.01,61.69 116.34,62.02 116.8,62.02 116.85,62.07 119.52,62.07 119.57,62.02 123.55,62.02 124.12,61.46 129.56,61.46 129.88,61.78 131.14,61.78 v1(133.67,59.25) 134.27,58.66 v2(134.27,57.79)
SSD_PCIE_RX_N1: length 74.7
  L3 w0.089: v2(125.46,22.7) 125.38,22.61 125.06,22.61 124.86,22.81 124.86,23.57 125.26,23.97 125.35,23.97 126.08,24.71 126.08,26.34 126.95,27.2 126.95,28.12 127.6,28.77 127.6,35.98 128.69,37.07 128.69,47.21 128.12,47.78 128.12,48.68 126.87,49.93 126.87,50.56 126.26,51.17 126.26,53.01 125.64,53.64 125.64,55.05 125.44,55.25 124.48,56.21 123.78,56.21 120.73,59.26 118.55,59.26 117.62,60.2 116.64,60.2 114.46,62.37 113.68,62.37 111.26,64.8 96.64,64.8 95.28,63.44 v3(95.28,63.11)
  BOTTOM w0.102: SSD1.29 123.45,22.89 123.52,22.96 124.93,22.96 125.2,22.7 v2(125.46,22.7) ; v3(95.28,63.11) 95.42,63.11 95.69,62.84 CPU1.BG5
SSD_PCIE_RX_N2: length 76.9
  L3 w0.089: v2(125.03,19.79) 125.68,19.79 125.92,20.03 125.92,20.81 124.5,22.23 124.5,24.14 125.73,25.36 125.73,26.56 126.28,27.11 126.28,29.08 127.25,30.04 127.25,36.15 128.34,37.24 128.34,47.06 127.76,47.64 127.76,48.53 126.52,49.78 126.52,50.41 124.73,52.2 124.73,54.66 120.84,58.55 118.48,58.55 117.32,59.71 115.78,59.71 111.02,64.47 96.81,64.47 95.78,63.44 95.78,62.9 v2(96.17,62.5)
  BOTTOM w0.102: CPU1.BJ6 96.29,62.5 v2(96.17,62.5) ; v2(125.03,19.79) 124.6,19.89 SSD1.17
SSD_PCIE_RX_N3: length 70.1
  L3 w0.089: v2(97.1,62.44) 96.7,62.84 96.7,63.52 96.97,63.79 101.47,63.79 104.25,61.01 104.25,59.67 105.52,58.4 106.56,58.4 107.34,57.62 111.35,57.62 113.93,55.03 116.82,55.03 118.13,53.73 118.13,53.61 121.13,50.6 121.73,50.6 122.35,49.99 122.35,45.13 122.84,44.63 122.84,37.73 122.91,37.65 122.91,33.66 122.66,33.4 122.66,32.72 122.65,32.72 122.65,26.41 121.66,25.42 121.66,25.38 121.65,25.36 121.65,17.14 121.25,16.74 v2(121.03,16.74)
  BOTTOM w0.102: CPU1.BK6 97.28,62.44 97.11,62.44 v2(97.1,62.44) ; v2(121.03,16.74) 121.17,16.89 SSD1.5
SSD_PCIE_RX_P1: length 74.7
  L3 w0.089: v3(95.27,62.46) 94.86,62.88 94.86,63.29 95.11,63.54 95.11,63.54 96.56,64.99 111.33,64.99 113.76,62.57 114.54,62.57 116.72,60.39 117.7,60.39 118.63,59.45 120.81,59.45 123.85,56.4 124.56,56.4 125.83,55.13 125.83,53.72 126.45,53.09 126.45,51.25 127.06,50.64 127.06,50.01 128.31,48.76 128.31,47.86 128.88,47.29 128.88,36.99 127.79,35.9 127.79,28.69 127.14,28.04 127.14,27.13 126.27,26.26 126.27,24.63 125.35,23.7 125.35,23.42 v2(125.34,23.42)
  BOTTOM w0.102: v2(125.34,23.42) 125.11,23.19 123.61,23.19 123.41,23.39 SSD1.31 ; v3(95.27,62.46) 95.41,62.46 CPU1.BG6
SSD_PCIE_RX_P2: length 76.9
  L3 w0.089: v2(96.21,63.15) 96.05,63.31 96.05,63.44 96.89,64.27 110.94,64.27 115.7,59.51 117.25,59.51 118.4,58.36 120.76,58.36 124.54,54.58 124.54,52.12 126.33,50.33 126.33,49.7 127.57,48.46 127.57,47.56 128.15,46.99 128.15,37.32 127.06,36.23 127.06,30.12 126.09,29.16 126.09,27.19 125.54,26.64 125.54,25.44 124.31,24.22 124.31,22.15 125.73,20.73 125.73,20.11 125.61,19.98 125.45,19.98 125.36,20.07 125.36,20.54 125.28,20.63 125.09,20.63 v2(125.03,20.57)
  BOTTOM w0.102: SSD1.19 123.49,20.39 123.76,20.12 124.38,20.12 124.48,20.22 124.48,20.39 124.56,20.47 124.93,20.47 v2(125.03,20.57) ; v2(96.21,63.15) 96.21,63.41 96.31,63.51 96.46,63.51 96.69,63.29 96.69,62.9 CPU1.BJ5
SSD_PCIE_RX_P3: length 70.1
  L3 w0.089: v2(97.1,63.08) 97,63.08 96.89,63.19 96.89,63.44 97.05,63.6 101.39,63.6 104.06,60.93 104.06,59.59 105.44,58.21 106.48,58.21 107.26,57.43 111.27,57.43 113.86,54.84 116.74,54.84 117.94,53.65 117.94,53.53 121.05,50.41 121.65,50.41 122.15,49.91 122.15,45.05 122.65,44.55 122.65,37.65 122.72,37.57 122.72,33.73 122.46,33.48 122.46,32.8 122.46,26.49 121.47,25.5 121.47,25.46 121.46,25.44 121.46,17.31 121.37,17.22 121.12,17.22 121.03,17.31 v2(121.03,17.64)
  BOTTOM w0.102: SSD1.7 121.77,17.39 121.66,17.28 121.66,17.16 121.61,17.12 121.27,17.12 121.21,17.18 120.85,17.18 120.76,17.26 120.76,17.54 120.87,17.64 v2(121.03,17.64) ; CPU1.BK5 97.58,62.87 97.58,63.14 97.47,63.24 97.35,63.24 97.35,63.24 97.2,63.24 97.1,63.14 v2(97.1,63.08)
SSD_PCIE_TX_CON_N1: length 3.1
  BOTTOM w0.102: C6312.1 125.22,24.47 123.57,24.47 123.49,24.39 SSD1.35
SSD_PCIE_TX_CON_N2: length 5.1
  BOTTOM w0.102: C6314.1 126.33,22.88 126.19,22.88 126.12,22.81 126.12,22.15 125.77,21.8 125.21,21.8 124.93,21.52 123.77,21.52 123.77,21.53 123.62,21.53 123.49,21.39 SSD1.23
SSD_PCIE_TX_CON_N3: length 6.3
  BOTTOM w0.102: SSD1.11 123.49,18.39 123.64,18.54 124.65,18.54 125,18.89 125.29,18.89 125.93,19.52 125.93,21.04 126.17,21.29 126.43,21.29 C6316.1
SSD_PCIE_TX_CON_P1: length 3.1
  BOTTOM w0.102: SSD1.37 123.49,24.89 123.68,24.7 125.24,24.7 C6311.1
SSD_PCIE_TX_CON_P2: length 5.1
  BOTTOM w0.102: SSD1.25 123.49,21.89 123.62,21.75 123.86,21.75 123.87,21.75 124.84,21.75 125.11,22.02 125.67,22.02 125.9,22.25 125.9,22.91 126.1,23.11 126.32,23.11 C6313.1
SSD_PCIE_TX_CON_P3: length 6.3
  BOTTOM w0.102: C6315.1 126.38,21.52 126.08,21.52 125.7,21.14 125.7,19.62 125.2,19.12 124.91,19.12 124.56,18.77 123.58,18.77 123.46,18.89 SSD1.13
SSD_PCIE_TX_N1: length 98.4
  L3 w0.089: v2(94.48,70.21) 94.63,70.21 96.7,72.28 112.08,72.28 112.2,72.4 113.4,72.4 114.71,71.09 120.35,71.09 123.29,68.15 124.02,68.15 128.82,63.34 129.36,63.34 131.26,61.44 131.26,58.25 131.98,57.53 131.98,49.6 133.11,48.47 133.11,46.26 134.18,45.19 134.18,44.46 134.17,44.45 134.17,40.05 133.72,39.6 133.72,38.39 133.61,38.28 133.61,25.08 133.28,24.76 133.28,24.46 v2(132.68,23.86)
  BOTTOM w0.083: 97.1,66.64 97.12,66.62 97.16,66.62 97.2,66.56 97.66,65.93 97.7,65.79 97.7,65.4 97.73,65.27 97.73,65.13 97.71,65.04 97.7,65.02 97.7,64.73 97.75,64.61 97.75,64.58 97.89,64.09 CPU1.BL4
  BOTTOM w0.102: 97.1,66.64 96.25,67.5 96.25,68.36 95.8,68.81 95.8,70.22 95.6,70.41 94.68,70.41 v2(94.48,70.21) ; v2(132.68,23.86) 132.91,24.1 132.91,24.1 132.91,24.43 132.73,24.62 132.08,24.62 131.72,24.25 129.55,24.25 129.36,24.06 127.4,24.06 127,24.46 126.68,24.46 C6312.2
SSD_PCIE_TX_N2: length 88.7
  L3 w0.089: v2(131.02,23.82) 131.02,24.86 131.96,25.81 131.96,26.58 131.29,27.25 131.29,29.98 131.87,30.55 131.87,33.04 132.44,33.62 132.44,39.61 133.27,40.44 133.27,43.53 131.61,45.19 131.61,48.42 131.04,48.99 131.04,56.34 129.66,57.73 129.66,58.25 128.82,59.09 128.82,59.46 127.42,60.86 127.42,63.42 123.64,67.21 122.92,67.21 119.93,70.19 114.37,70.19 113.35,69.17 108.32,69.17 106.25,71.24 98.86,71.24 98.35,70.73 98.35,69.64 97.88,69.17 v2(96.92,69.17)
  BOTTOM w0.076: 97.66,66.91 97.66,66.88 97.67,66.87 97.67,66.77 98.11,66.17 98.15,66.05 98.29,65.91 98.29,65.79 98.4,65.68 98.4,65.37 98.13,65.1 CPU1.BL2
  BOTTOM w0.102: v2(96.92,69.17) 97.4,68.76 97.66,68.5 97.66,66.91 ; C6314.2 128.56,22.62 129.09,23.14 130.51,23.14 130.75,23.38 v2(131.02,23.82)
SSD_PCIE_TX_N3: length 94.2
  L3 w0.089: v2(96.87,70.19) 97.15,70.19 97.24,70.28 97.24,70.56 97.36,70.68 97.72,70.68 98.8,71.75 109.68,71.75 110.89,70.55 120.13,70.55 123.07,67.61 123.79,67.61 128.6,62.8 129.13,62.8 130.71,61.22 130.71,57.26 130.72,57.25 130.72,57.17 131.4,56.49 131.4,49.14 131.97,48.57 131.97,45.33 133.62,43.68 133.62,40.28 132.8,39.46 132.8,33.47 132.33,33 132.33,27.52 132.92,26.93 132.92,25.25 132.06,24.4 132.06,23.59 132.36,23.3 132.36,23.05 v2(132,22.7)
  BOTTOM w0.076: 98.1,66.92 98.1,66.91 98.15,66.86 98.15,66.85 98.23,66.77 98.23,66.46 98.24,66.46 98.24,66.33 98.61,65.97 98.61,65.33 98.43,65.15 98.43,64.58 98.43,64.58 98.43,64.34 98.69,64.07 CPU1.BM4
  BOTTOM w0.102: C6316.2 127.85,21.32 128.41,21.32 128.99,21.9 130.8,21.9 131.49,22.58 131.49,23.01 131.62,23.14 132.12,23.14 132.21,23.05 132.21,22.91 v2(132,22.7) ; 98.1,66.92 98.1,68.6 97.88,68.81 97.88,70.08 97.6,70.37 97.05,70.37 v2(96.87,70.19)
SSD_PCIE_TX_P1: length 98.4
  L3 w0.089: v2(94.45,70.85) 94.99,70.85 96.62,72.47 112,72.47 112.12,72.59 113.48,72.59 114.79,71.28 120.43,71.28 123.37,68.34 124.1,68.34 128.9,63.53 129.44,63.53 131.45,61.52 131.45,58.33 132.17,57.61 132.17,49.68 133.3,48.54 133.3,46.34 134.37,45.27 134.37,44.38 134.36,44.37 134.36,39.97 133.91,39.52 133.91,38.31 133.8,38.2 133.8,25 133.47,24.68 v2(133.47,23.86)
  BOTTOM w0.083: 97.27,66.8 97.33,66.73 97.33,66.67 97.34,66.65 97.81,66.01 97.87,65.82 97.87,65.42 97.9,65.34 97.9,65.06 97.87,64.96 97.87,64.95 97.87,64.77 97.91,64.69 97.92,64.68 CPU1.BL3
  BOTTOM w0.102: 97.27,66.8 96.48,67.59 96.48,68.45 96.02,68.91 96.02,70.31 95.69,70.64 94.65,70.64 v2(94.45,70.85) ; v2(133.47,23.86) 133.14,24.19 133.14,24.53 132.82,24.85 131.99,24.85 131.62,24.48 129.45,24.48 129.26,24.29 127.5,24.29 127.09,24.69 126.68,24.69 C6311.2
SSD_PCIE_TX_P2: length 88.7
  L3 w0.089: v2(96.93,68.53) 97.26,68.2 97.43,68.2 97.52,68.29 97.52,68.89 97.61,68.98 97.96,68.98 98.54,69.56 98.54,70.66 98.94,71.05 106.17,71.05 108.24,68.98 113.43,68.98 114.45,70 119.85,70 122.84,67.02 123.56,67.02 127.23,63.35 127.23,60.78 128.63,59.38 128.63,59.01 129.47,58.17 129.47,57.65 130.85,56.27 130.85,48.91 131.42,48.34 131.42,45.11 133.08,43.45 133.08,40.52 132.25,39.69 132.25,33.7 131.68,33.12 131.68,30.63 131.1,30.06 131.1,27.17 131.77,26.5 131.77,25.89 130.83,24.94 130.83,24.43 130.74,24.34 130.19,24.34 130.1,24.25 130.1,24.06 v2(130.35,23.82)
  BOTTOM w0.076: CPU1.BL1 98.13,65.71 98.13,65.72 98.13,65.84 98.01,65.96 97.97,66.09 97.5,66.72 97.5,66.8 97.46,66.85 97.46,66.88 97.43,66.91
  BOTTOM w0.102: v2(96.93,68.53) 97.04,68.64 97.18,68.64 97.24,68.59 97.43,68.4 97.43,66.91 ; C6313.2 127.78,23.38 127.88,23.28 127.88,22.95 127.99,22.85 128.47,22.85 128.99,23.37 130.42,23.37 130.53,23.49 130.53,23.63 v2(130.35,23.82)
SSD_PCIE_TX_P3: length 94.3
  L3 w0.089: v2(132.79,22.7) 132.55,22.94 132.55,23.37 132.26,23.67 132.26,24.32 133.11,25.18 133.11,27.01 132.52,27.6 132.52,32.92 132.99,33.4 132.99,39.38 133.81,40.2 133.81,43.76 132.16,45.41 132.16,48.65 131.59,49.22 131.59,56.57 130.91,57.25 130.91,57.33 130.9,57.34 130.9,61.3 129.21,62.99 128.68,62.99 123.87,67.8 123.15,67.8 120.2,70.74 110.97,70.74 109.76,71.94 98.72,71.94 97.65,70.87 v2(96.87,70.87)
  BOTTOM w0.076: 98.33,66.92 98.4,66.85 98.4,66.53 98.41,66.52 98.41,66.4 98.77,66.04 98.77,65.26 98.59,65.08 98.59,64.65 CPU1.BM3
  BOTTOM w0.102: v2(132.79,22.7) 132.44,23.05 132.44,23.15 132.21,23.37 131.52,23.37 131.26,23.11 131.26,22.68 130.71,22.13 128.9,22.13 128.31,21.54 127.85,21.54 C6315.2 ; 98.33,66.92 98.33,68.69 98.11,68.91 98.11,70.18 97.7,70.59 97.14,70.59 v2(96.87,70.87)
SSD_SATA_RX_N: length 67.4
  L3 w0.089: v2(120.71,26.56) 121.05,26.56 121.92,27.42 121.92,27.8 121.83,27.89 121.51,27.89 121.31,28.09 121.31,28.54 121.51,28.74 121.83,28.74 121.92,28.83 121.92,32.95 121.92,33.7 122.17,33.96 122.17,37.35 122.1,37.42 122.1,44.33 121.61,44.82 121.61,47.83 121.25,48.19 120.36,48.19 120.1,48.44 120.1,50.59 119.03,51.66 118.25,51.66 116.95,52.96 116.82,52.96 116.22,52.35 115.94,52.35 115.7,52.59 115.7,52.88 116.3,53.48 116.3,53.6 115.85,54.06 113.58,54.06 113.12,53.59 112.61,53.59 111.18,55.02 111.18,55.3 111.71,55.83 111.71,55.95 111.58,56.08 111.45,56.08 110.93,55.55 109.82,55.55 109.59,55.78 109.59,56.25 109.46,56.38 107.47,56.38 106.2,57.65 105.29,57.65 103.76,59.19 101.39,59.19 100.83,59.75 100.41,59.75 100.32,59.66 100.32,59.38 100.12,59.18 99.78,59.18 99.58,59.38 99.58,59.66 99.49,59.75 98.52,59.75 98.21,60.05 98.21,60.42 98.1,60.53 95.07,60.53 94.66,60.94 94.66,61.38 93.86,62.18 93.86,62.62 94.07,62.83 94.07,62.84 v2(94.3,63.07)
  BOTTOM w0.102: v2(120.71,26.56) 121.07,26.19 121.44,26.19 121.64,26.39 SSD1.43 ; CPU1.BE5 94.52,63.07 v2(94.3,63.07)
SSD_SATA_RX_P: length 67.4
  L3 w0.089: v2(120.71,25.77) 121.04,25.77 121.13,25.86 121.13,26.37 122.11,27.34 122.11,27.88 121.91,28.08 121.59,28.08 121.5,28.17 121.5,28.46 121.59,28.55 121.91,28.55 122.11,28.75 122.11,32.87 122.11,32.87 122.11,33.63 122.37,33.88 122.37,37.43 122.29,37.5 122.29,44.41 121.8,44.9 121.8,44.9 121.8,47.91 121.33,48.38 120.44,48.38 120.29,48.52 120.29,50.67 119.11,51.85 118.33,51.85 117.03,53.15 116.74,53.15 116.14,52.55 116.02,52.55 115.89,52.67 115.89,52.8 116.49,53.4 116.49,53.68 115.93,54.25 113.5,54.25 113.04,53.78 112.69,53.78 111.37,55.1 111.37,55.22 111.9,55.75 111.9,56.03 111.66,56.27 111.38,56.27 110.85,55.75 109.9,55.75 109.78,55.86 109.78,56.33 109.54,56.57 107.55,56.57 106.28,57.84 105.37,57.84 103.83,59.38 101.47,59.38 100.91,59.94 100.33,59.94 100.13,59.74 100.13,59.46 100.04,59.37 99.86,59.37 99.77,59.46 99.77,59.74 99.57,59.94 98.6,59.94 98.4,60.13 98.4,60.5 98.18,60.72 95.15,60.72 94.85,61.02 94.85,61.45 94.14,62.17 94.14,62.29 v2(94.29,62.44)
  BOTTOM w0.102: CPU1.BE6 94.51,62.44 v2(94.29,62.44) ; v2(120.71,25.77) 120.91,25.96 121.63,25.96 121.7,25.89 SSD1.41
SSD_SATA_TX_CON_N: length 3.6
  BOTTOM w0.102: C6303.1 125.63,27.37 124.44,27.37 124.29,27.53 123.62,27.53 123.49,27.39 SSD1.47
SSD_SATA_TX_CON_P: length 3.6
  BOTTOM w0.102: SSD1.49 123.49,27.89 123.62,27.75 124.38,27.75 124.54,27.6 125.67,27.6 C6302.1
SSD_SATA_TX_N: length 76.7
  L3 w0.089: v2(127.69,27.07) 128.18,27.31 128.38,27.51 128.38,35.7 129.43,36.75 129.43,47.52 128.86,48.09 128.86,50.64 128.42,51.07 127.79,51.07 127.49,51.37 127.49,54.53 120.72,61.31 118.32,61.31 114.08,65.55 98.52,65.55 96.25,67.82 96.25,68.13 95.3,69.08 v2(94.39,69.08)
  BOTTOM w0.076: 95.85,68.15 95.85,67.33 97.24,65.93 97.24,65.38 97.22,65.27 97.22,65.14 97.23,64.96 97.23,64.76 97.23,64.73 97.05,64.09 CPU1.BJ4
  BOTTOM w0.102: v2(127.69,27.07) 127.68,27.09 C6303.2 ; v2(94.39,69.08) 94.57,68.9 95.1,68.9 95.85,68.15
SSD_SATA_TX_P: length 76.7
  L3 w0.089: v2(127.69,27.86) 127.69,27.59 127.78,27.5 128.1,27.5 128.19,27.59 128.19,35.78 128.51,36.1 129.24,36.83 129.24,47.44 128.67,48.01 128.67,50.56 128.34,50.88 127.71,50.88 127.3,51.29 127.3,54.45 120.64,61.12 118.24,61.12 114,65.36 98.44,65.36 96.06,67.74 96.06,68.05 95.23,68.89 94.96,68.89 94.87,68.8 94.87,68.11 94.79,68.02 94.6,68.02 v2(94.38,68.24)
  BOTTOM w0.076: CPU1.BJ3 97.07,64.77 97.07,64.95 97.05,65.12 97.05,65.36 97.07,65.42 97.07,65.86 95.68,67.26 95.68,68 95.67,68.01
  BOTTOM w0.102: C6302.2 127.06,27.85 127.3,27.61 127.44,27.61 v2(127.69,27.86) ; 95.67,68.01 95.01,68.67 94.48,68.67 94.38,68.58 v2(94.38,68.24)
SSD_SCP#: length 198.3
  TOP w0.102: R6606.1 189.55,3.84 188.07,3.84 v2(187.46,3.23) ; R6314.1 117.63,16.65 v2(117.39,16.41) ; v2(26.03,15.27) 25.43,15.86 25.43,18.41 24.71,19.13 24.32,19.13 22.69,20.76 22.69,22.68 v1(23.64,23.62) 24.2,23.06 R2449.2 25.08,23.71 v2(25.08,23.8)
  L3 w0.102: v2(187.46,3.23) 166.53,3.23 165.74,2.45 162.57,2.45 162.02,3 159.07,3 158.42,2.35 155.72,2.35 155.43,2.07 150.44,2.07 150.15,2.35 147.78,2.35 147.01,3.12 143.64,3.12 142.7,4.05 138.72,4.05 137.82,3.15 135.77,3.15 135.36,2.74 132.74,2.74 132.57,2.56 130.01,2.56 129.83,2.74 122.55,2.74 120.98,4.3 120.39,4.3 120.14,4.55 120.14,5.14 119.79,5.49 119.79,5.5 118.13,7.16 118.13,14.59 118.24,14.87 118.28,15.05 118.28,15.23 118.24,15.41 118.21,15.5 118.21,15.6 117.43,16.38 v2(117.39,16.41) 116.52,16.41 114.98,14.86 101.94,14.86 101.2,14.13 96.13,14.13 95.66,14.6 89.62,14.6 89.28,14.93 72.61,14.93 72.36,15.19 42.71,15.19 42.68,15.23 39.57,15.23 38.91,14.56 37.77,14.56 36.57,13.36 34.76,13.36 34.55,13.57 33.55,13.57 33.12,13.14 30.17,13.14 28.05,15.27 v2(26.03,15.27)
  BOTTOM w0.102: U2401.21 26.57,26.71 25.08,25.23 v2(25.08,23.8)
SSD_SCP#_1: length 9.3
  TOP w0.102: v2(115.82,14.72) v1(115.82,15.41) 115.82,15.64 116.77,16.59 R6314.2
  BOTTOM w0.102: v2(115.82,14.72) 115.85,14.72 115.74,14.84 114.69,14.84 113.07,16.46 113.07,17.33 113.5,17.76 114.18,17.76 114.31,17.64 SSD1.8
SSD_SCP#_2: length 11.3
  TOP w0.102: v2(196.87,8.18) 195.31,8.18 194.07,6.94 194.07,5.64 193.46,5.03 193.46,3.97 192.57,3.08 191.36,3.08 v1(191.22,3.23) 190.61,3.83 R6606.2
  BOTTOM w0.102: IO2.8 196.35,7.7 196.84,8.18 v2(196.87,8.18)
SSEQ0_A0: length 3.5
  TOP w0.102: U7101.11 v1(23.06,34.58) 23.3,34.58 23.58,34.3 R7146.1 24.09,33.82 24.3,33.6 R7145.2
SSEQ1: length 4.5
  TOP w0.102: R7152.2 18.86,31.14 18.86,31.78 v2(19.28,32.2) 19.37,32.29 U7101.3
  BOTTOM w0.102: v2(19.28,32.2) 19.82,31.65 v1(19.83,31.65) 20.02,31.85 R7144.1
ST_GND: length 2.2
  TOP w0.127: U9101.2 187.42,27.66 v1(187.99,28.23) 188.54,27.67 188.72,27.67 R9131.1
ST_PP: length 2.8
  TOP w0.127: U9101.7 188.09,30.16 188.28,30.36 189.61,30.36 TP9105.1
STRAP0: length 11.8
  BOTTOM w0.102: R7919.2 144.74,51.72 R7908.1 145.03,50.65 151.61,50.65 v1(151.84,50.42) 152.17,50.09 155.05,50.09 GPU1.D1
STRAP1: length 16
  BOTTOM w0.102: GPU1.D2 155.85,50.43 155.31,49.89 151.37,49.89 150.82,50.45 v1(142.85,50.45) 142.01,50.45 R7911.1 141.76,50.17 R7909.2
STRAP2: length 20.4
  BOTTOM w0.102: R7914.2 142.15,47.99 143.52,47.99 R7915.1 144.6,47.99 150.13,47.99 150.4,48.26 v1(152.24,48.26) 156.08,48.26 157.33,49.51 157.33,49.91 156.62,50.62 156.62,51.04 156.74,51.16 156.74,51.63 156.38,52 GPU1.E4
STRAP3: length 16.6
  BOTTOM w0.102: R7926.1 141.54,53.01 R7925.2 142.15,52.38 145.61,52.38 v1(145.67,52.32) 145.77,52.32 146.86,51.23 146.86,51.21 146.96,51.11 152.14,51.11 152.52,50.73 153.96,50.73 155.29,52.06 GPU1.E3
STRAP4: length 16.9
  BOTTOM w0.102: GPU1.D3 155.89,51.46 154.95,50.53 152.39,50.53 152.01,50.91 146.55,50.91 v1(146.29,51.17) 145.28,52.18 142.48,52.18 R7929.1 141.54,51.7 R7928.2
STRAP5: length 15.8
  BOTTOM w0.102: GPU1.C1 155.59,49.51 v1(152.72,49.51) 151.34,49.51 150.61,50.25 144.42,50.25 R7939.1 143.65,49.65 143.26,50.04 142.4,50.04 R7938.2
STRAP_REF0_GND_N9: length 4.7
  TOP w0.102: R7907.1 156.84,56.59 157.5,55.92 157.78,55.92 v1(158.18,55.53) 157.06,54.41 v2(156.38,54.41)
  BOTTOM w0.102: GPU1.F6 156.38,54.43 v2(156.38,54.41)
SUS_CLK: length 238.4
  TOP w0.089: v2(165,28.43) 165,27.81 R6117.1 ; v2(14.8,27.11) 14.8,27.22 v1(14.42,27.6)
  L3 w0.076: v2(114.67,40.49) 114.67,39.79 117.23,37.22 117.23,36.9 118.51,35.62 118.51,34.6 117.64,33.74 117.64,32.56 117.17,32.1 117.17,31.75 117.58,31.35 117.58,26.05 118.12,25.51 118.12,22.61 117.56,22.05 117.56,21.01 117.48,20.93 117.48,18.1 114.77,15.39 101.72,15.39 100.99,14.65 96.34,14.65 95.88,15.12 89.84,15.12 89.5,15.45 72.83,15.45 72.58,15.71 42.93,15.71 42.89,15.75 38.89,15.75 38.5,15.35 28.41,15.35 28.08,15.69 25.86,15.69 25.61,15.44 25.61,15.38 22.53,12.3 21.91,12.3 20.19,10.57 19.84,10.57 18.36,12.05 15.75,12.05 13.03,9.33 13.03,8.58 12.92,8.47 v2(12.91,8.47)
  L6 w0.089: v2(101.56,46.15) 101.94,45.77 104.37,45.77 104.41,45.82 104.87,45.82 105.37,45.32 105.37,44.63 105.89,44.11 111.46,44.11 113.24,42.33 114.32,42.33 114.32,42.33 114.72,41.93 114.72,40.97 114.67,40.92 v2(114.67,40.49) 114.98,40.8 116.31,40.8 117.15,39.96 122.95,39.96 123.72,39.19 127.3,39.19 130.64,35.85 130.64,35.01 134.75,30.91 137.47,30.91 140.35,28.02 140.35,27.98 142.55,25.78 152.7,25.78 153.52,26.6 153.63,26.6 154.05,27.02 154.05,27.14 154.52,27.61 161.77,27.61 162.07,27.31 163.88,27.31 v2(165,28.43)
  L8 w0.076: v2(12.91,8.47) 12.92,8.47 13.03,8.58 13.03,11.28 11.28,13.03 11.28,17.46 10.77,17.96 10.77,20.37 10.82,20.42 10.82,20.76 10.77,20.81 10.77,25.5 11.02,25.74 11.02,26.47 11.72,27.17 14.73,27.17 v2(14.79,27.11)
  BOTTOM w0.089: CPU1.BT32 101.3,45.89 v2(101.56,46.15) ; R2461.2 15.23,26.44 14.8,26.87 v2(14.8,27.11)
SUSACK#_R: length 17.7
  TOP w0.102: v1(115.8,35.53) 115.4,35.92 R1708.1 114.91,36 112.47,38.44 112.04,38.44 110.01,40.46 108.75,40.46 108.28,40.93 108.28,41.62 106.33,43.57 105.77,43.57 104.15,45.2 104.15,46.13 v2(104.23,46.2)
  BOTTOM w0.102: CPU1.BY32 103.92,45.89 v2(104.23,46.2)
SUSCLK_WLAN: length 20.2
  TOP w0.089: v2(169.66,16.17) 169.91,15.93 170.62,15.93 170.84,16.14 170.84,16.43 169.94,17.33 169.57,17.33 169.22,17.68 169.22,17.91 168.96,18.17 168.5,18.17 167.46,19.21 167.46,21.96 v1(167.04,22.38) 165.63,23.8 165.63,24.19 164.93,24.88 164.93,26.78 R6117.2
  BOTTOM w0.089: WLAN1.50 169.22,19.05 169.5,18.77 169.5,18.11 169.31,17.92 169.31,16.28 169.42,16.17 v2(169.66,16.17)
SVID_ALERT#_CPU: length 22.3
  TOP w0.089: v1(48.24,71.12) 47.79,70.67 v2(47.79,70.62) 47.61,70.44 PR4605.2
  L8 w0.076: v2(64.63,71.28) 64.21,71.28 64.19,71.3 61.09,71.3 60.83,71.56 52.9,71.56 52.37,72.08 49.26,72.08 v2(47.79,70.62)
  BOTTOM w0.089: v2(47.79,70.62) 47.64,70.46 PR4623.1 ; R727.2 65.32,70.58 v2(64.63,71.28) 64.04,70.68 R728.2
SVID_ALERT#_CPU_R: length 21.2
  BOTTOM w0.076: 79.62,66.05 79.62,66.05 79.96,65.71 79.98,65.64 79.98,65.4 79.96,65.35 79.83,65.23 79.68,65.23 79.48,65.02 79.48,64.58 79.73,64.33 CPU1.AA3
  BOTTOM w0.089: 79.62,66.05 79.5,66.18 79.5,66.51 78.41,67.6 78.41,67.9 77.03,69.28 77.03,69.75 v1(76.91,69.87) 76.07,70.71 69.45,70.71 68.29,71.87 64.55,71.87 64.23,71.55 R728.1
SVID_CLK_CPU: length 24.3
  TOP w0.089: v2(48.43,70.54) 48.4,70.52 PR4606.2
  L8 w0.076: v2(48.43,70.54) 48.43,70.58 49.47,71.63 52.18,71.63 52.71,71.1 60.59,71.1 60.85,70.84 64,70.84 64.02,70.82 64.94,70.82 v2(65.37,71.25)
  BOTTOM w0.089: PR4624.1 v2(48.43,70.54) ; R732.2 69.21,70.15 68.2,71.16 R723.2 67.88,71.49 v1(66.59,71.49) 66.46,71.62 65.56,71.62 65.37,71.43 v2(65.37,71.25)
SVID_CLK_CPU_R: length 12
  BOTTOM w0.089: CPU1.AA1 79.73,65.62 79.23,66.12 79.23,66.41 77.58,68.07 77.58,68.19 76.68,69.09 76.68,69.6 75.89,70.39 v1(75.56,70.39) 70.65,70.39 R732.1
SVID_DATA_CPU: length 18.3
  TOP w0.089: PR4604.2 46.8,70.26 v2(47.16,70.62) v1(46.66,71.11)
  L8 w0.076: v2(47.16,70.62) 47.16,71.04 48.66,72.54 52.6,72.54 53.12,72.02 59.46,72.02 v2(59.75,72.32)
  BOTTOM w0.089: R709.2 60.5,71.57 v2(59.75,72.32) ; v2(47.16,70.62) 46.85,70.31 PR4622.1
SVID_DATA_CPU_R: length 22.7
  BOTTOM w0.076: CPU1.AA2 79.83,64.87 80.01,65.05 80.03,65.09 80.04,65.13 80.15,65.37 80.15,65.67 80.1,65.8 79.79,66.11 79.79,66.44 79.67,66.57
  BOTTOM w0.089: 79.67,66.57 79.67,67.31 78.74,68.24 v1(78.74,68.3) 77.62,69.42 77.62,69.62 76.32,70.92 69.61,70.92 68.33,72.21 64.54,72.21 64.27,71.94 63.66,71.94 63.42,71.7 R726.2 62.34,71.7 R709.1
SYS_LED_MASK#: length 6.7
  BOTTOM w0.127: C2436.1 36.49,15.29 R2457.1 v1(35.43,15.22) 35.17,15.22 34.69,15.7 R2410.1 34.71,16.16 PR2455.2 33.61,16.92 33.06,17.47 U2401.55
SYS_LED_MASK#_R: length 100.2
  TOP w0.127: v2(12.02,69.53) 10.6,70.95 9.44,70.95 8.94,70.45 U6402.2 ; v3(13.65,20.16) 14.68,20.16 v1(15.32,19.52)
  L3 w0.127: v3(13.65,20.16) 13.15,20.16 10.13,23.18 10.13,26.24 11.51,27.62 11.51,28.43 13.77,30.69 13.77,32.58 13.77,32.58 13.77,33.71 14.42,34.36 14.42,39.54 13.08,40.87 12.16,40.87 10.59,42.45 10.59,49.19 11.99,50.59 12.53,50.59 13.26,51.33 13.26,52.37 12.84,52.79 12.84,65.1 13.26,65.52 13.26,68.29 v2(12.02,69.53)
  L8 w0.127: v2(38.03,16.57) 36.65,17.94 36.24,17.94 36.24,17.95 33.12,17.95 31.01,15.84 30.33,15.84 28.53,17.65 23.57,17.65 22.76,18.46 22.53,18.46 21.66,19.33 21.66,19.85 21.4,20.11 21.03,20.11 20.77,19.85 20.77,19.18 21.72,18.23 21.72,17.8 21.46,17.54 17.3,17.54 14.68,20.16 v3(13.65,20.16)
  BOTTOM w0.127: R2410.2 36.02,16.6 36.88,16.6 R2456.2 37.61,16.99 v2(38.03,16.57) ; R6419.1 v2(12.02,69.53)
SYS_PEX_RST_MON#: length 21.2
  L3 w0.102: v2(147.55,64.39) 146.9,64.39 137.88,73.41 v2(137.88,74.83)
  BOTTOM w0.102: R7604.2 137.63,76.07 v1(137.68,76.03) 137.88,75.82 v2(137.88,74.83) 136.44,74.83 R7606.1 135.6,73.98 U7601.4 ; v2(147.55,64.39) 147.51,64.39 147.57,64.46 GPU1.AC7
SYS_PWROK: length 179
  L5 w0.127: v2(132.25,58.87) 131.93,58.56 131.77,58.56 130.8,57.59 130.8,56.08 131.09,55.79 131.09,49.81 130.9,49.62 130.9,46.93 131.09,46.75 131.09,44.44 130.05,43.41 130.05,41.18 123.8,34.94 123.8,30.57 123.22,29.99 123.22,23.4 122.06,22.23 122.06,21.48 121.52,20.94 121.52,17.32 121.39,17.19 120.3,17.19 119.35,18.14 117.42,18.14 114.89,15.61 113.52,15.61 112.95,16.18 103.13,16.18 102.47,15.52 98.1,15.52 97.2,14.63 96.74,14.63 95.14,16.23 91.15,16.23 90.02,17.35 54.15,17.35 53.91,17.12 47.5,17.12 46.06,18.56 42.93,18.56 42.73,18.56 42.33,18.95 42.33,19.36 40.28,21.41 37.58,21.41 33.93,25.06 33.79,25.06 31.96,26.9 v2(31.96,28.88)
  BOTTOM w0.127: U2401.28 29.37,28.53 29.58,28.74 29.58,28.84 29.99,29.25 30.36,29.25 30.62,28.99 30.62,28.97 30.83,28.77 30.86,28.77 31.05,28.57 31.64,28.57 v2(31.96,28.88) ; CPU1.CR10 112.53,59.97 113.63,59.97 113.64,59.95 115.06,59.95 115.07,59.97 115.17,59.97 116.78,61.58 116.92,61.58 117.02,61.68 119.36,61.68 119.46,61.58 123.25,61.58 123.83,61 126.2,61 126.2,61 127.1,61 127.1,61 128.67,61 129.29,60.37 131.33,60.37 v1(131.68,60.02) 132.25,59.45 v2(132.25,58.87) 131.67,58.29 ED1701.1 130.79,57.92 128.93,57.92 128.67,58.18 128.06,58.18 127.8,57.92 127.8,56.77 127.52,56.49 R1717.2
SYSPWR_PRES: length 4.2
  TOP w0.102: v1(17.81,22.92) 17.89,23 18.73,23 v2(18.8,22.93) 19.4,22.93 R2463.2 19.41,22.15 R2454.1
  BOTTOM w0.102: U2401.120 18.32,23.07 18.46,22.93 v2(18.8,22.93)
T_CRIT#: length 7.2
  TOP w0.102: R2601.1 126.75,41.54 127.32,42.11 v2(127.32,42.32)
  BOTTOM w0.102: v2(127.32,42.32) 128.26,41.38 U2601.4 128.7,39.75 129.49,38.96 v1(129.49,38.32) 129.49,37.38 R2604.2
TABLE_MODE#: length 118.3
  TOP w0.102: R2027.2 113.28,32.71 v2(113.52,32.95) ; v1(23.07,19.35) 23.41,19.01 v2(23.67,19.01)
  L3 w0.102: v2(23.67,19.01) 24.01,18.66 26.38,18.66 26.38,18.67 26.74,18.67 26.74,18.66 28.2,18.66 29.12,19.59 33.3,19.59 33.89,19 36.21,19 36.43,19.23 v2(43.01,19.23)
  L5 w0.102: v2(43.01,19.23) 43.54,19.77 45.48,19.77 47.68,17.57 53.69,17.57 53.92,17.8 90.54,17.8 91.32,17.01 102.09,17.01 102.34,17.27 113.33,17.27 113.83,17.76 114.69,17.76 115.23,18.3 115.23,31.23 v2(113.52,32.95)
  BOTTOM w0.102: v2(23.67,19.01) 23.4,18.74 23.4,16.23 23.14,15.96 23.14,13.53 22.97,13.36 U2401.85
TBTA_SENSEN: length 2.5
  BOTTOM w0.102: R7217.2 24.06,66.7 v1(24.06,65.97) 24.06,65.95 24.58,65.44 U7201.A10
TBTA_SENSEP: length 3
  BOTTOM w0.102: R7216.2 24.48,66.46 24.48,65.86 24.8,65.53 24.8,64.86 24.85,64.81 24.85,64.42 U7201.B10
TESTMODE: length 11.6
  BOTTOM w0.102: GPU1.AD9 148.19,67.38 147.86,67.71 147.86,68.18 147.96,68.28 147.96,68.72 147.66,69.02 147.66,73.56 145.91,75.32 v1(145.02,75.32) 144.3,75.32 R7602.1
THERM_SYS_SHDN#: length 2.3
  TOP w0.102: v1(125.73,42.13) 126.01,42.41 R2601.2 126.8,42.41 127.56,43.17 Q2602.S
THERMTRIP#_CPU: length 15.5
  TOP w0.102: v2(95.23,67.25) 94.91,67.57 94.91,72.47 94.96,72.52 94.96,72.93 v2(94.53,73.36) 94.53,73.96 v1(94.6,74.03)
  BOTTOM w0.102: v2(94.53,73.36) 96.25,73.36 96.64,73.75 96.64,74.48 96.63,74.49 96.63,75.16 96.76,75.29 R308.2 97.14,75.86 97.04,75.97 ED301.1 ; CPU1.BJ1 96.81,65.78 95.34,67.25 v2(95.23,67.25)
TOUCH_DETECT: length 127.7
  TOP w0.102: v1(48.25,76.71) 48.25,77.26 v2(48.31,77.32) 48.31,77.61 47.99,77.93 47.57,77.93 47.36,78.14 R5504.2
  L3 w0.102: v2(119.09,88.19) 119.78,87.51 127.41,87.51 131.83,83.09 131.83,81.99 128.25,78.41 v2(127.05,78.41)
  L6 w0.102: v2(48.19,80.36) 48.56,79.99 50.36,79.99 51.09,80.73 51.09,81.18 51.37,81.46 57.65,81.46 59.76,83.58 59.76,84.03 v2(59.77,84.03)
  L8 w0.102: v2(127.05,78.41) 128.25,77.21 128.25,63.34 127.55,62.63 127.55,60.88 127.53,60.86 127.53,60.81 126.66,59.95 126.66,59.93 126.65,59.93 v2(126.65,59.92)
  BOTTOM w0.102: R2102.1 126.36,59.62 126.66,59.92 126.66,59.93 126.65,59.93 v2(126.65,59.92) ; v2(59.77,84.03) 59.76,84.03 59.76,84.04 59.36,84.04 59,84.4 59,86.31 61.64,88.95 63.43,88.95 63.57,88.81 71.97,88.81 72.33,89.17 118.12,89.17 v2(119.09,88.19) ; ED5502.2 48.23,76.81 48.31,76.88 v2(48.31,77.32) 48.3,77.32 48.3,77.66 48.38,77.74 48.38,78.31 48.4,78.32 LCD1.25 48.4,80.06 48.19,80.27 v2(48.19,80.36)
TOUCH_DETECT_R: length 15.6
  BOTTOM w0.076: CPU1.CN14 111.49,57.3 111.6,57.2 arc(111.66,57.15) 111.74,57.13 111.9,57.13 arc(111.94,57.13) 111.98,57.15 arc(112.04,57.18) 112.1,57.19 112.17,57.19 arc(112.24,57.18) 112.31,57.15 arc(112.4,57.12) 112.49,57.1 112.92,57.1 113.07,57.26 113.99,57.26 114.11,57.14
  BOTTOM w0.102: R2102.2 124.71,59.62 124.63,59.7 v1(124.17,59.7) 123.78,60.09 123.28,60.09 120.74,57.56 116.65,57.56 116.57,57.48 115.56,57.48 115.21,57.12 114.62,57.12 114.11,57.14
TOUCH_PANEL_INTR#: length 79.3
  TOP w0.127: v1(50.07,77.92) 50.07,77.71 v2(50.43,77.35)
  L5 w0.127: v2(113.97,63.97) 113.97,63.97 113.97,64.55 113.68,64.84 113.31,64.84 112.94,64.47 99.41,64.47 97.41,66.46 95.16,66.46 94.58,65.88 92.52,65.88 91.87,66.53 91.71,66.53 90.76,67.49 89.06,67.49 88.8,67.23 86.8,67.23 86.38,66.81 83.3,66.81 83.17,66.94 72.8,66.94 71.97,67.76 69.03,67.76 67.52,69.27 67.15,69.27 66.86,68.98 65.09,68.98 59.89,74.17 54.04,74.17 51.31,76.9 50.88,76.9 v2(50.43,77.35)
  BOTTOM w0.102: LCD1.27 49.2,78.53 49.39,78.34 49.39,78.22 50.06,77.55 50.23,77.55 v2(50.43,77.35)
  BOTTOM w0.127: ED5502.5 49.73,76.65 v2(50.43,77.35) ; v2(113.97,63.97) 113.97,63.97 113.97,64.51 113.67,64.81 113.31,64.81 112.57,64.07 112.24,64.07 112.11,63.94 111.37,63.94 CPU1.CN3
TOUCH_PANEL_PD#: length 146
  TOP w0.127: v2(48.97,77.35) 49.47,76.85 v1(49.47,76.68)
  L5 w0.127: v2(106.51,42.2) 105.15,42.2 104.37,42.98 102.46,42.98 100.21,45.23 100.21,46.12 99.49,46.84 99.49,48.6 99.25,48.84 99.25,49.03 98.99,49.29 98.8,49.29 98.51,49.58 72.78,49.58 72.2,50.15 71.26,50.15 71.05,49.94 70.46,49.94 70.19,49.67 65.34,49.67 63.26,47.6 57.94,47.6 53.18,42.83 v2(53.18,40.6)
  L6 w0.127: v2(41.65,34.24) 42.27,34.24 44.88,36.85 48.3,36.85 52.06,40.6 v2(53.18,40.6) ; v2(41.95,57.69) 41.93,57.69 42.16,57.91 42.16,59.19 41.8,59.55 41.8,68.93 40.66,70.07 40.66,74.75 42.26,76.36 48.53,76.36 48.97,76.8 v2(48.97,77.35)
  L8 w0.127: v2(41.65,34.24) 39.03,36.85 34.57,36.85 32,39.41 32,42.04 33.09,43.13 33.09,48.33 33.2,48.44 33.2,49.12 35.63,51.55 35.63,52.19 41.13,57.69 v2(41.95,57.69)
  BOTTOM w0.076: 106.49,42.61 106.33,42.78 106.33,43.05 106.22,43.25 106.22,43.88 CPU1.CC35
  BOTTOM w0.102: v2(48.97,77.35) 48.62,77.7 48.62,78.31 48.72,78.41 48.73,78.41 48.8,78.48 LCD1.26
  BOTTOM w0.127: 106.49,42.61 106.49,42.22 v2(106.51,42.2) ; ED5502.4 49.23,77.1 48.98,77.35 v2(48.97,77.35)
TOUCH_REPORT_SW: length 90.9
  L3 w0.102: v2(30.87,34.18) 30.48,34.18 30.27,34.39 30.27,38.5 29.96,38.81 29.96,38.82 29.93,38.85 29.93,40.92 29.77,41.07 29.77,43.61 30.84,44.67 30.84,51.43 v2(31.56,52.15)
  L5 w0.102: v2(41.39,57) 34.58,57 32.8,55.22 32.8,53.4 v2(31.56,52.15)
  L6 w0.102: v2(36.92,12.35) 34.3,12.35 31.61,15.04 31.61,25.36 30.68,26.29 30.68,28.92 30.56,29.03 30.56,33.88 v2(30.87,34.18) ; v2(41.39,57) 41.43,57.04 41.43,58.27 41.74,58.58 41.74,59.26 41.55,59.45 41.55,68.77 40.33,69.99 40.33,74.77 42.32,76.75 46.81,76.75 v2(47.42,77.36)
  BOTTOM w0.102: LCD1.24 48,78.49 48.18,78.31 48.18,77.83 48.08,77.73 47.79,77.73 v2(47.42,77.36) 47.72,77.05 47.72,76.7 47.73,76.7 ED5502.1 ; v2(36.92,12.35) 37.12,12.56 37.12,12.58 37.38,12.84 37.78,12.84 37.88,12.94 v1(37.88,12.95) 37.88,13.09 37.15,13.82 D2402.A
TP_65982D_RESET_N: length 1.8
  BOTTOM w0.127: TP7205.1 17.18,61.17 17.58,60.77 18.22,60.77 R7229.2
TP_WAKE_KBC#: length 155.8
  TOP w0.102: v2(114.03,16.69) 114.03,16.69 114.03,14.93 115.58,13.37 115.58,11.72 116.9,10.41 117.06,10.41 117.16,10.3 117.16,6.09 118.59,4.66 AFTP6536.1 120.5,4.66 v2(120.57,4.73) 120.54,4.73 119.61,5.66 R6511.2 ; R303.2 110.17,36.98 v2(110.17,37.23)
  L5 w0.102: v2(110.17,37.23) 110.74,37.23 115.43,32.54 115.43,18.1 v2(114.03,16.69) 114.03,16.69 113.66,17.07 102.42,17.07 102.17,16.81 91.15,16.81 90.36,17.59 54.05,17.59 53.81,17.36 47.6,17.36 46.16,18.8 42.83,18.8 42.58,19.05 42.58,20.38 43.22,21.02 43.22,21.38 42.08,22.52 42.08,25.56 40.1,27.54 35.33,27.54 v2(34.47,26.68)
  BOTTOM w0.076: CPU1.CB34 105.25,44.34 105.59,44 105.65,43.84 105.65,43.43 105.67,43.38 105.68,43.34 105.68,43.1 105.65,43.01 105.65,40.24 105.44,40.03
  BOTTOM w0.102: U2401.33 33.58,26.27 33.99,26.68 v2(34.47,26.68) ; v2(120.57,4.73) 120.63,4.73 120.76,4.87 126.17,4.87 127.1,5.8 TPAD1.4 127.1,7.82 v1(126.48,8.44) ; v2(110.17,37.23) 109.96,37.02 108.22,37.02 108.1,37.13 107.12,37.13 106.98,37.27 105.71,37.27 105.12,37.87 105.12,38.61 105.44,38.93 105.44,40.03
TPM_GPIO0: length 2.4
  TOP w0.127: U9101.29 184.84,25.76 R9121.1 184.09,25.48 v1(183.44,25.48)
TPM_GPIO1: length 1.1
  TOP w0.102: TP9102.1 185.34,25.38 U9101.30
TPM_GPIO3: length 1.7
  TOP w0.127: U9101.6 188.61,29.66 TP9103.1
TPM_GPIO4: length 2.1
  TOP w0.127: R9118.1 184.39,33.22 v1(184.39,32.4) 184.39,31.41 U9101.13
TPM_GPIO6_PP: length 2.6
  TOP w0.127: TP9104.1 189.5,28.66 U9101.4
TPM_ID: length 9.9
  BOTTOM w0.102: CPU1.CK25 110.11,50.27 110.27,50.11 111.49,50.11 111.52,50.14 111.7,50.31 111.7,50.5 111.92,50.72 113.57,50.72 114.37,51.52 v1(114.68,51.52) 114.89,51.52 115.64,50.77 117.44,50.77 117.66,50.55 R1911.1 R1910.2
TPM_SPI_IRQ#: length 92.5
  TOP w0.102: v2(162.99,30.53) 162.99,30.72 v1(163.33,31.05) ; R9124.2 177.72,32.6 177.71,32.6 177.35,32.6 177.34,32.6 177.31,32.6 177.19,32.48 177.15,32.48 v2(176.85,32.17)
  L6 w0.102: v2(107.47,52.82) 107.87,52.42 111.75,52.42 112.99,51.19 115.99,51.19 116.33,50.85 118.31,50.85 119.7,49.46 122.39,49.46 123.26,50.32 124.15,50.32 124.19,50.27 126.84,50.27 128,49.11 129.84,49.11 130.16,49.43 134.33,49.43 134.58,49.68 136.12,49.68 v2(136.38,49.94) ; v2(162.99,30.53) 163.05,30.48 167.47,30.48 169.17,32.17 v2(176.85,32.17)
  L8 w0.102: v2(162.99,30.53) 162.07,31.46 162.07,34.53 162.85,35.32 162.85,36.13 161.76,37.23 161.76,42.12 158.7,45.18 157.64,45.18 153.86,48.95 150.25,48.95 149.09,50.11 148.44,50.11 148.36,50.19 148,50.19 147.93,50.11 145.26,50.11 144.65,49.5 139.73,49.5 138.68,50.55 136.99,50.55 v2(136.38,49.94)
  BOTTOM w0.102: CPU1.CF20 107.26,53.03 v2(107.47,52.82)
TS_VREF: length 6.6
  BOTTOM w0.102: TP7614.1 139.75,61.49 141.86,61.49 142.57,62.2 142.57,62.8 142.8,63.03 142.8,63.04 142.96,63.2 GPU1.AE2
TYPEC_DCIN1_EN#: length 77.9
  TOP w0.127: Q7406.2 20.77,70.86 20,71.62 R7428.1 19.56,71.22 19.56,70.45 v2(19.42,70.31) 19.23,70.31 v1(18.81,70.74)
  L6 w0.127: v2(19.42,70.31) 19.42,67.72 19.32,67.62 19.32,66.27 19.16,66.11 19.02,66.11 18.44,65.53 18.44,64.96 18.7,64.7 18.99,64.7 20.5,63.19 20.94,63.19 21.31,62.83 21.31,60.08 22.35,59.04 22.35,55.8 21.4,54.86 21.4,47.95 21.4,47.88 23.5,45.79 23.5,38.53 22.43,37.47 22.43,31.12 23.15,30.41 23.47,30.41 24.96,28.92 24.96,28.08 24.39,27.5 24.39,25.17 23.6,24.38 23.6,24.36 23.58,24.34 23.58,22.62 24.51,21.7 24.51,18.66 24.16,18.31 24.16,15.16 v2(23.99,14.99)
  BOTTOM w0.127: Q7407.2 20.91,68.66 20.61,68.96 20.61,69.4 19.7,70.31 v2(19.42,70.31) ; v2(23.99,14.99) 25.16,14.99 25.59,15.42 25.59,15.45 25.85,15.71 30,15.71 31.44,14.27 U2401.63
TYPEC_SMBCLK: length 97.5
  TOP w0.127: v2(41.01,11.66) 41.01,12.35 v1(40.99,12.37) ; v2(20.59,13.53) 20.64,13.48 RN2413.4
  L6 w0.127: v2(33.43,54.49) 33.15,54.81 32.98,54.82 32.37,54.82 28.91,58.28 28.91,59.42 29.27,59.78 29.27,61.75 29.27,61.86 28.39,62.74 28.39,65.31 28.12,65.59 v3(27.65,65.59)
  L8 w0.127: v2(33.43,54.49) 33.78,54.49 33.9,54.37 33.9,52.18 31.91,50.19 31.91,48.23 28.56,44.88 28.56,40.05 28.93,39.69 28.93,39.3 32.96,35.27 36.06,35.27 39.14,32.19 39.35,32.19 42.27,29.27 42.27,22.11 42.28,22.1 42.28,21.52 v2(41.97,21.2) ; v2(41.01,11.66) 40.82,11.47 40.04,11.47 39.41,10.84 35.08,10.84 32.77,13.15 30.55,13.15 30.45,13.04 24.09,13.04 21.81,15.32 21.23,15.32 20.82,14.91 20.82,13.76 v2(20.59,13.53)
  BOTTOM w0.127: v2(33.43,54.49) 33.39,54.53 R7220.1 ; v3(27.65,65.59) 27.65,65.59 27.65,65.59 27.46,65.59 27.33,65.46 27.33,64.4 U7201.B5 ; v2(41.01,11.66) 41.01,11.7 41.12,11.81 41.12,12.88 41.35,13.1 41.35,16.43 41.6,16.67 41.6,19.95 42.25,20.6 42.25,20.92 v2(41.97,21.2) ; U2401.91 20.57,13.53 v2(20.59,13.53)
TYPEC_SMBDA: length 99.2
  TOP w0.127: v2(21.37,13.53) 21.31,13.46 RN2413.3 ; v2(41.82,11.63) 41.82,11.92 v1(42.2,12.3)
  L6 w0.127: v3(27.94,66.13) 28.65,65.42 28.65,62.84 29.53,61.96 29.53,61.65 29.53,61.65 29.53,59.68 29.16,59.31 29.16,58.39 32.47,55.08 32.99,55.08 33.17,55.06 33.39,55.26 33.48,55.26 v2(33.45,55.26)
  L8 w0.127: v2(33.45,55.26) 33.48,55.26 34.16,54.58 34.16,52.08 32.17,50.09 32.17,48.13 28.82,44.78 28.82,40.16 29.18,39.79 29.18,39.4 33.06,35.52 36.16,35.52 39.24,32.44 39.46,32.44 42.52,29.38 42.52,22.22 42.53,22.21 42.53,21.45 v2(42.78,21.2) ; v2(41.82,11.63) 41.75,11.63 41.35,11.22 40.15,11.22 39.51,10.58 34.97,10.58 32.67,12.89 30.66,12.89 30.56,12.79 23.99,12.79 21.71,15.07 21.34,15.07 21.08,14.81 21.08,13.82 v2(21.37,13.53)
  BOTTOM w0.127: U7201.A5 27.08,65.57 27.67,66.16 27.9,66.16 27.9,66.13 v3(27.94,66.13) ; v2(33.45,55.26) 33.48,55.26 33.43,55.3 R7221.1 ; v2(41.82,11.63) 41.82,11.62 41.67,11.62 41.38,11.92 41.38,12.77 41.6,13 41.6,16.32 41.85,16.57 41.85,19.84 42.5,20.49 42.5,20.92 v2(42.78,21.2) ; U2401.89 v2(21.37,13.53)
U3_PD#_EC: length 161.4
  TOP w0.102: v3(29.3,8.31) 29.3,8.88 28.83,9.35 ; R2407.2 28.17,10.01 28.83,9.35 ; v1(28.84,9.35) 28.83,9.35
  L3 w0.102: v3(156.66,8.31) 157.57,8.31 157.82,8.56 165.55,8.56 166.48,9.49 169.74,9.49 170.18,9.92 172.9,9.92 174.46,11.49 v3(177,11.49)
  L8 w0.102: v3(156.66,8.31) 155.71,8.31 155.07,8.95 152.69,8.95 152.69,8.96 151.74,8.96 148.48,5.69 138.34,5.69 137.25,6.79 126.39,6.79 125.76,7.42 122.39,7.42 120.46,9.35 112.94,9.35 112.69,9.09 103.64,9.09 102.33,10.41 87.34,10.41 86.72,11.03 74.34,11.03 74,11.37 74,11.38 73.51,11.87 55.97,11.87 55.19,11.09 44.98,11.09 42.72,8.83 34.63,8.83 33.68,7.88 29.73,7.88 v3(29.3,8.31)
  BOTTOM w0.102: v3(177,11.49) 177.29,11.49 179.35,9.42 IO1.15
U3301_GPIO0: length 13.1
  TOP w0.102: AFTP3301.1 15.4,5.42 v2(15.11,5.71)
  BOTTOM w0.102: v2(15.11,5.71) 16.01,6.61 16.01,7.15 15.56,7.61 15.04,7.61 14.69,7.95 14.69,9.05 13.01,10.73 13.01,10.78 13.01,10.78 13.01,11.41 12.99,11.43 12.99,12.08 12.97,12.1 12.97,12.11 12.7,12.37 12.05,12.37 11.44,12.98 11.11,12.98 10.92,12.8 U3301.31
