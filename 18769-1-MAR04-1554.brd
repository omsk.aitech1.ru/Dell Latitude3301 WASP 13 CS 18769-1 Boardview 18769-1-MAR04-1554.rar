# Allegro board 18769-1-MAR04-1554.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
3D3V_S0 on TOP: 174.29,12.12 174.1,12.3 174.1,13.27 173.98,13.39 173.98,13.57 174.11,13.7 174.7,13.7 175.36,13.05 176.32,13.05 176.47,12.9 176.47,12.37 176.21,12.12
3D3V_S0 on TOP: 145.3,85.55 145.12,85.73 145.12,86.16 145.26,86.3 145.26,88.03 145.4,88.16 146.6,88.16 146.95,87.81 146.95,86.44 146.47,85.96 146.06,85.96 145.83,85.73 145.83,85.65 145.73,85.55 ; 1 cut-out
3D3V_S0 on TOP: 118.89,15.04 118.22,15.72 118.22,16.83 118.07,16.97 118.07,18.89 118.5,19.31 119.63,19.31 119.94,19.01 119.94,15.26 119.72,15.04 ; 2 cut-outs
3D3V_S0 on BOTTOM: 118.11,58.97 117.96,59.13 117.96,60.25 118.15,60.44 118.46,60.44 118.65,60.64 118.65,61 118.82,61.16 119.22,61.16 119.33,61.06 119.33,59.17 119.13,58.97 ; 1 cut-out
3D3V_S0 on BOTTOM: 111.07,68.63 110.89,68.81 110.89,69.93 111.03,70.06 112.07,70.06 112.28,69.86 112.28,69.13 111.78,68.63
3D3V_S0 on BOTTOM: 128.84,76.64 126.85,78.63 126.85,80.69 127.01,80.85 127.01,81.11 127.29,81.4 128.44,81.4 128.66,81.17 128.66,80.09 128.63,80.06 128.63,78.94 129.25,78.33 129.85,78.33 130.01,78.17 130.01,77.62 129.92,77.53 129.92,76.85 129.71,76.64 ; 1 cut-out
3D3V_S0 on BOTTOM: 64.08,11.9 64.05,11.93 57,11.93 56.74,12.19 56.74,12.64 56.92,12.83 57.6,12.83 57.7,12.93 57.7,13.34 58.22,13.87 61.23,13.87 61.28,13.92 65.19,13.92 65.42,13.69 65.42,12.88 65.32,12.78 64.85,12.78 64.72,12.65 64.72,11.97 64.64,11.9
3D3V_S0 on L3: 136.52,22.88 135.63,22.88 135.27,23.24 135.27,23.72 135.82,24.27 135.82,28.13 135.54,28.41 135.53,28.41 135.17,28.77 135.17,30.8 136.33,31.96 136.33,33.26 135.9,33.68 135.9,37.64 135.92,37.64 136.33,38.05 136.33,38.05 136.56,38.28 136.56,39.71 136.56,39.72 136.56,40.41 135.34,41.62 135.34,43.71 135.55,43.92 136.66,43.92 136.94,44.2 136.94,46.07 136.92,46.09 136.92,48.37 136.17,49.12 136.17,51.15 137.59,52.57 137.59,55.29 137.36,55.53 137.36,57.69 138.08,58.42 138.71,58.42 140.03,59.74 140.03,62.38 140.38,62.72 141.21,62.72 141.41,62.53 141.41,59.27 139.81,57.68 138.58,57.68 138.34,57.44 138.34,57.16 138.35,57.15 138.35,55.15 138.84,54.66 138.84,50.21 138.72,50.09 138.67,50.09 138.67,44.28 137.97,43.58 137.97,43.07 137.78,42.88 136.97,42.88 136.76,42.67 136.76,42 138.05,40.71 138.05,37.89 137.3,37.14 137.3,31.5 137.3,31.5 137.3,29.54 136.94,29.18 136.94,23.32 136.93,23.31 136.93,23.29
3D3V_S0 on L6: 136.95,62.14 133.91,62.14 130.94,65.11 130.94,66.03 129.92,67.05 129,67.05 126.72,69.34 126.72,74.27 127.6,75.15 127.6,78.58 127.59,78.59 127.59,78.69 126.72,79.56 126.72,80.74 126.72,80.74 126.72,80.92 127.19,81.39 127.84,81.39 128.49,80.74 135.81,80.74 135.85,80.78 137.83,80.78 138.5,81.44 138.5,84.82 139.34,85.66 143.74,85.66 144.93,86.86 144.93,87.48 145.44,87.99 146.34,87.99 146.36,87.97 146.37,87.98 146.82,87.98 147.17,87.63 147.17,83.82 147.91,83.08 147.91,81.98 147.71,81.78 147.52,81.78 145.54,83.76 141.47,83.76 140.7,82.99 140.7,81.62 140.87,81.45 141.69,81.45 141.75,81.39 141.75,80.87 140.36,79.48 130.51,79.48 129.15,78.13 129.15,74.35 128.75,73.94 128.75,70.95 131.34,68.36 131.34,68.35 132.02,67.67 132.02,66.46 134.96,63.51 140.58,63.51 141.48,62.61 141.48,62.17 141.24,61.93 137.16,61.93
3D3V_S0 on L6: outline of 102 points within 32.25,12.91 136.65,81.72
3D3V_S5 on TOP: 188.6,24.49 188.47,24.61 188.47,25.12 186.65,26.95 186.65,27.25 186.72,27.32 188.48,27.32 188.75,27.05 188.75,26.71 189.06,26.4 189.06,25.61 189.2,25.47 189.2,24.67 189.01,24.49 ; 1 cut-out
3D3V_S5 on TOP: 176.99,25.47 176.75,25.72 176.75,26.14 177.09,26.48 178.37,26.48 178.58,26.27 178.58,25.64 178.42,25.47 ; 1 cut-out
3D3V_S5 on TOP: 167.39,32.7 167.3,32.8 167.3,33.43 167.42,33.56 169.99,33.56 170.23,33.32 170.23,32.77 170.22,32.77 170.15,32.7
3D3V_S5 on TOP: 163.33,12.95 163,13.28 162.54,13.28 161.83,13.98 161.83,14.63 162.14,14.94 162.77,14.94 162.79,14.93 163.51,14.93 163.71,15.13 164.74,15.13 164.97,14.9 164.97,13.38 164.54,12.95 ; 1 cut-out
3D3V_S5 on TOP: 19.34,16.79 19.24,16.9 19.24,17.53 19.82,18.12 19.82,18.5 19.95,18.62 21.6,18.62 21.7,18.52 21.7,16.95 21.55,16.79 ; 1 cut-out
3D3V_S5 on TOP: 31.11,28.73 29.45,30.38 24.12,30.38 23.89,30.61 23.89,31.04 24.02,31.17 26.43,31.17 26.5,31.25 26.5,33.36 27.05,33.9 27.05,35.81 26.61,36.25 26.61,39.75 26.09,40.26 26.09,41.41 25.67,41.84 24.98,41.84 22.52,44.3 22.52,45.42 22.77,45.67 25.96,45.67 30.21,41.42 30.21,37.5 30.61,37.09 30.61,36.66 30.58,36.63 30.58,33.6 32.3,31.88 32.3,29.36 31.67,28.73 ; 6 cut-outs
3D3V_S5 on TOP: 62.52,68.88 62.32,69.08 62.32,69.66 62.48,69.81 62.48,73.52 62.72,73.76 62.72,75.02 62.99,75.3 63.43,75.3 63.94,74.79 63.94,69.57 63.3,68.93 63.29,68.93 63.25,68.88
3D3V_S5 on BOTTOM: 34.79,61.3 34.66,61.42 34.66,62.26 34.35,62.57 34.35,63.99 34.4,64.04 34.4,64.09 35.55,64.09 35.98,63.66 35.98,61.47 35.8,61.3
3D3V_S5 on BOTTOM: 66.04,11.9 65.96,11.97 65.96,13.09 66.29,13.42 66.31,13.42 66.48,13.59 70.44,13.59 70.8,13.23 70.8,12.14 70.56,11.9 ; 2 cut-outs
3D3V_S5 on BOTTOM: 91.3,6.25 90.88,6.68 90.88,12.18 91.02,12.33 91.14,12.33 91.15,12.34 94.03,12.34 94.07,12.37 96.74,12.37 97.11,12 97.11,7.35 96.02,6.25 ; 5 cut-outs
3D3V_S5 on BOTTOM: 62.29,73.74 61.43,74.6 61.43,75.87 61.81,76.26 63.84,76.26 64.1,76 64.1,74.46 63.38,73.74 ; 2 cut-outs
3D3V_S5 on BOTTOM: 192.34,1.15 192.09,1.4 192.09,2.01 192.32,2.24 193.61,2.24 193.97,1.88 195.06,1.88 195.44,2.27 196.79,2.27 196.91,2.14 196.91,1.35 196.71,1.15
3D3V_S5 on BOTTOM: 26.48,32.38 24.83,34.04 24.54,34.04 23.97,34.61 23.97,42.9 23.01,43.87 22.52,43.87 21.86,44.53 21.86,46.26 21.91,46.31 23.38,46.31 23.58,46.11 23.58,45.01 23.81,44.79 24.19,44.79 24.32,44.66 24.32,44 24.33,44 25.01,43.32 28.7,43.32 28.85,43.17 28.85,42.69 28.7,42.54 25.99,42.54 25.36,41.9 25.36,35.71 26.39,34.68 26.39,33.66 26.7,33.35 27.65,33.35 27.72,33.27 27.72,32.69 27.42,32.38 ; 4 cut-outs
3D3V_S5 on BOTTOM: 32.49,28.5 32.37,28.61 32.37,28.97 32.36,28.97 32.19,29.14 31.78,29.14 31.55,28.9 30.9,28.9 30.31,29.49 29.07,29.49 28.89,29.67 28.89,30.43 28.94,30.49 30.09,30.49 30.11,30.46 30.49,30.46 30.67,30.64 30.67,33.66 30.72,33.71 31.25,33.71 31.69,34.14 31.69,35.67 31.76,35.74 32.45,35.74 32.55,35.64 32.55,34.83 33.72,33.66 33.72,30.18 33.05,29.51 33.05,28.99 33.07,28.98 33.07,28.6 32.96,28.5
3D3V_S5 on L4VCC: 36.69,18.71 41.86,13.55 70.38,13.55 70.59,13.33 70.59,8.8 69.79,7.99 34.71,7.99 29.58,13.12 29.58,24.43 30.58,25.43 30.58,29.94 31.48,30.84 33.08,30.84 35.6,28.32 35.6,23.5 36.69,22.4
3D3V_S5 on L5: 58.52,73.07 61.47,70.11 62.44,70.11 63.1,69.45 63.1,69.06 62.96,68.92 61.55,68.92 60.96,68.92 57.89,71.99 42.55,71.99 42.25,72.3 42.25,72.87 42.44,73.07
3D3V_S5 on L5: 145.73,10.41 145.91,10.59 146.74,10.59 148.58,12.43 157.19,12.43 157.24,12.37 159.11,12.37 160.1,13.37 160.11,13.37 160.79,14.05 164.56,14.05 165.24,13.37 175.23,13.37 177.94,10.65 177.94,10.6 178.9,9.64 178.9,8.56 179.16,8.31 179.67,8.31 180.81,7.17 180.81,6.63 181.14,6.3 193.26,6.3 193.26,6.28 194.04,5.49 194.04,2.16 194.35,1.86 194.86,1.86 195.14,1.58 195.14,1.12 192.39,1.12 189.99,3.53 174.64,3.53 174.1,4.07 174.1,7.93 173.75,8.29 152.79,8.29 152.62,8.11 152.62,8.08 150.13,5.6 84.11,5.6 81.04,8.67 71.65,8.67 70.19,10.13 68.7,10.13 67.28,11.55 66.36,11.55 65.96,11.95 65.96,12.88 67.03,13.95 82.22,13.95 82.27,13.91 87.98,13.91 91.76,10.13 116.13,10.13 116.99,9.26 121.87,9.26 123.01,10.41
3D3V_S5 on L5: 23.37,44.55 23.37,44.43 23.06,44.12 22.49,44.12 22.3,44.31 22.3,47.18 23.31,48.18 23.31,56.59 27.02,60.31 27.02,64.29 28.46,65.73 30,65.73 30.34,65.39 30.43,65.39 30.91,64.91 30.91,64.6 30.38,64.07 29.65,64.07 29.52,63.94 29.52,61.15 29.52,61.15 29.78,60.89 31.61,60.89 32.92,62.21 34.52,62.21 35.29,62.98 35.7,62.98 35.77,62.92 35.77,62.35 34.61,61.19 33.4,61.19 32.18,59.97 29.82,59.97 29.52,59.67 29.52,58.43 30.46,57.49 30.46,52.1 28.66,50.3 28.66,48.23 27.55,47.13 25.95,47.13
3D3V_S5 on L8: 29.34,60.44 27.32,62.47 27.32,64.39 28.27,65.34 28.27,66.26 27.65,66.88 26.9,66.88 26.2,67.58 26.2,69.25 26.88,69.92 28.75,69.92 28.78,69.89 29.07,69.89 29.66,69.3 34.57,69.3 41.96,76.68 53.4,76.68 53.8,76.29 62.58,76.29 63.54,75.32 63.54,75.32 63.69,75.18 63.69,74.04 63.4,73.75 62.44,73.75 61.55,74.65 58.8,74.65 58.52,74.36 54.52,74.36 54.01,74.87 52.55,74.87 51.74,75.67 43.62,75.67 42.25,74.3 42.25,73.67 43.04,72.88 43.04,72.21 42.34,71.51 39.37,71.51 38.14,70.27 38.14,69.78 34.84,66.48 31.05,66.48 30.77,66.2 30.76,66.2 30.72,66.16 30.72,65.4 30.91,65.21 30.91,64.6 30.36,64.05 29.76,64.05 29.34,63.64 29.34,62.49 30.87,60.97 30.87,60.55 30.77,60.44
3D3V_S5_KBC on TOP: 36.55,1.33 34.71,3.17 34.71,3.66 35.04,3.99 35.62,3.99 35.67,3.94 35.8,3.94 37.55,2.19 38.72,2.19 39.08,2.55 43.09,2.55 43.22,2.42 53.78,2.42 53.91,2.29 55.05,2.29 55.16,2.39 60.39,2.39 60.46,2.32 60.46,1.58 60.21,1.33 ; 1 cut-out
3D3V_S5_KBC on TOP: 19.4,25.99 19.4,26.01 19.25,26.16 19.25,26.49 19.72,26.96 19.72,27.3 19.44,27.57 19.23,27.57 19.12,27.68 19.12,28.28 19.47,28.63 20.79,28.63 20.95,28.79 21.52,28.79 21.68,28.63 22.52,28.63 22.75,28.41 22.75,27.91 22.63,27.79 20.68,27.79 20.42,27.53 20.42,26.72 19.68,25.99 ; 2 cut-outs
3D3V_S5_KBC on TOP: 24.01,11.1 23.79,11.32 23.79,11.33 23.69,11.43 23.69,11.54 23.44,11.79 22.31,11.79 21.8,11.28 20.3,11.28 20.13,11.45 20.13,12 20.49,12.35 21.73,12.35 21.79,12.4 21.79,12.57 21.79,12.57 21.9,12.68 22.22,12.68 22.22,12.68 23.86,12.68 24.18,12.36 24.18,12.12 24.2,12.11 24.51,11.81 24.51,11.3 24.3,11.1 ; 1 cut-out
3D3V_S5_PCH on TOP: 115.58,56.28 115.3,56.56 115.3,58.42 115.2,58.52 114.64,58.52 114.49,58.36 114.49,57.78 114.41,57.7 113.62,57.7 113.47,57.55 113.47,56.99 113.34,56.87 112.1,56.87 112.05,56.92 112.05,59.86 112.18,59.99 113.52,59.99 113.74,60.21 113.74,62.19 113.89,62.34 114.52,62.34 114.81,62.05 115.7,62.05 116.37,61.38 116.37,60.24 117.59,59.03 117.71,59.03 119.15,57.58 119.15,56.5 119,56.36 117.59,56.36 117.51,56.28 ; 3 cut-outs
3D3V_S5_PCH on BOTTOM: 116.34,55.95 116.29,56 116.29,57.09 116.32,57.12 116.92,57.12 117.1,57.3 118.19,57.3 118.27,57.22 118.27,56.74 118.22,56.69 117.76,56.69 117.56,56.49 117.56,56.08 117.43,55.95
3D3V_SSD on TOP: 115.32,16.09 115.17,16.24 115.17,17.29 115.05,17.4 115.05,21.5 115.28,21.73 117.82,21.73 118.43,21.13 118.43,20.12 118.28,19.97 118.05,19.97 117.92,19.84 117.92,17.99 117.64,17.71 116.85,17.71 116.83,17.73 116.42,17.73 116.37,17.68 116.37,16.56 115.91,16.09 ; 4 cut-outs
3D3V_SSD on TOP: 116.16,30.51 115.99,30.68 115.99,32.51 115.52,32.98 115.52,33.37 115.6,33.44 117.38,33.44 117.54,33.29 117.54,32.98 117.05,32.5 117.05,31.56 117.43,31.19 117.43,30.6 117.34,30.51 ; 3 cut-outs
3D3V_SSD on BOTTOM: 114.42,32.94 114.16,33.19 114.16,34.22 114.46,34.52 116.41,34.52 116.42,34.51 116.81,34.51 117.46,33.86 117.46,33.25 117.15,32.94
3D3V_SSD on BOTTOM: 114.58,15.7 114.48,15.8 114.48,20.12 114.7,20.34 116.36,20.34 116.61,20.09 116.61,16.14 116.17,15.7
3D3V_SSD on L8: 117.5,33.16 117.5,24.24 117.04,23.78 117.04,18.37 116.67,18 115.51,18 114.48,19.03 114.48,22.62 114.69,22.83 114.69,32.99 115.18,33.48 117.17,33.48
3D3V_TP_VDD on TOP: 125.62,4.05 125.29,4.37 124.04,4.37 123.74,4.68 120.98,4.68 119.97,5.69 119.97,6.47 120.01,6.51 120.92,6.51 121.18,6.25 121.18,5.89 121.28,5.78 122.73,5.78 122.84,5.9 122.84,6.2 122.99,6.34 123.31,6.34 123.46,6.2 123.46,5.69 123.86,5.29 126.57,5.29 126.57,5.18 126.6,5.15 126.6,4.22 126.43,4.05 ; 2 cut-outs
3D3V_TPM on TOP: 176.84,26.6 176.72,26.73 176.72,27.44 177.09,27.81 177.09,28.21 177.36,28.48 177.99,28.48 178.24,28.22 179.77,28.22 179.91,28.35 182.47,28.35 182.54,28.28 182.54,28.06 182.44,27.95 181.86,27.95 181.85,27.96 181.7,27.96 181.4,27.66 180.05,27.66 179.68,27.28 178.79,27.28 178.1,26.6 ; 1 cut-out
3D3V_TPM on TOP: 186.73,30.49 186.63,30.59 186.63,31.42 187.03,31.83 189.34,31.83 189.42,31.76 189.42,31.04 188.86,30.49 ; 2 cut-outs
3D3V_VCCPRIM on TOP: 112.63,46.53 112.28,46.88 112.28,47.4 112.04,47.64 110.79,47.64 110.58,47.84 110.58,48.25 110.78,48.45 113.31,48.45 113.53,48.23 113.53,46.76 113.29,46.53 ; 1 cut-out
3D3V_VCCPRIM on TOP: 105.68,50.19 105.44,50.43 105.44,51 104.89,51.55 103.4,51.55 103.28,51.67 103.28,52.12 103.13,52.27 100.75,52.27 100.41,51.93 100.12,51.93 99.98,52.07 99.98,52.55 100.74,53.31 101.12,53.31 101.76,52.68 105.06,52.68 105.44,53.06 106.46,53.06 106.51,53.01 106.51,51.7 106.59,51.62 107.76,51.62 107.81,51.57 107.81,51.19 107.68,51.06 107.47,51.06 107.39,50.98 107.39,50.77 107.33,50.71 107.33,50.29 107.23,50.19 ; 4 cut-outs
3D3V_VCCPRIM on BOTTOM: 105.06,51.54 104.6,51.99 104.6,52.35 105.06,52.81 106.46,52.81 106.59,52.68 106.59,51.66 106.46,51.54
3D3V_VCCPRIM on L3: 105.3,52.38 105.58,52.38 107.4,50.55 110.45,50.55 112.56,48.44 113.2,48.44 113.47,48.16 113.47,47.71 113.3,47.53 111.65,47.53 110.15,49.03 106.59,49.03 105.14,50.47 105.14,51.57 104.99,51.72 103.26,51.72 103.01,51.97 103.01,52.38 103.24,52.61 105.07,52.61
3D3V_VCCPRIM on L6: 106.99,58.91 110.38,58.91 110.77,58.52 110.77,58.19 110.52,57.93 107.27,57.93 106.89,58.31 106.89,58.81
3D3V_WLAN on TOP: 167.82,29.51 167.2,30.13 167.2,31.8 167.41,32.01 169.81,32.01 169.94,31.88 169.94,30.82 169.74,30.63 168.86,30.63 168.63,30.4 168.63,29.64 168.5,29.51 ; 3 cut-outs
3D3V_WLAN on TOP: 166.91,11.97 165.43,13.45 165.43,15.93 165.59,16.09 167.01,16.09 167.18,15.92 167.18,15.27 167.29,15.16 168.25,15.16 168.63,14.78 169.74,14.78 169.81,14.71 169.81,14.07 169.57,13.83 169.57,12.37 169.17,11.97 ; 6 cut-outs
3D3V_WLAN on BOTTOM: 166.76,11.95 166.41,12.3 166.41,13.36 166.82,13.77 168.33,13.77 170.06,15.5 170.06,21.93 171.11,22.98 171.11,24.81 170.5,25.42 170.5,26.53 169.3,27.73 169.3,29.45 168.41,30.34 166.68,30.34 166.5,30.52 166.5,31.5 166.63,31.64 168.53,31.64 168.68,31.78 171.24,31.78 172.22,30.8 172.22,27.86 174.41,25.67 174.41,21.11 173.75,20.45 173.75,16.89 172.58,15.72 172.57,15.72 172.22,15.36 172.22,15.35 168.82,11.95
+DC_IN_C on TOP: 34.51,74.99 34.28,75.22 34.28,78.03 33.86,78.44 33.33,78.44 33.24,78.54 33.24,80.83 33.87,81.46 36.54,81.46 38.19,79.81 38.19,77.65 37.93,77.4 37.93,76.51 37.81,76.38 36.29,76.38 35.98,76.07 35.98,75.35 35.61,74.99 ; 3 cut-outs
+DC_IN_C on BOTTOM: 36.28,76.38 36.16,76.51 36.16,77.27 35.65,77.78 33.24,77.78 32.83,78.19 32.83,80.62 33.03,80.83 36.16,80.83 36.18,80.8 36.49,80.8 36.64,80.65 36.64,80.55 36.72,80.47 37.5,80.47 37.58,80.4 37.58,79.79 37.22,79.43 36.79,79.43 36.64,79.28 36.64,78.19 37.17,77.65 37.81,77.65 37.93,77.53 37.93,76.51 37.81,76.38
AUD_AGND on TOP: 190.92,16.77 190.92,17.28 190.92,17.28 190.92,18.69 190.98,18.75 191.63,18.75 192.42,17.96 192.42,16.29 192.27,16.13 191.55,16.13 ; 1 cut-out
AUD_AGND on TOP: 180.96,7.78 180.71,8.03 180.71,9.81 181.09,10.19 181.44,10.19 181.85,9.78 182.74,9.78 182.87,9.66 182.87,8.92 181.72,7.78 ; 3 cut-outs
AUD_AGND on TOP: 187.77,8.97 187.59,9.15 187.59,9.86 187.77,10.04 188.18,10.04 188.28,10.14 188.28,12.83 188.63,13.19 189.42,13.19 189.6,13.01 189.6,10.39 189.7,10.29 190.84,10.29 191.1,10.55 191.1,12.5 191.43,12.83 192.04,12.83 192.29,12.58 192.29,9.76 192.01,9.48 189.88,9.48 189.37,8.97 ; 3 cut-outs
AUD_AGND on L2GND, L4VCC, L7VCC: 184.91,13.24 184.91,15.34 186.52,15.36 186.65,15.23 189.5,15.23 189.99,15.72 189.99,16.03 190.78,16.82 190.78,18.93 190.34,19.37 189.32,19.37 188.99,19.04 186.29,19.04 184.64,17.39 183.67,17.39 183.67,18.16 184.91,19.41 184.91,19.79 185.16,20.03 186.2,20.03 186.69,20.53 186.69,21.16 186.81,21.28 188.58,21.28 188.91,20.95 189.52,20.95 192.41,18.06 192.41,15.07 191.59,14.26 191.59,13.13 192.23,12.5 192.23,9.99 191.83,9.59 189.52,9.59 189.09,9.16 187.67,9.16 187.15,8.64 187.15,8.24 186.45,7.54 183.53,7.54 182.92,8.15 181.92,8.15 181.75,7.97 180.84,7.97 180.1,8.7 179.39,8.7 179.35,8.75 179.35,9.94 178.61,10.68 178.61,11.08 178.81,11.27 178.96,11.27 179.44,11.75 179.72,11.75 180.06,12.09 180.06,12.14 180.84,12.92 184.6,12.92
AUD_AGND on L9GND: 184.91,13.24 184.91,15.34 186.52,15.36 186.65,15.23 189.5,15.23 189.99,15.72 189.99,16.03 190.78,16.82 190.78,18.93 190.34,19.37 189.32,19.37 188.99,19.04 186.29,19.04 184.64,17.39 183.67,17.39 183.67,18.16 184.91,19.41 184.91,19.79 185.16,20.03 186.2,20.03 186.69,20.53 186.69,21.16 186.81,21.28 188.58,21.28 188.91,20.95 189.52,20.95 192.41,18.06 192.41,15.07 191.59,14.26 191.59,13.13 192.23,12.5 192.23,9.99 191.83,9.59 189.52,9.59 189.09,9.16 187.67,9.16 187.15,8.64 187.15,8.24 186.45,7.54 183.53,7.54 182.92,8.15 181.92,8.15 181.75,7.97 181.14,7.97 180.85,8.26 180.85,9.38 180.3,9.92 179.36,9.92 178.61,10.68 178.61,11.08 178.81,11.27 178.96,11.27 179.44,11.75 179.72,11.75 180.06,12.09 180.06,12.14 180.84,12.92 184.6,12.92
AUD_PC_BEEP_C on TOP: 171.79,6.28 171.41,6.66 171.41,6.91 171.54,7.04 172.17,7.04 172.3,6.91 176.11,6.91 176.24,7.04 176.24,8.56 176.36,8.69 176.36,9.07 176.49,9.2 176.87,9.2 177,9.07 177,8.69 176.75,8.44 176.75,6.53 176.49,6.28
AUD_RING on BOTTOM: 181.25,8.33 181.18,8.39 181.18,9.89 180.8,10.27 180.8,10.32 180.8,10.33 180.8,10.85 181.19,11.25 181.63,11.25 183.07,9.81 183.07,8.39 183.02,8.34 183.02,8.33
AUD_RING on L3: 181.09,11.31 181.9,11.31 182.66,10.55 185.92,10.55 187.16,11.79 189.4,11.79 190.28,10.9 190.28,10.24 190,9.96 189.73,9.96 188.99,10.7 187.69,10.7 186.45,9.45 182.18,9.45 181.39,10.24 180.96,10.24 180.68,10.52 180.68,10.9
AUD_SLEEVE on BOTTOM: 184.73,8.33 184.7,8.36 184.7,9.49 183.57,10.62 183.43,10.62 183.42,10.61 182.36,10.61 181.54,11.44 181.54,11.83 181.97,12.27 183.98,12.27 186.55,9.71 186.55,8.35 186.52,8.33
AUD_SLEEVE on L5: 181.57,11.99 182.64,11.99 183.6,11.03 186.55,11.03 187.08,11.56 187.11,11.56 187.67,12.12 190.44,12.12 191.02,11.54 191.02,10.24 190.89,10.11 190.51,10.11 190.26,10.37 190.26,10.77 190.16,10.88 189.5,10.88 188.73,10.11 182.56,10.11 181.32,11.36 181.32,11.74
AUD_SPK_L+ on TOP: 160.01,4.98 159.45,5.54 159.45,7.27 159.65,7.47 160.54,7.47 160.62,7.4 160.62,6.33 161.25,5.69 161.25,5.26 160.97,4.98
AUD_SPK_L+ on TOP: 183.3,18.67 183.17,18.8 183.17,19.74 183.45,20.02 183.83,20.02 183.96,19.89 183.96,19.44 183.71,19.18 183.71,18.93 183.45,18.67
AUD_SPK_L+ on L6: 161.3,5.01 160.59,5.01 160.31,5.29 160.31,7.14 160.57,7.4 161.35,7.4 161.56,7.19 161.56,6.86 161.35,6.66 161.35,5.06
AUD_SPK_L+_C on TOP: 159.7,7.73 159.42,8.01 159.42,8.82 159.8,9.2 159.8,9.66 160.41,10.27 160.41,11.84 161.07,12.5 161.51,12.5 161.66,12.35 161.66,10.93 161.28,10.55 161.28,10.01 160.9,9.63 160.67,9.63 160.46,9.43 160.46,8.97 160.59,8.84 160.59,7.9 160.41,7.73
AUD_SPK_L+_C on BOTTOM: 161.79,8.01 161.58,8.21 161.58,9.68 161.48,9.78 160.54,9.78 160.36,9.96 160.36,10.47 160.62,10.72 162.12,10.72 162.45,10.39 162.45,8.08 162.37,8.01
AUD_SPK_L- on TOP: 182.79,18.75 182.64,18.9 182.64,19.46 182.31,19.79 182.31,20.66 183.2,21.54 183.48,21.54 183.63,21.39 183.63,20.91 183.12,20.4 183.12,18.98 182.89,18.75
AUD_SPK_L- on TOP: 158.31,5.34 158.13,5.52 158.13,7.09 158.48,7.45 159.19,7.45 159.25,7.4 159.25,5.52 159.07,5.34
AUD_SPK_L-_C on TOP: 158.36,7.85 158.18,8.03 158.18,8.69 158.33,8.84 158.43,8.84 158.76,9.17 158.76,9.18 159.03,9.45 159.03,10.61 159.63,11.21 160.06,11.21 160.24,11.03 160.24,10.19 159.63,9.58 159.63,9.23 159.32,8.92 159.32,8.69 159.35,8.67 159.35,8.03 159.17,7.85
AUD_SPK_L-_C on BOTTOM: 159.65,8.03 158.46,9.22 158.46,10.53 158.68,10.75 160.03,10.75 160.16,10.62 160.16,9.96 160.54,9.58 161.33,9.58 161.43,9.48 161.43,8.08 161.38,8.03
AUD_SPK_R+ on TOP: 162.06,5.01 161.91,5.16 161.91,5.54 161.94,5.57 161.94,5.77 161.15,6.56 161.15,7.32 161.18,7.35 162.09,7.35 162.19,7.24 162.19,6.53 162.75,5.97 162.75,5.16 162.6,5.01
AUD_SPK_R+ on TOP: 181.32,18.27 180.73,18.85 180.73,19.36 180.84,19.46 181.01,19.46 181.03,19.45 181.36,19.45 181.72,19.08 181.72,18.42 181.57,18.27
AUD_SPK_R+ on L6: 162.8,4.93 162.14,4.93 162.01,5.06 162.01,6.38 162.7,7.07 163.18,7.07 163.36,6.89 163.36,6.15 162.88,5.67 162.88,5.01
AUD_SPK_R+_C on TOP: 161.2,7.73 161.05,7.88 161.05,8.62 161.38,8.95 161.38,10.22 162.34,11.18 162.8,11.18 163.28,10.7 163.28,9.86 163.13,9.71 162.5,9.71 162.47,9.73 162.39,9.73 162.09,9.43 162.09,7.88 161.94,7.73
AUD_SPK_R+_C on BOTTOM: 163.77,8.03 163.59,8.21 163.59,9.56 163.46,9.68 162.78,9.68 162.6,9.86 162.6,10.62 162.85,10.88 164.05,10.88 164.38,10.55 164.38,10.01 164.66,9.73 164.66,8.13 164.55,8.03
AUD_SPK_R- on TOP: 163,5.01 162.83,5.19 162.83,5.47 162.85,5.49 162.85,6 162.32,6.53 162.32,6.63 162.32,6.64 162.32,7.38 162.43,7.5 163.53,7.5 163.74,7.28 163.74,7.28 163.91,7.1 163.91,5.57 163.74,5.4 163.74,5.26 163.49,5.01 ; 1 cut-out
AUD_SPK_R-_C on TOP: 162.45,7.73 162.29,7.88 162.29,8.49 162.6,8.79 163.49,8.79 163.79,9.1 163.79,9.89 164.63,10.72 165.39,10.72 165.8,10.32 165.8,9.68 163.84,7.73 ; 2 cut-outs
AUD_SPK_R-_C on BOTTOM: 163.16,6.96 162.7,7.42 162.7,9.56 162.75,9.61 163.33,9.61 163.41,9.53 163.41,7.96 163.54,7.83 164.53,7.83 164.78,8.08 164.78,9.81 164.55,10.04 164.55,10.55 164.68,10.67 165.93,10.67 166.12,10.49 166.12,7.97 165.11,6.96
BT+ on TOP: 112.99,3.76 112.71,4.04 112.64,4.04 112.46,4.22 112.46,4.71 112.22,4.95 111.25,4.95 110.51,5.69 110.51,6.32 110.91,6.72 114.65,6.72 114.92,6.44 114.92,6.04 114.03,5.15 113.58,5.15 113.3,4.86 113.3,4.63 113.4,4.53 113.4,4.45 113.5,4.45 113.7,4.25 113.7,4.01 113.45,3.76
BT+ on BOTTOM: 105.11,3.66 99.02,9.74 99.02,12.65 99.33,12.96 99.68,12.96 99.7,12.94 100.24,12.94 104.58,12.94 105.09,12.43 105.09,10.82 105.08,10.81 105.08,10.22 105.34,9.95 108.79,9.95 108.79,9.94 108.93,9.81 108.93,9.5 109.14,9.29 109.47,9.29 109.67,9.49 109.67,9.9 109.72,9.95 114.75,9.95 115.05,10.25 122.12,10.25 122.24,10.13 122.24,5.76 120.14,3.66 ; 2 cut-outs
CA_VREF on L3: 107.53,22.53 100.8,22.53 98.51,20.25 88.86,20.25 88.61,20.5 88.61,22.28 88.48,22.41 87.34,22.41 87.21,22.28 87.21,21.26 86.96,21.01 79.59,21.01 79.34,20.76 79.34,19.49 79.46,19.36 100.16,19.36 101.43,20.63 107.78,20.63 108.17,21.01 108.17,21.9
CA_VREF on L8: 69.56,22.03 69.56,21.14 69.68,21.01 79.84,21.01 80.35,20.5 80.35,19.74 79.97,19.36 72.35,19.36 72.22,19.49 71.21,19.49 71.08,19.61 66,19.61 65.24,20.38 65.24,21.77 65.37,21.9 68.54,21.9 68.92,22.28 69.3,22.28
CA_VREF on L8: 50.63,26.86 51.33,26.86 52.85,25.33 52.85,24.71 52.67,24.53 50.43,24.53 50.06,24.89 50.06,26.29
EC_AGND on TOP: 16.65,16.97 16.32,17.3 16.32,18.27 15.68,18.9 15.68,19.45 14.84,20.29 14.84,20.71 15.02,20.89 15.56,20.89 15.68,21.01 15.68,21.98 15.76,22.05 15.79,22.03 16.85,22.03 17.03,21.85 17.03,18.17 17.09,18.11 17.09,17.23 16.83,16.97 ; 5 cut-outs
EMMC_RCOMP on TOP: 110.32,55.55 110.07,55.81 110.07,56.82 110.2,56.95 110.71,56.95 110.83,56.82 110.83,55.68 110.71,55.55
HDMI_PLL_GND on BOTTOM: 20.28,45.06 19.52,45.83 19.52,54.92 19.8,55.2 20.43,55.2 20.41,55.22 20.69,55.22 20.87,55.05 20.87,52.71 21.17,52.41 21.17,49 21.6,48.57 21.6,45.24 21.42,45.06 ; 1 cut-out
JGND on TOP: 33.46,72.09 32.6,72.95 32.6,74.2 33.36,74.96 33.79,74.96 34.02,74.73 35.52,74.73 36.03,75.24 36.03,75.87 36.28,76.13 37.55,76.13 37.55,75.62 37.05,75.11 37.05,72.95 36.18,72.09 ; 1 cut-out
JGND on BOTTOM: 32.71,72.83 32.48,73.06 32.48,73.34 32.6,73.46 32.6,74.99 32.98,75.37 36.03,75.37 36.41,75.75 37.68,75.75 37.81,75.62 37.81,74.86 36.79,73.84 36.28,73.84 36.03,73.59 36.03,73.08 35.78,72.83
KB_BL_CTRL# on BOTTOM: 28.46,9.17 28.41,9.21 28.41,10.75 28.58,10.92 35.67,10.92 35.99,10.6 35.99,10.06 35.09,9.17
Net_59 on TOP_-MB (solid shape): 166.46,13.65 165.57,13.65 165.57,15.12 166.46,15.12
Net_60 on TOP_-MB (solid shape): 164.83,13.65 163.94,13.65 163.94,15.12 164.83,15.12
Net_61 on TOP_-MB (solid shape): 117.6,17.78 116.71,17.78 116.71,19.25 117.6,19.25
Net_62 on TOP_-MB (solid shape): 119.23,17.78 118.34,17.78 118.34,19.25 119.23,19.25
Net_63 on TOP_-MB (solid shape): 43.36,80.75 42.47,80.75 42.47,82.22 43.36,82.22
Net_64 on TOP_-MB (solid shape): 42.43,30.63 41.54,30.63 41.54,32.1 42.43,32.1
Net_65 on TOP_-MB (solid shape): 44.05,30.63 43.16,30.63 43.16,32.1 44.05,32.1
Net_66 on TOP_-MB (solid shape): 41.73,80.75 40.84,80.75 40.84,82.22 41.73,82.22
Net_67 on TOP_-MB (solid shape): 38.59,73.82 37.7,73.82 37.7,75.3 38.59,75.3
Net_68 on TOP_-MB (solid shape): 36.96,73.82 36.07,73.82 36.07,75.3 36.96,75.3
Net_69 on TOP_-MB (solid shape): 35.33,75.07 34.44,75.07 34.44,76.54 35.33,76.54
Net_70 on TOP_-MB (solid shape): 35.35,76.82 34.46,76.82 34.46,78.29 35.35,78.29
Net_71 on TOP_-MB (solid shape): 33.7,75.07 32.81,75.07 32.81,76.54 33.7,76.54
Net_72 on TOP_-MB (solid shape): 33.73,76.82 32.84,76.82 32.84,78.29 33.73,78.29
Net_147 on TOP_-MB (solid shape): 16.74,59.89 15.85,59.89 15.85,61.49 16.74,61.49
Net_148 on TOP_-MB (solid shape): 15.01,59.89 14.12,59.89 14.12,61.49 15.01,61.49
Net_1069 on TOP_-MB (solid shape): 32.02,68.37 31,68.37 31,70.22 32.02,70.22
Net_1070 on TOP_-MB (solid shape): 29.32,68.37 28.31,68.37 28.31,70.22 29.32,70.22
Net_1186 on TOP_-MB (solid shape): 160,85.11 160.23,84.57 160.18,84.44 159.52,84.16 159.39,84.22 159.16,84.75 159.21,84.89 159.87,85.16
Net_1187 on TOP_-MB (solid shape): 159.48,86.33 159.71,85.79 159,85.38 158.87,85.43 158.64,85.97 158.7,86.1 159.35,86.38
Net_1188 on TOP_-MB (solid shape): 158.92,84.65 159.15,84.11 159.1,83.98 158.44,83.7 158.31,83.76 158.08,84.29 158.13,84.43 158.79,84.7
Net_1189 on TOP_-MB (solid shape): 158.41,85.87 158.63,85.33 158.58,85.2 157.93,84.92 157.79,84.97 157.56,85.51 157.62,85.64 158.27,85.92
Net_1190 on TOP_-MB (solid shape): 157.82,84.2 158.05,83.66 158,83.53 157.34,83.25 157.21,83.3 156.98,83.84 157.04,83.97 157.69,84.25
Net_1191 on TOP_-MB (solid shape): 157.31,85.41 157.54,84.88 157.48,84.74 156.83,84.47 156.69,84.52 156.47,85.06 156.52,85.19 157.17,85.47
Net_1192 on TOP_-MB (solid shape): 186.4,27.11 182.79,27.11 182.79,30.72 186.4,30.72
Net_1195 on TOP_-MB (solid shape): 30.61,74.5 28.18,74.5 28.18,77.85 30.61,77.85
Net_1196 on TOP_-MB (solid shape): 25.97,74.58 23.53,74.58 23.53,77.94 25.97,77.94
Net_1355 on TOP_-MB (solid shape): 159.61,68.97 160.05,68.58 160.06,68.44 159.53,67.83 159.38,67.82 158.94,68.2 158.93,68.34 159.46,68.96
Net_1356 on TOP_-MB (solid shape): 160.6,68.1 161.05,67.72 161.06,67.57 160.52,66.96 160.38,66.95 159.94,67.33 159.93,67.48 160.46,68.09
Net_1370 on TOP_-MB (solid shape): 105.26,79.97 101.91,79.97 101.91,82.41 105.26,82.41
Net_1371 on TOP_-MB (solid shape): 101.45,81.24 98.1,81.24 98.1,83.68 101.45,83.68
Net_1372 on TOP_-MB (solid shape): 31.63,71.74 28.27,71.74 28.27,74.18 31.63,74.18
Net_1446 on TOP_-MB (solid shape): 137.86,11.09 132.66,11.09 132.66,13.98 137.86,13.98
Net_1466 on TOP_-MB (solid shape): 21.37,33.58 18.58,33.58 18.58,38.38 21.37,38.38
Net_1467 on TOP_-MB (solid shape): 155.48,70.44 155.98,69.93 155.98,69.79 155.57,69.38 155.43,69.38 154.92,69.88 154.92,70.02 155.34,70.44
Net_1468 on TOP_-MB (solid shape): 154.55,69.5 155.05,69 155.05,68.86 154.64,68.44 154.49,68.44 153.99,68.95 153.99,69.09 154.4,69.5
Net_1469 on TOP_-MB (solid shape): 154.61,67.94 155.11,67.44 155.11,67.3 154.7,66.89 154.56,66.89 154.05,67.39 154.05,67.53 154.47,67.94
Net_1470 on TOP_-MB (solid shape): 158.63,66.51 159.13,66.01 159.13,65.86 158.72,65.45 158.57,65.45 158.07,65.95 158.07,66.1 158.48,66.51
Net_1471 on TOP_-MB (solid shape): 155.7,66.47 156.2,65.97 156.2,65.83 155.79,65.41 155.64,65.41 155.14,65.92 155.14,66.06 155.55,66.47
Net_1472 on TOP_-MB (solid shape): 157.37,68.17 157.88,67.66 157.88,67.52 157.46,67.11 157.32,67.11 156.82,67.61 156.82,67.75 157.23,68.17
Net_1473 on TOP_-MB (solid shape): 156.44,67.23 156.94,66.73 156.94,66.59 156.53,66.17 156.39,66.17 155.88,66.68 155.88,66.82 156.3,67.23
Net_1474 on TOP_-MB (solid shape): 158.31,63.38 158.81,62.88 158.81,62.74 158.4,62.32 158.26,62.32 157.75,62.83 157.75,62.97 158.17,63.38
Net_1475 on TOP_-MB (solid shape): 157.38,62.45 157.88,61.95 157.88,61.8 157.47,61.39 157.32,61.39 156.82,61.89 156.82,62.04 157.23,62.45
Net_1476 on TOP_-MB (solid shape): 160.01,65.12 160.52,64.62 160.52,64.48 160.1,64.06 159.96,64.06 159.46,64.57 159.46,64.71 159.87,65.12
Net_1477 on TOP_-MB (solid shape): 159.08,64.19 159.58,63.69 159.58,63.54 159.17,63.13 159.03,63.13 158.52,63.63 158.52,63.78 158.94,64.19
Net_1478 on TOP_-MB (solid shape): 155.07,63.34 155.58,62.84 155.58,62.7 155.16,62.28 155.02,62.28 154.52,62.79 154.52,62.93 154.93,63.34
Net_1479 on TOP_-MB (solid shape): 154.14,62.41 154.64,61.91 154.64,61.76 154.23,61.35 154.09,61.35 153.58,61.85 153.58,62 154,62.41
Net_1480 on TOP_-MB (solid shape): 156.91,64.86 157.42,64.36 157.42,64.21 157,63.8 156.86,63.8 156.36,64.3 156.36,64.45 156.77,64.86
Net_1481 on TOP_-MB (solid shape): 155.98,63.93 156.48,63.42 156.48,63.28 156.07,62.87 155.93,62.87 155.42,63.37 155.42,63.51 155.84,63.93
Net_1482 on TOP_-MB (solid shape): 157.69,65.58 158.2,65.07 158.2,64.93 157.78,64.52 157.64,64.52 157.14,65.02 157.14,65.16 157.55,65.58
Net_1483 on TOP_-MB (solid shape): 154.76,65.54 155.26,65.04 155.26,64.89 154.85,64.48 154.71,64.48 154.2,64.98 154.2,65.13 154.62,65.54
Net_1484 on TOP_-MB (solid shape): 156.54,61.49 157.05,60.99 157.05,60.85 156.63,60.43 156.49,60.43 155.99,60.94 155.99,61.08 156.4,61.49
Net_1485 on TOP_-MB (solid shape): 155.61,60.56 156.11,60.06 156.11,59.91 155.7,59.5 155.56,59.5 155.05,60 155.05,60.15 155.47,60.56
Net_1486 on TOP_-MB (solid shape): 152.84,66.31 153.35,65.81 153.35,65.66 152.93,65.25 152.79,65.25 152.29,65.75 152.29,65.9 152.7,66.31
Net_1487 on TOP_-MB (solid shape): 153.68,67.01 154.18,66.51 154.18,66.36 153.77,65.95 153.62,65.95 153.12,66.45 153.12,66.6 153.53,67.01
Net_1488 on TOP_-MB (solid shape): 153.78,68.78 154.28,68.28 154.28,68.14 153.87,67.72 153.73,67.72 153.22,68.23 153.22,68.37 153.64,68.78
Net_1489 on TOP_-MB (solid shape): 152.85,67.85 153.35,67.35 153.35,67.2 152.94,66.79 152.79,66.79 152.29,67.29 152.29,67.44 152.7,67.85
Net_1490 on TOP_-MB (solid shape): 151.91,65.38 152.41,64.87 152.41,64.73 152,64.32 151.86,64.32 151.35,64.82 151.35,64.96 151.77,65.38
Net_1812 on TOP_-MB (solid shape): 152.27,62.04 152.68,61.63 152.68,61.48 152.11,60.91 151.96,60.91 151.55,61.32 151.55,61.46 152.13,62.04
Net_1813 on TOP_-MB (solid shape): 151.34,62.97 151.75,62.56 151.75,62.42 151.17,61.84 151.03,61.84 150.62,62.25 150.62,62.4 151.19,62.97
Net_2099 on TOP_-MB (solid shape): 27.48,26.37 25.68,26.37 25.68,27.57 27.48,27.57
Net_2100 on TOP_-MB (solid shape): 27.48,10.78 25.68,10.78 25.68,11.97 27.48,11.97
Net_2106 on TOP_-MB (solid shape): 110.23,82.1 109.82,82.1 109.82,82.55 109.58,82.55 109.58,82.1 109.18,82.1 109.18,82.55 108.94,82.55 108.94,82.1 108.53,82.1 108.53,82.78 110.23,82.78
Net_2108 on TOP_-MB (solid shape): 96.91,32.72 96.22,32.72 96.22,33.12 96.68,33.12 96.68,33.36 96.22,33.36 96.22,33.77 96.68,33.77 96.68,34.01 96.22,34.01 96.22,34.42 96.91,34.42
Net_2208 on TOP_-MB (solid shape): 183.57,23.42 182.1,23.42 182.1,24.31 183.57,24.31
Net_2209 on TOP_-MB (solid shape): 183.57,21.8 182.1,21.8 182.1,22.69 183.57,22.69
Net_2210 on TOP_-MB (solid shape): 181.82,23.42 180.34,23.42 180.34,24.31 181.82,24.31
Net_2211 on TOP_-MB (solid shape): 181.82,21.8 180.34,21.8 180.34,22.69 181.82,22.69
Net_2212 on TOP_-MB (solid shape): 130.91,9.92 129.44,9.92 129.44,10.81 130.91,10.81
Net_2213 on TOP_-MB (solid shape): 129.18,10.04 127.71,10.04 127.71,10.92 129.18,10.92
Net_2214 on TOP_-MB (solid shape): 130.91,8.29 129.44,8.29 129.44,9.18 130.91,9.18
Net_2215 on TOP_-MB (solid shape): 129.18,8.41 127.71,8.41 127.71,9.3 129.18,9.3
Net_2216 on TOP_-MB (solid shape): 62.75,81.2 61.28,81.2 61.28,82.09 62.75,82.09
Net_2217 on TOP_-MB (solid shape): 62.75,79.57 61.28,79.57 61.28,80.46 62.75,80.46
Net_2218 on TOP_-MB (solid shape): 35.33,71.98 33.86,71.98 33.86,72.87 35.33,72.87
Net_2219 on TOP_-MB (solid shape): 35.33,70.36 33.86,70.36 33.86,71.25 35.33,71.25
Net_2220 on TOP_-MB (solid shape): 35.51,42.47 34.03,42.47 34.03,43.36 35.51,43.36
Net_2221 on TOP_-MB (solid shape): 35.51,40.85 34.03,40.85 34.03,41.74 35.51,41.74
Net_2359 on TOP_-MB (solid shape): 152.8,33.14 152.02,33.14 152.02,38.35 152.8,38.35
Net_2360 on TOP_-MB (solid shape): 137.59,33.14 136.81,33.14 136.81,38.35 137.59,38.35
Net_2361 on TOP_-MB (solid shape): 130.56,15.66 129.77,15.66 129.77,20.87 130.56,20.87
Net_3989 on TOP_-MB (solid shape): 155.45,58.83 155.87,58.42 155.87,58.28 155.36,57.77 155.22,57.77 154.81,58.19 154.81,58.33 155.31,58.83
Net_3990 on TOP_-MB (solid shape): 156.39,57.9 156.8,57.49 156.8,57.34 156.3,56.84 156.15,56.84 155.74,57.25 155.74,57.4 156.24,57.9
Net_4124 on TOP_-MB (solid shape): 162.2,62.36 162.61,61.94 162.61,61.8 162.11,61.3 161.96,61.3 161.55,61.71 161.55,61.85 162.05,62.36
Net_4125 on TOP_-MB (solid shape): 161.26,63.29 161.67,62.88 161.67,62.73 161.17,62.23 161.03,62.23 160.62,62.64 160.62,62.79 161.12,63.29
Net_4133 on TOP_-MB (solid shape): 3.2,18.74 0.41,18.74 0.41,19.6 3.2,19.6
Net_4423 on TOP_-MB (solid shape): 92.43,4.1 92.43,3.28 92.33,3.18 91.46,3.18 91.35,3.28 91.35,4.1 91.46,4.2 92.33,4.2
Net_4427 on TOP_-MB (solid shape): 112.04,55.45 111.05,55.45 110.95,55.55 110.95,56.37 111.05,56.47 112.04,56.47
Net_4428 on TOP_-MB (solid shape): 151.51,33.14 148.61,33.14 148.61,38.35 151.51,38.35
Net_4429 on TOP_-MB (solid shape): 141,33.14 138.1,33.14 138.1,38.35 141,38.35
Net_4430 on TOP_-MB (solid shape): 133.96,15.66 131.07,15.66 131.07,20.87 133.96,20.87
Net_4497 on TOP_-MB (solid shape): 184.59,13.28 180.83,13.28 180.83,17.04 184.59,17.04
Net_4610 on TOP_-MB (solid shape): 123,9.92 121.96,9.92 121.96,13.93 123,13.93
Net_4611 on TOP_-MB (solid shape): 121.26,9.92 120.22,9.92 120.22,13.93 121.26,13.93
Net_4730 on TOP_-MB (solid shape): 91.4,4.1 91.4,3.28 91.3,3.18 90.43,3.18 90.32,3.28 90.32,4.1 90.43,4.2 91.3,4.2
Net_4877 on TOP_-MB (solid shape): 137.89,85.22 137.43,85.22 137.43,84.98 137.89,84.98 137.89,84.57 137.43,84.57 137.43,84.33 137.89,84.33 137.89,83.92 137.2,83.92 137.2,85.62 137.89,85.62
Net_4983 on TOP_-MB (solid shape): 14.24,18.89 10.91,18.89 10.91,19.6 14.24,19.6
Net_4984 on TOP_-MB (solid shape): 14.24,5.94 10.91,5.94 10.91,6.65 14.24,6.65
Net_4992 on TOP_-MB (solid shape): 113.06,56.37 113.06,55.55 112.96,55.45 111.97,55.45 111.97,56.47 112.96,56.47
Net_5012 on TOP_-MB (solid shape): 110.87,80.37 109.02,80.37 109.02,81.39 110.87,81.39
Net_5013 on TOP_-MB (solid shape): 110.87,77.68 109.02,77.68 109.02,78.69 110.87,78.69
Net_5014 on TOP_-MB (solid shape): 92.58,79.76 90.73,79.76 90.73,80.78 92.58,80.78
Net_5015 on TOP_-MB (solid shape): 92.58,77.07 90.73,77.07 90.73,78.08 92.58,78.08
Net_5016 on TOP_-MB (solid shape): 69.09,79.63 67.23,79.63 67.23,80.65 69.09,80.65
Net_5017 on TOP_-MB (solid shape): 69.09,76.94 67.23,76.94 67.23,77.96 69.09,77.96
Net_5018 on TOP_-MB (solid shape): 47.69,51.17 45.83,51.17 45.83,52.18 47.69,52.18
Net_5019 on TOP_-MB (solid shape): 47.69,48.47 45.83,48.47 45.83,49.49 47.69,49.49
Net_9322 on TOP_-MB (solid shape): 141.2,19.47 140.57,18.85 139.53,19.89 140.16,20.52
Net_9323 on TOP_-MB (solid shape): 140.05,18.32 139.42,17.7 138.38,18.74 139.01,19.37
Net_9466 on TOP_-MB (solid shape): 137.86,9.79 132.66,9.79 132.66,10.58 137.86,10.58
Net_9586 on TOP_-MB (solid shape): 60.84,79.28 59.24,79.28 59.24,80.17 60.84,80.17
Net_9587 on TOP_-MB (solid shape): 60.84,77.55 59.24,77.55 59.24,78.43 60.84,78.43
Net_9588 on TOP_-MB (solid shape): 2.23,5.94 0.41,5.94 0.41,7.08 2.23,7.08
Net_9592 on TOP_-MB (solid shape): 104.59,86 102.89,86 102.89,86.94 104.59,86.94
Net_9593 on TOP_-MB (solid shape): 4.75,72.27 3.25,72.27 3.25,73.27 4.75,73.27
Net_9594 on TOP_-MB (solid shape): 4.75,69.27 3.25,69.27 3.25,70.27 4.75,70.27
Net_9609 on TOP_-MB (solid shape): 107.49,34.27 106.22,34.27 106.22,36.02 107.49,36.02
Net_9610 on TOP_-MB (solid shape): 105.03,34.27 103.76,34.27 103.76,36.02 105.03,36.02
Net_9611 on TOP_-MB (solid shape): 158.29,59.41 158.79,58.91 158.79,58.77 158.38,58.35 158.24,58.35 157.73,58.86 157.73,59 158.15,59.41
Net_9612 on TOP_-MB (solid shape): 159.22,60.35 159.73,59.84 159.73,59.7 159.31,59.29 159.17,59.29 158.67,59.79 158.67,59.93 159.08,60.35
Net_9613 on TOP_-MB (solid shape): 154.55,61.17 155.06,60.66 155.06,60.52 154.64,60.11 154.5,60.11 154,60.61 154,60.75 154.41,61.17
Net_9614 on TOP_-MB (solid shape): 153.62,60.23 154.12,59.73 154.12,59.59 153.71,59.17 153.57,59.17 153.06,59.68 153.06,59.82 153.48,60.23
Net_9615 on TOP_-MB (solid shape): 58.78,35.02 59.28,34.52 59.28,34.38 58.87,33.96 58.73,33.96 58.22,34.47 58.22,34.61 58.64,35.02
Net_9616 on TOP_-MB (solid shape): 59.72,35.96 60.22,35.45 60.22,35.31 59.81,34.9 59.66,34.9 59.16,35.4 59.16,35.54 59.57,35.96
Net_9617 on TOP_-MB (solid shape): 57.87,35.82 58.37,35.32 58.37,35.18 57.96,34.76 57.81,34.76 57.31,35.27 57.31,35.41 57.72,35.82
Net_9618 on TOP_-MB (solid shape): 58.8,36.76 59.3,36.25 59.3,36.11 58.89,35.7 58.75,35.7 58.24,36.2 58.24,36.34 58.66,36.76
Net_9619 on TOP_-MB (solid shape): 42.35,77.66 41.05,77.66 41.05,79.67 42.35,79.67
Net_9620 on TOP_-MB (solid shape): 38.16,77.66 36.87,77.66 36.87,79.67 38.16,79.67
Net_9624 on TOP_-MB (solid shape): 110.3,83.01 107.81,83.01 107.81,84.69 110.3,84.69
Net_9652 on TOP_-MB (solid shape): 136.97,83.2 135.29,83.2 135.29,85.69 136.97,85.69
Net_9653 on TOP_-MB (solid shape): 98.81,32.65 97.14,32.65 97.14,35.14 98.81,35.14
Net_9674 on TOP_-MB (solid shape): 37.02,35.98 35.68,35.98 35.68,37.53 37.02,37.53
Net_9675 on TOP_-MB (solid shape): 38.3,35.98 36.97,35.98 36.97,37.53 38.3,37.53
Net_9691 on TOP_-MB (solid shape): 99.78,29.27 99.78,25.84 99.66,25.71 97.12,25.71 96.99,25.84 96.99,26.31 97.51,26.31 97.51,26.05 98.02,26.05 98.02,26.31 98.27,26.31 98.27,26.05 98.78,26.05 98.78,26.09 98.79,26.12 98.81,26.14 98.84,26.16 98.87,26.17 98.89,26.17 98.92,26.16 98.95,26.15 99.03,26.05 99.54,26.05 99.54,26.31 99.29,26.31 98.98,26.65 98.73,26.65 98.52,26.31 98.02,26.31 98.04,26.4 98.04,26.65 97.79,26.65 97.51,26.31 96.99,26.31 96.99,27.31 98.98,27.31 98.98,27.84 98.73,27.84 98.73,27.31 98.04,27.31 98.04,27.84 97.79,27.84 97.79,27.31 96.99,27.31 96.99,29.01 97.35,29.01 97.35,28.76 97.6,28.76 97.62,28.78 98.39,28.78 98.73,28.5 98.98,28.5 99.17,28.76 99.43,28.76 99.43,29.01 99.17,29.01 99.15,29.04 98.89,29.04 98.86,28.99 98.84,28.97 98.82,28.95 98.79,28.95 98.76,28.95 98.73,28.96 98.64,29.04 98.13,29.04 98.13,28.78 97.88,28.78 97.88,29.04 97.62,29.04 97.6,29.01 96.99,29.01 96.99,29.27 97.12,29.39 99.66,29.39
Net_9692 on TOP_-MB (solid shape): 81.37,28.88 81.37,26.09 81.24,25.96 78.83,25.96 78.57,26.22 78.57,26.32 80.35,26.32 80.35,26.57 80.1,26.57 80.1,26.32 79.84,26.32 79.84,26.57 79.34,26.57 79.34,26.32 79.08,26.32 79.08,26.57 78.83,26.57 78.83,26.32 78.57,26.32 78.57,26.85 80.64,26.85 80.64,27.11 80.39,27.11 80.39,26.85 78.57,26.85 78.57,27.92 79.63,27.92 79.63,28.17 79.37,28.17 79.37,27.92 78.57,27.92 78.57,28.33 81.09,28.33 81.09,28.58 80.84,28.58 80.84,28.33 78.57,28.33 78.57,28.88 78.7,29.01 81.24,29.01
Net_9693 on TOP_-MB (solid shape): 75.96,29.45 76.02,29.54 76.13,29.52 76.18,29.47 76.18,27.91 76.06,27.79 75.31,27.79 75.31,28.18 75.5,28.37 75.67,28.37 75.96,28.66 75.96,29.37
Net_9695 on TOP_-MB (solid shape): 61.94,30.92 61.94,29.39 61.81,29.27 59.52,29.27 59.4,29.39 59.4,29.76 59.86,29.76 59.86,29.51 60.11,29.51 60.16,29.62 60.92,29.62 60.92,29.88 60.67,29.88 60.67,29.62 60.41,29.62 60.41,29.88 60.16,29.88 60.11,29.76 59.4,29.76 59.4,30.3 59.85,30.3 59.86,30.27 59.86,30.01 60.11,30.01 60.11,30.23 61.01,30.23 61.01,29.98 61.26,29.98 61.59,30.31 61.59,30.56 61.34,30.56 61.01,30.23 60.11,30.23 60.11,30.3 60.11,30.55 59.85,30.55 59.85,30.3 59.4,30.3 59.4,30.92 59.52,31.04 61.81,31.04
Net_9696 on TOP_-MB (solid shape): outline of 143 points within 87.28,51.54 89.99,58.9
Net_9697 on TOP_-MB (solid shape): outline of 2503 points within 0.51,0.51 197.49,89.49
Net_9698 on TOP_-MB (solid shape): outline of 153 points within 34.71,1.33 60.46,3.99
Net_9699 on TOP_-MB (solid shape): outline of 160 points within 64.1,1.58 73.24,4.5
Net_9700 on TOP_-MB (solid shape): 78.57,3.56 78.57,3.11 78.73,2.95 78.81,2.95 78.82,2.95 79,2.91 79.17,2.95 79.2,2.95 79.37,2.79 79.37,2.36 79.25,2.24 78.07,2.24 77.94,2.37 77.94,3.04 78.01,3.24 77.95,3.45 77.94,3.46 77.94,3.59 78.04,3.69 78.45,3.69
Net_9701 on TOP_-MB (solid shape): 114.92,6.44 114.92,6.04 114.03,5.15 113.58,5.15 113.54,5.1 113.53,5.1 113.28,4.82 113.39,4.47 113.42,4.44 113.49,4.39 113.58,4.36 113.59,4.36 113.7,4.25 113.7,4.01 113.45,3.76 113.16,3.76 112.46,4.46 112.46,4.71 112.42,4.76 112.42,4.76 112.34,4.86 112.24,4.93 112.22,4.95 112.2,4.95 112.07,4.97 111.95,4.95 111.95,4.95 111.59,4.95 111.58,4.96 111.43,4.99 111.27,4.95 111.25,4.95 110.51,5.69 110.51,6.32 110.91,6.72 114.65,6.72
Net_9702 on TOP_-MB (solid shape): 116.83,10.23 116.97,10.23 116.98,10.21 116.98,6.02 117.06,5.94 117.06,5.8 117.51,5.34 117.51,4.51 117.51,4.51 117.51,4.16 117.29,3.95 116.36,3.95 116.26,4.04 116.26,5.88 116.25,5.89 116.25,5.93 116.21,5.93 116.01,6.13 116.01,6.78 116.34,7.11 116.34,7.11 116.44,7.21 116.44,9.39 116.22,9.61 116.22,10.21 116.25,10.25 116.81,10.25
Net_9703 on TOP_-MB (solid shape): 121.18,6.25 121.18,5.89 121.28,5.78 122.73,5.78 122.84,5.9 122.84,6.2 122.99,6.34 123.31,6.34 123.46,6.2 123.46,5.69 123.86,5.29 125.72,5.29 125.74,5.27 126.55,5.27 126.55,4.17 126.43,4.05 125.62,4.05 125.29,4.37 124.04,4.37 123.92,4.5 126.44,4.5 126.44,4.71 125.67,4.71 125.67,4.5 123.92,4.5 123.74,4.68 123.62,4.68 123.59,4.69 123.54,4.71 123.49,4.71 123.43,4.71 123.38,4.71 123.34,4.69 123.3,4.68 120.95,4.68 120.95,4.76 120.95,4.81 120.93,4.87 120.91,4.92 122.11,4.92 122.11,5.68 121.9,5.68 121.9,4.92 120.91,4.92 120.88,4.96 120.84,5.01 120.8,5.04 120.75,5.07 120.7,5.09 120.65,5.11 120.59,5.11 120.54,5.11 120.1,5.55 120.83,5.55 120.83,5.81 120.57,5.81 120.57,5.55 120.1,5.55 120,5.66 120.01,6.06 120.83,6.06 120.83,6.31 120.57,6.31 120.57,6.06 120.01,6.06 120.01,6.14 120.01,6.18 119.99,6.22 119.97,6.25 119.97,6.47 120.01,6.51 120.92,6.51
Net_9704 on TOP_-MB (solid shape): outline of 157 points within 63,4.22 79.08,7.19
Net_9705 on TOP_-MB (solid shape): 160.62,7.4 160.62,6.33 161.25,5.69 161.25,5.26 161.21,5.22 160.25,5.22 160.02,4.98 160.01,4.98 159.45,5.54 159.45,7.27 159.65,7.47 160.54,7.47
Net_9706 on TOP_-MB (solid shape): 162.19,7.25 162.19,6.58 162.19,6.58 162.19,6.48 162.72,5.95 162.72,5.54 162.7,5.52 162.7,5.22 162.14,5.22 162.06,5.26 162.04,5.34 162.02,5.5 161.94,5.65 161.94,5.77 161.15,6.56 161.15,7.32 161.18,7.35 162.09,7.35
Net_9707 on TOP_-MB (solid shape): 163.74,7.28 163.74,7.28 163.91,7.1 163.91,5.66 163.47,5.22 163,5.22 162.98,5.22 162.95,5.23 162.93,5.25 162.91,5.27 162.9,5.29 162.9,5.32 162.9,5.37 162.9,5.43 162.9,5.49 162.89,5.55 162.87,5.6 162.85,5.63 162.85,6 162.36,6.5 163.46,6.5 163.46,6.75 163.21,6.75 163.21,6.5 162.36,6.5 162.32,6.53 162.32,6.63 162.32,6.64 162.32,7.38 162.43,7.5 163.53,7.5
Net_9708 on TOP_-MB (solid shape): 159.25,7.4 159.25,5.52 159.07,5.34 158.31,5.34 158.24,5.4 158.24,7.21 158.48,7.45 159.19,7.45
Net_9709 on TOP_-MB (solid shape): 177,9.07 177,8.69 176.75,8.44 176.75,7.76 176.75,6.97 176.75,6.97 176.75,6.53 176.49,6.28 174.5,6.28 174.48,6.3 172.08,6.3 172.06,6.28 171.79,6.28 171.41,6.66 171.41,6.91 171.54,7.04 172.16,7.04 172.33,6.87 173.09,6.87 173.09,6.87 173.84,6.87 173.89,6.91 174.88,6.91 175.07,6.86 175.26,6.91 175.67,6.91 175.85,6.86 176.03,6.91 176.04,6.91 176.11,6.91 176.24,7.04 176.24,8.56 176.36,8.69 176.36,9.07 176.49,9.2 176.87,9.2
Net_9710 on TOP_-MB (solid shape): 127.45,9.32 131.16,9.32 131.76,8.73 131.76,8.71 132.15,8.32 132.15,8.31 132.39,8.08 133.58,8.08 134.1,7.55 134.33,7.55 134.33,7.55 134.44,7.55 134.46,7.56 135.45,7.56 135.62,7.39 135.62,6.9 135.49,6.77 129.06,6.77 128.88,6.95 128.71,6.95 128.13,7.53 127.71,7.53 127.56,7.68 127.56,7.96 128.26,7.96 128.26,8.22 128,8.22 128,7.96 127.56,7.96 127.56,8.3 127.57,8.33 127.59,8.38 127.59,8.43 127.59,8.48 127.59,8.53 127.57,8.58 127.56,8.61 127.56,8.67 127.2,9.03 126.78,9.03 126.66,9.15 126.66,9.41 126.68,9.46 126.86,9.64 127.14,9.64
Net_9711 on TOP_-MB (solid shape): outline of 96 points within 132.42,7.67 141.34,13.49
Net_9712 on TOP_-MB (solid shape): 163.28,10.7 163.28,9.86 163.13,9.71 162.5,9.71 162.47,9.73 162.39,9.73 162.33,9.66 162.31,9.66 162.22,9.61 162.17,9.52 162.17,9.51 162.09,9.43 162.09,7.88 161.94,7.73 161.2,7.73 161.06,7.86 161.06,8.63 161.38,8.95 161.38,10.22 162.34,11.18 162.8,11.18
Net_9713 on TOP_-MB (solid shape): 165.8,10.32 165.8,9.68 163.84,7.73 162.45,7.73 162.29,7.88 162.29,8.49 162.6,8.79 163.49,8.79 163.6,8.9 164.39,8.9 164.39,9.16 164.13,9.16 164.13,8.9 163.6,8.9 163.79,9.1 163.79,9.41 164.39,9.41 164.39,9.67 164.13,9.67 164.13,9.41 163.79,9.41 163.79,9.49 163.87,9.56 163.87,9.96 164.63,10.72 165.39,10.72
Net_9714 on TOP_-MB (solid shape): 161.66,12.35 161.66,10.93 161.28,10.55 161.28,10.29 161.25,10.27 161.25,9.99 160.92,9.65 160.73,9.65 160.62,9.62 160.55,9.52 160.55,9.51 160.46,9.43 160.46,8.97 160.59,8.84 160.59,7.9 160.41,7.73 159.7,7.73 159.42,8.01 159.42,8.82 159.8,9.2 159.8,9.66 160.41,10.27 160.41,11.84 161.07,12.5 161.51,12.5
Net_9715 on TOP_-MB (solid shape): 160.24,11.03 160.24,10.27 159.68,9.71 159.68,9.63 159.63,9.58 159.63,9.23 159.32,8.92 159.32,8.9 159.3,8.87 159.3,7.98 159.17,7.85 158.36,7.85 158.24,7.97 158.24,8.76 158.33,8.84 158.43,8.84 158.76,9.17 158.76,9.18 159.03,9.45 159.03,9.85 159.06,9.88 159.06,10.64 159.63,11.21 160.06,11.21
Net_9716 on TOP_-MB (solid shape): 181.85,9.78 182.74,9.78 182.87,9.66 182.87,8.96 182.31,8.41 182.31,8.36 181.72,7.78 180.96,7.78 180.71,8.03 180.71,8.14 181.12,8.14 181.12,8.39 181.37,8.39 181.37,8.14 181.63,8.14 181.63,8.39 181.99,8.75 181.99,9 181.74,9 181.41,8.72 181.41,8.47 181.37,8.39 180.87,8.39 180.87,8.14 180.71,8.14 180.71,8.37 180.73,8.38 180.73,9.38 181.66,9.38 181.66,9.63 181.41,9.63 181.41,9.38 180.73,9.38 180.73,9.72 180.71,9.73 180.71,9.81 181.09,10.19 181.44,10.19
Net_9717 on TOP_-MB (solid shape): outline of 96 points within 187.59,8.97 192.29,13.19
Net_9718 on TOP_-MB (solid shape): 112.42,10.88 112.44,10.84 112.47,10.82 112.5,10.79 112.54,10.78 112.58,10.77 112.6,10.77 112.98,10.77 113,10.77 113.03,10.77 113.09,10.79 113.12,10.78 113.15,10.77 113.17,10.75 113.18,10.73 113.19,10.69 113.19,9.6 112.71,9.12 109.22,9.12 108.93,9.41 108.93,9.66 109.25,9.98 110.82,9.98 110.85,10.01 112.66,10.01 112.66,10.26 112.41,10.26 112.41,10.01 110.85,10.01 111.77,10.93 112.4,10.93
Net_9719 on TOP_-MB (solid shape): outline of 3453 points within 121.95,9.45 188.07,60.97
Net_9720 on TOP_-MB (solid shape): 183.04,11.52 183.5,11.06 183.5,9.81 183.38,9.68 183.02,9.68 182.98,9.72 182.89,9.81 182.89,10.21 182.9,10.26 182.91,10.3 182.91,10.88 182.87,11 182.78,11.09 182.75,11.1 182.75,11.56 182.8,11.61 183.04,11.61
Net_9721 on TOP_-MB (solid shape): 121.35,13.93 121.35,9.97 121.24,9.87 120.09,9.87 119.33,10.63 118.63,10.63 118.29,10.98 118.29,12.44 119.88,14.02 121.26,14.02
Net_9722 on TOP_-MB (solid shape): outline of 164 points within 172.92,10.93 179.85,13.41
Net_9723 on TOP_-MB (solid shape): outline of 84 points within 20.13,11.1 24.51,12.68
Net_9724 on TOP_-MB (solid shape): 139.99,18.68 140.56,18.68 140.57,18.67 140.58,18.68 140.75,18.68 141.18,19.11 142.97,19.11 143.06,19.03 143.17,19.03 143.28,18.91 143.6,18.91 143.75,18.76 143.75,16.54 140.86,13.64 139.76,13.64 139.51,13.39 139.51,12.98 139.53,12.89 139.53,12.88 139.53,12.32 138.04,10.83 132.85,10.83 132.28,11.4 132.28,11.83 132.29,11.85 132.31,12.13 132.17,12.38 132.17,13.59 132.21,13.6 132.49,13.75 132.61,14.03 132.62,14.05 132.82,14.25 137.45,14.25 137.46,14.26 137.67,14.26 137.67,14.43 137.86,14.62 137.86,18.32 138.75,19.21 139.46,19.21
Net_9725 on TOP_-MB (solid shape): 167.18,15.92 167.18,15.27 167.29,15.16 167.35,15.16 167.36,15.14 167.39,15.11 167.43,15.08 167.47,15.06 167.52,15.05 167.54,15.05 168.1,15.05 168.53,14.62 169.81,14.62 169.81,14.07 169.57,13.83 169.57,12.37 169.43,12.23 167.71,12.23 167.45,11.97 166.91,11.97 165.76,13.12 169.33,13.12 169.33,13.37 169.08,13.37 169.08,13.12 165.76,13.12 165.43,13.45 165.43,13.63 169.33,13.63 169.33,13.88 169.08,13.88 169.08,13.63 165.43,13.63 165.43,13.73 168.48,13.73 168.48,13.99 168.23,13.99 168.23,13.73 167.57,13.73 167.57,13.99 167.31,13.99 167.31,13.73 165.43,13.73 165.43,14.52 167.57,14.52 167.57,14.77 167.31,14.77 167.31,14.52 165.43,14.52 165.43,15.39 166.28,15.39 166.32,15.38 166.57,15.38 166.57,15.63 166.32,15.63 166.28,15.64 166.03,15.64 166.03,15.39 165.43,15.39 165.43,15.93 165.59,16.09 167.01,16.09
Net_9726 on TOP_-MB (solid shape): 175.36,13.05 177.35,13.05 177.47,12.93 177.47,12.39 177.24,12.15 174.39,12.15 174.24,12.31 177.05,12.31 177.05,12.56 176.8,12.56 176.8,12.31 174.24,12.31 174.22,12.33 174.22,13.2 173.98,13.44 173.98,13.57 174.11,13.7 174.7,13.7
Net_9727 on TOP_-MB (solid shape): 134.06,20.78 134.06,15.72 133.74,15.4 132.85,15.4 132.85,15.4 132.57,15.4 131.84,14.67 131.84,14.53 131.69,14.38 131.69,14.27 131.69,14.26 131.67,13.95 131.84,13.69 131.84,13.16 131.28,12.6 129.45,12.6 128.97,13.09 128.97,14.05 130.33,15.41 130.8,15.41 131.06,15.67 131.06,20.84 131.19,20.96 133.88,20.96
Net_9728 on TOP_-MB (solid shape): 164.97,14.9 164.97,13.38 164.61,13.02 164.51,12.95 163.33,12.95 163,13.28 163,14.31 163.77,14.31 163.77,14.56 163.51,14.56 163.51,14.31 163,14.31 163,14.43 163.66,15.09 163.72,15.13 164.74,15.13
Net_9729 on TOP_-MB (solid shape): 138.88,20.84 138.88,19.72 137.73,18.57 137.73,14.67 137.46,14.4 134.35,14.4 134.24,14.51 134.24,19.04 134.6,19.41 136.38,19.41 136.74,19.77 136.74,20.25 138.42,20.25 138.42,20.5 138.16,20.5 138.16,20.25 136.74,20.25 136.74,20.27 137.59,21.11 138.61,21.11
Net_9730 on TOP_-MB (solid shape): outline of 510 points within 45.17,14.66 113.9,23.68
Net_9731 on TOP_-MB (solid shape): 119.72,19.21 119.73,19.19 119.73,19.16 119.72,19.13 119.68,19.08 119.64,19.04 119.61,18.99 119.59,18.94 119.58,18.89 119.57,18.84 119.57,18.78 119.58,18.73 119.59,18.68 119.62,18.63 119.65,18.59 119.68,18.54 119.72,18.51 119.77,18.48 119.82,18.46 119.87,18.44 119.94,18.43 119.94,15.26 119.72,15.04 118.98,15.04 118.92,15.11 118.89,15.11 118.33,15.66 118.33,15.67 118.22,15.84 118.22,16.08 118.24,16.09 118.29,16.13 118.32,16.17 118.36,16.22 118.38,16.27 118.4,16.32 118.41,16.38 118.41,16.44 118.4,16.49 118.38,16.55 118.36,16.6 118.32,16.64 118.29,16.69 118.24,16.72 118.22,16.74 118.22,16.83 118.2,16.85 119.47,16.85 119.47,17.1 119.21,17.1 119.21,16.85 118.2,16.85 118.07,16.97 118.07,17.35 119.47,17.35 119.47,17.61 119.21,17.61 119.21,17.35 118.07,17.35 118.07,18.89 118.5,19.31 119.63,19.31
