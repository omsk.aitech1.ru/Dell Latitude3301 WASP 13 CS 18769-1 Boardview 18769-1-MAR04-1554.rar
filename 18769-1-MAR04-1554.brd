# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FP1_USB20_P: length 83.9
  L3 w0.089: v2(107.23,61.84) 107.5,61.56 107.5,61.53 107.61,61.42 107.61,61.12 109.17,59.56 110.24,59.56 112.29,57.5 112.29,57.05 113.92,55.42 117.01,55.42 120.81,51.62 121.32,51.62 122.72,50.22 122.72,45.25 123.19,44.78 123.19,37.87 123.27,37.8 123.27,33.51 123.01,33.25 123.01,32.49 123.01,26.24 122.21,25.43 122.21,25.42 122,25.22 122,9.01 121.88,8.89 121.88,6.29 123.01,5.16 123.93,5.16 124.89,4.2 129.88,4.2 131.38,5.7 135.19,5.7 136.09,4.8 136.09,4.68 v2(135.84,4.43)
  BOTTOM w0.102: v2(135.84,4.43) 135.04,5.23 R9210.1 ; v2(107.23,61.84) 107.23,61.85 107.28,61.85 107.6,62.18 CPU1.CG6
FP_3D3V: length 5.6
  TOP w0.508: v2(144.58,8.41) 144.58,8.63 144.39,8.81 R9213.1
  BOTTOM w0.305: v2(144.58,8.41) 144.75,8.23 144.75,5.86 v1(145.38,5.23) 145.5,5.1 Q9201.D
FP_EN#: length 4.1
  BOTTOM w0.102: Q9202.D 147.89,7.38 R9212.2 147.89,6.74 147.45,6.3 147.45,5.29 Q9201.G 148.25,4.49 v1(148.25,4.19)
FPR_SCAN#: length 124.6
  TOP w0.102: R9201.2 141.59,8.61 141.48,8.72 139.99,8.72 v2(139.59,8.32) 139.59,8.31 139.59,8.29 139.21,7.91 137.07,7.91 135.72,6.57 131.35,6.57 128.48,3.7 115.97,3.7 v2(114.94,4.73)
  L3 w0.102: v2(40.81,14.38) 41.45,15.03 42.59,15.03 42.63,14.99 72.27,14.99 72.53,14.73 89.14,14.73 89.47,14.4 95.45,14.4 96.82,13.02 107.14,13.02 114.94,5.22 v2(114.94,4.73)
  BOTTOM w0.102: v2(40.81,14.38) 40.81,16.6 41.05,16.84 41.05,18.5 39.87,19.68 39.87,20.29 39.27,20.89 37.89,20.89 36.97,21.81 34.61,21.81 34.32,22.1 34.12,22.1 v1(33.93,22.29) 33.55,22.67 U2401.42 ; v2(139.59,8.32) 139.35,8.57 FP1.7
FWP/GPIO2: length 3.3
  BOTTOM w0.102: 12.39,13.07 12.28,13.07 11.92,13.44 11.44,13.44 11.28,13.6 U3301.29 ; 12.39,13.07 v1(12.4,13.07) ; 12.39,13.07 13.18,13.07 R3314.1
GC6_FB_EN: length 71.1
  TOP w0.102: v2(138.88,48.94) 139.67,48.94 Q7907.3 ; v2(166.28,48.54) 166.2,48.62 164.69,48.62 163.27,47.2 159.36,47.2 157.33,49.22 148.72,49.22 v2(148.18,49.76)
  L3 w0.102: v2(185.13,40.98) 185.52,40.59 185.52,38.25 180.6,33.33 180.09,33.33 179.09,34.33 175.38,34.33 174.28,35.42 173.33,35.42 171.72,37.03 171.72,44.87 168.35,48.24 168.18,48.24 168.08,48.24 167.3,49.03 166.58,49.03 166.28,48.73 v2(166.28,48.54)
  L8 w0.102: v2(148.18,49.76) 147.98,49.55 146,49.55 145.83,49.72 145.47,49.72 145.35,49.6 145.04,49.6 144.71,49.27 140.43,49.27 140.1,48.94 v2(138.88,48.94)
  BOTTOM w0.102: R2004.1 137.26,48.94 v1(138.11,48.94) v2(138.88,48.94) ; v2(148.18,49.76) 148.15,49.72 R7937.2 ; v2(185.13,40.98) 185.19,41.04 D8601.1 186.08,42.23 R7953.2
GC6_FB_EN_GPU: length 19.4
  TOP w0.102: v2(148.94,49.65) 148.3,50.29 142.48,50.29 142.27,50.5 140.8,50.5 140.58,50.28 140.58,49.66 140.4,49.48 Q7907.2
  BOTTOM w0.102: v2(148.94,49.65) 149.02,49.58 R7937.1 149.73,48.94 R7927.1 149.87,49.08 v1(151.12,49.08) 155.61,49.08 155.94,49.41 155.99,49.41 156.2,49.62 156.2,49.67 156.3,49.76 156.98,49.76
GC6_FB_EN_GPU_L: length 6
  TOP w0.102: Q7907.6 Q7907.5 v1(143.7,49.48) 145.54,49.48 145.65,49.38 v2(145.65,49.29)
  BOTTOM w0.102: R7952.2 145.39,49.77 145.65,49.51 v2(145.65,49.29)
GC6_FB_EN_MCP: length 38.8
  L6 w0.102: v2(107,48.15) 107.45,47.7 107.45,46.7 107.73,46.41 108.09,46.41 108.39,46.71 108.39,48.93 108.7,49.24 109.88,49.24 113.19,45.92 113.19,45.39 113.8,44.79 114.65,44.79 115.92,46.06 122.82,46.06 123.77,47.01 134.57,47.01 135.59,48.03 v2(135.59,48.4)
  BOTTOM w0.102: v2(107,48.15) 107,48.14 106.65,48.49 CPU1.CE28 ; v2(135.59,48.4) 135.86,48.4 R2004.2 136.3,49.21 v1(135.8,49.71)
GC6_PWR_EN: length 2.5
  BOTTOM w0.102: v1(141.24,74.58) 141.24,75.11 R8626.2 140.42,75.93 U8605.2
GC6_THM_DIS#: length 151.5
  TOP w0.102: v2(40.76,29.85) 40.49,29.85 v1(40.19,30.15)
  L3 w0.102: v2(119.95,18.82) 120.52,19.38 120.52,20.49 121.03,21.01 121.03,24.06 120.38,24.71 120.37,24.71 120.12,24.97 120.12,27.36 120.03,27.44 120.03,27.8 120.26,28.03 120.26,30.24 121.01,30.99 121.01,34.08 121.27,34.34 121.27,36.97 121.12,37.12 121.12,37.67 120.24,38.55 119.7,38.55 116.28,41.97 116.28,44.83 118.84,47.4 118.84,48.38 118.64,48.58 118.64,48.66 117.74,49.56 v2(116.9,49.56)
  L5 w0.102: v2(25.57,31.37) 25.83,31.1 27.3,31.1 27.98,31.78 28.94,31.78 29.65,31.07 32.17,31.07 32.17,31.07 39.54,31.07 v2(40.76,29.85)
  BOTTOM w0.102: v2(119.95,18.82) 118.73,18.82 116.88,16.96 116.88,16.24 116.25,15.29 116.25,14.54 116.12,14.42 115.79,14.08 114.8,14.08 111.43,17.45 55.04,17.45 52.95,19.54 47.02,19.54 42.93,23.62 42.93,28.84 41.92,29.85 v2(40.76,29.85) ; R2447.2 25.11,30.91 25.56,31.37 v2(25.57,31.37) ; v2(116.9,49.56) 116.54,49.2 114.97,49.2 114.44,49.72 112.97,49.72 112.87,49.82 CPU1.CR26
GC6_THM_DIS#_EC: length 5
  BOTTOM w0.102: U2401.23 27.37,28.81 26.65,29.52 R2426.1 R2471.2 25.88,29.67 R2447.1 24.73,29.67 v1(24.18,30.22)
GFX_CLK_CPU_N: length 106
  L3 w0.089: v2(91.9,71.19) 92.07,71.19 92.74,71.87 93.77,71.87 93.89,71.99 93.89,72.6 93.8,72.68 91.41,72.68 91.21,72.88 91.21,73.33 91.41,73.54 92.82,73.54 92.91,73.62 92.91,74.86 93.9,75.84 95.57,75.84 95.86,75.56 95.86,74.93 95.66,74.73 94.28,74.73 94.2,74.64 94.2,74.35 94.28,74.26 95.54,74.26 95.74,74.06 95.74,73.16 95.83,73.07 111.18,73.07 111.45,73.34 111.45,74.6 112.06,75.22 112.77,75.22 113.18,74.81 113.18,74.26 114.66,72.79 115.29,72.79 115.49,72.59 115.49,71.99 115.58,71.9 115.88,71.9 115.96,71.99 115.96,72.59 116.16,72.79 117.76,72.79 118.86,73.88 121.85,73.88 122.66,73.07 123.22,73.07 123.67,72.61 123.67,72.4 124.41,71.66 126.01,71.66 126.39,72.04 126.39,72.78 128.09,74.47 128.09,75.78 130.53,78.22 139.38,78.22 139.81,77.79 139.94,77.79 140.17,78.02 140.45,78.02 140.77,77.7 140.77,77.42 140.54,77.19 140.54,77.06 141.7,75.9 141.7,71.04 142.08,70.66 142.2,70.66 142.52,70.97 142.8,70.97 143.12,70.66 143.12,70.37 142.8,70.06 142.8,69.93 143.14,69.6 143.26,69.6 143.9,70.24 144.19,70.24 144.51,69.92 144.51,69.64 143.87,69 143.87,68.87 144.07,68.66 144.2,68.66 144.84,69.31 145.12,69.31 145.44,68.99 145.44,68.7 144.8,68.06 144.8,67.94 145.01,67.73 145.13,67.73 145.78,68.37 146.06,68.37 146.38,68.05 146.38,67.77 145.74,67.13 145.74,67 146.07,66.67 146.39,66.67 147,67.28 147.47,67.28 147.67,67.08 147.67,66.11 147.61,66.06 v2(147.6,65.51)
  BOTTOM w0.102: v2(91.9,71.19) 91.6,70.89 91,70.89 90.28,70.17 90.28,70.14 90.26,70.11 90.26,66.62 91.11,65.77 91.11,65.11 91.1,65.11 90.87,64.87 CPU1.AW2 ; GPU1.AD8 147.6,65.51 v2(147.6,65.51)
GFX_CLK_CPU_P: length 105.9
  L3 w0.089: v2(91.9,70.38) 92.33,70.38 92.42,70.46 92.42,71.27 92.82,71.67 93.84,71.67 94.08,71.91 94.08,72.67 93.88,72.87 91.49,72.87 91.4,72.96 91.4,73.26 91.49,73.34 92.9,73.34 93.1,73.55 93.1,74.78 93.97,75.65 95.49,75.65 95.67,75.48 95.67,75.01 95.58,74.92 94.21,74.92 94.01,74.72 94.01,74.27 94.21,74.07 95.46,74.07 95.55,73.98 95.55,73.08 95.75,72.88 111.26,72.88 111.64,73.26 111.64,74.52 112.14,75.03 112.69,75.03 112.99,74.73 112.99,74.18 114.58,72.59 115.21,72.59 115.3,72.51 115.3,71.91 115.5,71.71 115.95,71.71 116.15,71.91 116.15,72.51 116.24,72.59 117.84,72.59 118.94,73.69 121.77,73.69 122.58,72.88 123.14,72.88 123.48,72.53 123.48,72.32 124.33,71.47 126.09,71.47 126.58,71.96 126.58,72.7 128.28,74.4 128.28,75.7 130.61,78.03 139.3,78.03 139.73,77.6 140.01,77.6 140.25,77.83 140.37,77.83 140.58,77.63 140.58,77.5 140.35,77.27 140.35,76.99 141.51,75.82 141.51,70.96 142,70.47 142.28,70.47 142.59,70.78 142.72,70.78 142.93,70.58 142.93,70.45 142.61,70.14 142.61,69.85 143.06,69.41 143.34,69.41 143.98,70.05 144.11,70.05 144.32,69.84 144.32,69.72 143.67,69.08 143.67,68.79 143.99,68.47 144.28,68.47 144.92,69.12 145.04,69.12 145.25,68.91 145.25,68.78 144.61,68.14 144.61,67.86 144.93,67.54 145.21,67.54 145.85,68.18 145.98,68.18 146.19,67.97 146.19,67.85 145.55,67.2 145.55,66.92 145.99,66.48 146.47,66.48 147.08,67.09 147.39,67.09 147.48,67 147.48,66.24 147.33,66.1 v2(147.03,66.1)
  BOTTOM w0.102: v2(91.9,70.38) 91.9,70.44 91.69,70.66 91.09,70.66 90.51,70.08 90.51,70.04 90.49,70.02 90.49,66.72 91.34,65.87 91.34,65.85 91.34,65.84 91.34,65.14 91.35,65.13 91.35,64.57 CPU1.AY3 ; v2(147.03,66.1) GPU1.AE8
GFX_PCIE_RX_CON_N0: length 23.3
  TOP w0.102: C7602.2 130.25,66.98 134.44,62.79 143.9,62.79 145.93,64.83 148.71,64.83 148.84,64.95 v2(149.35,64.95)
  BOTTOM w0.102: GPU1.AB9 v2(149.35,64.95)
GFX_PCIE_RX_CON_N1: length 25.3
  TOP w0.102: v2(149.33,66.17) 149.51,66.36 149.51,66.56 149.41,66.67 145.8,66.67 142.82,63.69 134.64,63.69 131.12,67.21 131.12,68.17 130.52,68.78 129.85,68.78 129.74,68.67 129.74,68.58 129.67,68.51 C7604.2
  BOTTOM w0.102: GPU1.AC10 v2(149.33,66.17)
GFX_PCIE_RX_CON_N2: length 24.8
  TOP w0.102: C7606.2 132.36,70.03 135.47,73.14 139.98,73.14 145.39,67.74 149.57,67.74 149.73,67.9 v2(149.92,67.9)
  BOTTOM w0.102: GPU1.AC11 v2(149.92,67.9)
GFX_PCIE_RX_CON_N3: length 26
  TOP w0.102: v2(151.11,67.87) 150.86,67.89 150.56,68.2 150.56,68.86 149.47,69.95 144.64,69.95 140.51,74.08 135.08,74.08 134.69,73.69 133.57,73.69 132.28,72.4 C7608.2
  BOTTOM w0.102: GPU1.AB12 v2(151.11,67.87)
GFX_PCIE_RX_CON_P0: length 23.3
  TOP w0.102: C7601.2 129.86,67.21 130.35,67.21 134.54,63.02 143.8,63.02 145.83,65.05 148.62,65.05 148.76,65.2 v2(148.76,65.59)
  BOTTOM w0.102: GPU1.AC9 v2(148.76,65.59)
GFX_PCIE_RX_CON_P1: length 25.3
  TOP w0.102: C7603.2 129.59,69 130.61,69 131.35,68.27 131.35,67.31 134.74,63.92 142.72,63.92 145.7,66.9 149.5,66.9 149.67,66.73 v2(149.92,66.73)
  BOTTOM w0.102: GPU1.AB10 v2(149.92,66.73)
GFX_PCIE_RX_CON_P2: length 25.2
  TOP w0.102: v2(149.35,68.47) 149.47,68.35 149.47,68.07 149.37,67.96 145.48,67.96 140.08,73.37 135.38,73.37 132.27,70.26 129.98,70.26 129.88,70.36 129.88,70.69 129.78,70.79 C7605.2
  BOTTOM w0.102: GPU1.AD11 v2(149.35,68.47)
GFX_PCIE_RX_CON_P3: length 26.5
  TOP w0.102: C7607.2 129.51,71.43 129.8,71.43 129.96,71.59 129.96,72 130.14,72.17 132.37,72.17 133.66,73.46 134.79,73.46 135.17,73.85 140.41,73.85 144.55,69.72 149.37,69.72 150.33,68.76 150.33,68.1 150.55,67.88 v2(150.51,67.36)
  BOTTOM w0.102: GPU1.AC12 v2(150.51,67.36)
GFX_PCIE_RX_N0: length 41
  TOP w0.102: v2(102.62,60.51) 102.85,60.66 103.18,60.66 103.47,60.95 103.47,61.91 103.01,62.36 103.01,63.96 103.97,64.93 105.5,64.93 105.74,65.16 105.74,67.11 105.84,67.21 106.12,67.21 106.22,67.11 106.22,65.18 106.47,64.93 107.3,64.93 107.53,65.16 107.53,65.57 107.63,65.68 107.91,65.68 108.02,65.57 108.02,65.16 108.25,64.93 108.72,64.93 108.96,65.16 108.96,65.57 109.06,65.68 109.34,65.68 109.44,65.57 109.44,65.16 109.67,64.93 113.68,64.93 117.24,61.37 117.83,61.37 120.78,61.37 120.91,61.51 126.65,67.24 128.16,67.24 C7602.1
  BOTTOM w0.102: CPU1.BW9 102.8,60.51 v2(102.62,60.51)
GFX_PCIE_RX_N1: length 39.3
  TOP w0.102: C7604.1 128.16,68.76 127.16,68.76 120.48,62.08 117.53,62.08 114.27,65.34 114.27,66.24 113.67,66.85 110.77,66.85 110.23,67.4 110.23,67.86 109.87,68.22 107.02,68.22 106.44,68.8 104.3,68.8 103.75,68.24 103.75,66.02 102.37,64.65 102.37,62.63 102.37,62.63 102.37,62.35 102.07,62.04 101.97,62.04 v2(101.71,61.79)
  BOTTOM w0.102: v2(101.71,61.79) 102.1,62.18 CPU1.BU6
GFX_PCIE_RX_N2: length 39.3
  TOP w0.102: v2(100.78,61.78) 101.23,62.23 101.23,62.59 101.69,63.05 101.69,69.83 103.29,71.43 105.86,71.43 107.99,69.31 110.9,69.31 111.38,68.82 113.25,68.82 115.85,71.42 118.92,71.42 119.2,71.71 121.74,71.71 123.16,70.29 128.16,70.29 C7606.1
  BOTTOM w0.102: CPU1.BT7 100.99,61.78 v2(100.78,61.78)
GFX_PCIE_RX_N3: length 43.6
  TOP w0.102: C7608.1 128.15,72.17 126.99,72.17 126.31,71.49 124.4,71.49 123.91,71.97 123.91,72.42 123.2,73.13 122.01,73.13 121.62,72.74 115.73,72.74 113.3,70.31 108.37,70.31 106.14,72.55 103.04,72.55 100.57,70.08 100.57,65.3 100.12,64.85 100.12,62.91 100.09,62.87 100.09,62.32 100.12,62.29 100.12,61.5 100.64,60.99 100.89,60.99 101.23,60.64 101.55,60.64 v2(101.72,60.48)
  BOTTOM w0.102: v2(101.72,60.48) 101.91,60.48 CPU1.BU9
GFX_PCIE_RX_P0: length 41
  TOP w0.102: C7601.1 128.13,67.47 126.55,67.47 120.68,61.6 117.73,61.6 117.33,61.6 113.77,65.16 109.77,65.16 109.67,65.26 109.67,65.67 109.43,65.9 108.96,65.9 108.73,65.67 108.73,65.26 108.62,65.16 108.35,65.16 108.24,65.26 108.24,65.67 108.01,65.9 107.54,65.9 107.3,65.67 107.3,65.26 107.2,65.16 106.57,65.16 106.45,65.27 106.45,67.2 106.22,67.44 105.75,67.44 105.51,67.2 105.51,65.26 105.41,65.16 103.88,65.16 102.78,64.06 102.78,62.27 103.24,61.81 103.24,61.04 103.09,60.89 102.92,60.89 v2(102.66,61.15)
  BOTTOM w0.102: v2(102.66,61.15) 102.81,61.15 CPU1.BW8
GFX_PCIE_RX_P1: length 39.3
  TOP w0.102: C7603.1 128.13,68.99 127.07,68.99 120.39,62.31 117.63,62.31 114.5,65.44 114.5,66.34 113.76,67.08 110.87,67.08 110.46,67.49 110.46,67.96 109.97,68.45 107.11,68.45 106.54,69.02 104.2,69.02 103.52,68.34 103.52,66.11 102.15,64.74 102.15,62.54 102.15,62.44 101.98,62.27 101.83,62.27 v2(101.68,62.42)
  BOTTOM w0.102: CPU1.BU5 101.75,62.42 v2(101.68,62.42)
GFX_PCIE_RX_P2: length 39
  TOP w0.102: C7605.1 128.13,70.52 123.26,70.52 121.84,71.94 119.11,71.94 118.82,71.65 115.75,71.65 113.15,69.05 111.48,69.05 111,69.53 108.08,69.53 105.96,71.66 103.19,71.66 101.46,69.92 101.46,63.15 100.91,62.6 100.91,62.6 100.78,62.47 v2(100.78,62.47)
  BOTTOM w0.102: v2(100.78,62.47) 100.8,62.47 101.09,62.18 CPU1.BT6
GFX_PCIE_RX_P3: length 43.1
  TOP w0.102: v2(101.69,61.12) 101.46,60.88 101.31,60.88 100.98,61.21 100.73,61.21 100.35,61.6 100.35,62.39 100.32,62.42 100.32,62.78 100.35,62.81 100.35,64.76 100.8,65.21 100.8,69.99 103.13,72.32 106.04,72.32 108.28,70.08 113.21,70.08 113.4,70.08 115.83,72.51 121.72,72.51 121.85,72.65 122.1,72.9 123.11,72.9 123.69,72.33 123.69,71.88 124.3,71.26 126.41,71.26 127.08,71.94 127.73,71.94 127.84,71.84 127.84,71.63 127.97,71.5 128.24,71.5 C7607.1
  BOTTOM w0.102: CPU1.BU8 101.93,60.88 v2(101.69,61.12)
GFX_PCIE_TX_C_N0: length 14.6
  BOTTOM w0.083: CPU1.BW4 102.77,64.09 102.64,64.58 102.64,64.62 102.6,64.7 102.58,64.73 102.58,65.02 102.59,65.04 102.61,65.13 102.61,65.27 102.58,65.4 102.58,65.65 102.75,66.09 102.75,66.79 102.6,66.94
  BOTTOM w0.102: C1606.2 108.04,73.16 107.81,73.16 106.11,71.46 103.29,71.46 102.17,70.33 102.17,68.58 102.12,68.53 102.12,67.42 102.6,66.94
GFX_PCIE_TX_C_N1: length 16.9
  BOTTOM w0.083: 101.7,63.74 101.44,64 101.44,64.38 101.59,64.53 101.76,64.53 101.92,64.69 101.95,64.77 101.95,64.9 101.96,64.97 101.93,65.06 101.93,65.34 101.95,65.45 101.95,65.65 101.77,66.12 101.77,66.29 101.77,68.26 101.67,68.36
  BOTTOM w0.102: 101.67,68.36 101.6,68.43 101.6,68.8 101.69,68.88 101.69,70.94 102.93,72.19 105.82,72.19 107.27,73.64 107.27,74.83 107.51,75.06 C1608.2 ; 101.7,63.74 CPU1.BU4
GFX_PCIE_TX_C_N2: length 17.3
  BOTTOM w0.102: CPU1.BU2 101.3,65.69 101.3,65.96 101.3,67.96 101.03,68.22 101.03,68.22 100.9,68.36 100.9,68.9 100.98,68.97 100.98,71.32 102.65,72.99 102.84,72.99 102.84,72.99 105.53,72.99 106.56,74.02 106.56,75.85 107.02,76.3 108.01,76.3 C1610.2
GFX_PCIE_TX_C_N3: length 20.4
  BOTTOM w0.102: CPU1.BT4 101.13,64.13 100.87,64.4 100.87,65.08 100.88,65.1 100.88,65.55 100.84,65.59 100.84,65.68 100.84,65.68 100.84,67.67 100.45,68.05 100.45,68.63 100.26,68.82 100.26,71.61 102.38,73.72 105.25,73.72 105.83,74.3 105.83,77.06 106.63,77.86 108.04,77.86 C1612.2
GFX_PCIE_TX_C_P0: length 13.5
  BOTTOM w0.083: 102.78,67.08 102.92,66.94 102.92,66.06 102.75,65.62 102.75,65.42 102.78,65.34 102.78,65.06 102.76,64.96 102.75,64.95 102.75,64.77 102.75,64.77 CPU1.BW3
  BOTTOM w0.102: C1605.2 108.01,72.93 107.91,72.93 106.2,71.23 103.39,71.23 102.4,70.24 102.4,68.48 102.35,68.44 102.35,67.51 102.78,67.08
GFX_PCIE_TX_C_P1: length 16.6
  BOTTOM w0.083: 101.86,68.45 101.94,68.37 101.94,66.29 101.94,66.15 102.13,65.68 102.13,65.42 102.12,65.4 102.1,65.27 102.1,65.12 102.13,64.99 102.13,64.96 102.13,64.76 102.13,64.73 102.11,64.7 102.07,64.61 102.07,63.99 101.99,63.91 101.78,63.91 101.7,63.99 CPU1.BU3
  BOTTOM w0.102: C1607.2 108.29,74.35 107.81,74.83 107.6,74.83 107.5,74.73 107.5,73.55 105.92,71.96 103.03,71.96 101.92,70.85 101.92,68.79 101.83,68.7 101.83,68.48 101.86,68.45
GFX_PCIE_TX_C_P2: length 16.2
  BOTTOM w0.102: C1609.2 108.04,76.07 107.11,76.07 106.79,75.75 106.79,73.92 105.63,72.76 102.74,72.76 101.2,71.22 101.2,68.88 101.13,68.8 101.13,68.45 101.53,68.05 101.53,65.96 101.53,65.93 101.53,65.74 101.58,65.64 101.69,65.52 CPU1.BU1
GFX_PCIE_TX_C_P3: length 19.4
  BOTTOM w0.102: CPU1.BT3 101.13,65.08 101.11,65.1 101.11,65.17 101.11,65.17 101.11,65.64 101.07,65.69 101.07,65.77 101.06,65.78 101.06,67.76 100.68,68.15 100.68,68.73 100.49,68.91 100.49,71.52 102.47,73.49 105.34,73.49 106.06,74.21 106.06,76.96 106.72,77.63 107.51,77.63 107.88,77.27 108.21,77.27 C1611.2
GFX_PCIE_TX_N0: length 49.9
  TOP w0.102: v2(112.37,74.51) 112.52,74.37 112.52,74.3 112.62,74.2 114.26,74.2 114.5,74.44 119.1,74.44 119.2,74.54 119.2,74.89 119.44,75.13 119.91,75.13 120.14,74.89 120.14,74.54 120.24,74.44 120.52,74.44 120.62,74.54 120.62,74.89 120.86,75.13 121.33,75.13 121.56,74.89 121.56,74.54 121.67,74.44 125.51,74.44 125.75,74.2 125.75,73.74 125.85,73.64 126.13,73.64 126.23,73.74 126.23,74.2 126.47,74.44 127.14,74.44 127.38,74.2 127.38,73.99 127.48,73.89 127.76,73.89 127.86,73.99 127.86,74.2 128.09,74.44 128.91,74.44 129.01,74.54 129.01,75.13 129.25,75.37 129.72,75.37 129.95,75.13 129.95,74.54 130.06,74.44 130.34,74.44 130.44,74.54 130.44,75.13 130.67,75.37 131.14,75.37 131.38,75.13 131.38,74.54 131.48,74.44 132.28,74.44 133.54,75.7 138.31,75.7 138.5,75.88 v2(138.5,76.03)
  BOTTOM w0.102: GPU1.AG7 145.18,67.1 145.04,67.1 144.08,68.05 144.08,70.59 139.73,74.95 139.73,74.98 139.44,75.27 139.13,75.57 138.85,75.57 138.52,75.9 138.52,76 v2(138.5,76.03) ; C1606.1 111.42,73.41 111.52,73.51 111.52,73.92 111.83,74.23 112.09,74.23 v2(112.37,74.51)
GFX_PCIE_TX_N1: length 47.3
  TOP w0.102: v2(110.96,75.1) 111.3,75.1 111.42,74.98 111.79,74.98 112.46,75.66 113.31,75.66 114.34,76.69 120.9,76.69 121.34,76.25 128.17,76.25 128.45,76.53 133.83,76.53 133.95,76.41 137.74,76.41 138.13,76.8 140.01,76.8 140.51,76.31 140.51,75.98 140.5,75.97 140.5,75.83 140.7,75.63 140.85,75.63 140.85,75.63 141.18,75.63 141.88,74.94 141.88,74.61 141.53,74.26 141.53,74.11 141.73,73.91 141.87,73.91 142.22,74.26 142.55,74.26 v2(143.61,73.21)
  BOTTOM w0.102: v2(143.61,73.21) 143.61,72.82 145.1,71.33 145.1,68.34 145.94,67.49 145.94,67.06 146.2,66.8 146.31,66.65 146.31,66.23 146.44,66.1 ; v2(110.96,75.1) 110.61,74.76 109.51,74.76 C1608.1
GFX_PCIE_TX_N2: length 47.4
  TOP w0.102: v2(110.27,76.65) 110.49,76.43 112.21,76.43 113.23,77.45 121.14,77.45 121.48,77.11 128.03,77.11 128.15,77.24 128.96,77.24 129.06,77.34 129.06,77.8 129.3,78.03 129.77,78.03 130,77.8 130,77.34 130.1,77.24 134.86,77.24 135.14,77.51 140.56,77.51 142.77,75.3 142.99,75.3 143.19,75.49 143.52,75.49 143.85,75.16 143.85,74.83 143.66,74.63 143.66,74.49 145.07,73.08 v2(145.38,73.08)
  BOTTOM w0.102: v2(145.38,73.08) 145.38,72.57 146.01,71.94 146.01,68.33 146.33,68.01 146.76,68.01 146.92,67.85 147.06,67.85 ; C1610.1 109.47,76.32 109.94,76.32 v2(110.27,76.65)
GFX_PCIE_TX_N3: length 45.5
  TOP w0.102: v2(145.44,74.81) 145.22,74.81 143.03,76.99 142.41,76.99 141.17,78.23 132.44,78.23 131.74,78.92 128.77,78.92 127.83,77.98 121.62,77.98 121.44,78.16 112.89,78.16 112.39,77.66 111.71,77.66 v2(111.27,78.09)
  BOTTOM w0.102: v2(111.27,78.09) 111.13,77.95 109.36,77.95 C1612.1 ; v2(145.44,74.81) 145.44,74.51 146.8,73.15 146.8,69.07 146.91,68.97 147.05,68.97 GPU1.AG10
GFX_PCIE_TX_P0: length 51
  TOP w0.102: v2(112.37,73.72) 112.62,73.97 114.36,73.97 114.59,74.21 119.2,74.21 119.43,74.44 119.43,74.8 119.53,74.9 119.81,74.9 119.91,74.8 119.91,74.44 120.15,74.21 120.62,74.21 120.85,74.44 120.85,74.8 120.96,74.9 121.23,74.9 121.34,74.8 121.34,74.44 121.57,74.21 125.42,74.21 125.52,74.11 125.52,73.65 125.76,73.41 126.23,73.41 126.46,73.65 126.46,74.11 126.56,74.21 127.05,74.21 127.15,74.11 127.15,73.89 127.38,73.66 127.85,73.66 128.09,73.89 128.09,74.11 128.19,74.21 129.01,74.21 129.24,74.44 129.24,75.04 129.35,75.14 129.62,75.14 129.73,75.04 129.73,74.44 129.96,74.21 130.43,74.21 130.67,74.44 130.67,75.04 130.77,75.14 131.05,75.14 131.15,75.04 131.15,74.44 131.38,74.21 132.37,74.21 133.64,75.47 138.16,75.47 v2(138.52,75.11)
  BOTTOM w0.102: GPU1.AG6 144.87,66.79 144.87,66.94 144.4,67.41 143.85,67.96 143.85,70.5 141.29,73.06 139.5,74.85 139.5,74.89 139.04,75.34 138.75,75.34 v2(138.52,75.11) ; C1605.1 109.21,72.2 109.38,72.03 109.58,72.03 109.75,72.2 109.75,73.08 109.85,73.18 111.51,73.18 111.75,73.42 111.75,73.83 111.92,74 112.09,74 v2(112.37,73.72)
GFX_PCIE_TX_P1: length 47.6
  TOP w0.102: v2(143.09,72.7) 142.9,72.51 142.76,72.51 142.56,72.71 142.56,72.88 143.02,73.33 143.02,73.48 142.46,74.03 142.31,74.03 141.96,73.69 141.63,73.69 141.3,74.02 141.3,74.35 141.65,74.7 141.65,74.84 141.09,75.41 140.94,75.41 140.94,75.4 140.61,75.4 140.28,75.74 140.28,76.07 140.28,76.07 140.28,76.21 139.92,76.57 138.23,76.57 137.83,76.18 133.85,76.18 133.73,76.3 128.54,76.3 128.26,76.02 121.24,76.02 120.8,76.46 114.44,76.46 113.58,75.6 113.41,75.43 112.56,75.43 111.88,74.75 111.55,74.75 111.39,74.6 111.39,74.37 v2(111.02,74)
  BOTTOM w0.102: v2(143.09,72.7) 143.4,72.7 144.87,71.23 144.87,68.24 145.72,67.4 145.72,66.97 145.87,66.81 GPU1.AF7 ; C1607.1 109.44,74.53 110.5,74.53 110.82,74.22 110.82,74.21 v2(111.02,74)
GFX_PCIE_TX_P2: length 48.4
  TOP w0.102: v2(110.27,75.86) 110.27,75.99 110.49,76.2 112.3,76.2 113.32,77.22 121.05,77.22 121.38,76.89 128.12,76.89 128.25,77.01 129.06,77.01 129.29,77.25 129.29,77.7 129.39,77.8 129.67,77.8 129.77,77.7 129.77,77.25 130.01,77.01 134.96,77.01 135.23,77.29 140.46,77.29 142.68,75.07 143.09,75.07 143.28,75.27 143.43,75.27 143.63,75.07 143.63,74.92 143.43,74.73 143.43,74.39 144.87,72.95 144.87,72.55 144.74,72.42 v2(144.74,72.32)
  BOTTOM w0.102: C1609.1 109.47,76.09 110.04,76.09 v2(110.27,75.86) ; v2(144.74,72.32) 144.84,72.32 144.87,72.29 145.33,72.29 145.78,71.84 145.78,68.23 146.23,67.78 146.67,67.78 147.02,67.43 147.04,67.42 147.5,67.42 147.63,67.28
GFX_PCIE_TX_P3: length 46.5
  TOP w0.102: v2(111.43,77.17) 111.42,77.17 111.68,77.43 112.48,77.43 112.99,77.93 121.34,77.93 121.52,77.75 127.93,77.75 128.87,78.69 131.65,78.69 132.34,78 141.07,78 142.31,76.76 142.94,76.76 145,74.7 v2(145,74.35)
  BOTTOM w0.102: GPU1.AG9 146.58,68.5 146.58,73.06 146.24,73.39 146.22,73.41 145.28,74.35 v2(145,74.35) ; v2(111.43,77.17) 111.18,77.17 111.02,77.33 111.02,77.62 110.92,77.73 109.83,77.73 109.72,77.62 109.72,77.24 109.55,77.07 109.31,77.07 109.21,77.17 C1611.1
GPD11/LANPHYPC: length 37.4
  TOP w0.102: R1721.2 124.69,33.61 v1(124.69,33.56) 124.69,33.02 124.44,32.77 124.34,32.77 123.84,32.27 123.84,31.91 124.26,31.5 v2(124.63,31.5)
  L6 w0.102: v2(124.63,31.5) 124.17,31.04 119.59,31.04 118.86,30.32 115.49,30.32 113.07,32.74 111.24,32.74 107.03,36.95 106.76,36.95 105.14,38.57 103.13,38.57 v2(102.84,38.28)
  BOTTOM w0.076: 101.57,40.96 101.57,42.76 101.63,42.92 101.74,43.22 101.74,43.78 101.75,43.84 101.78,43.87 101.78,44.54 CPU1.BU34
  BOTTOM w0.102: 101.57,40.96 101.57,40.7 101.56,40.65 101.57,40.64 101.57,40.56 101.8,40.33 101.81,40.32 101.81,39.75 102.5,39.06 102.5,38.54 102.76,38.28 v2(102.84,38.28)
GPD_7: length 11
  TOP w0.102: R1525.1 101.46,35.05 R1524.2 102.52,35.05 v2(102.89,35.42)
  BOTTOM w0.076: 103.22,41.18 103.16,41.24 103.16,42.47 102.97,42.66 102.97,43.04 102.99,43.1 102.99,43.34 102.97,43.4 102.97,43.64 CPU1.BV35
  BOTTOM w0.102: 103.22,41.18 103.22,39.43 103.35,39.3 v1(103.35,37.64) 103.35,35.88 v2(102.89,35.42)
GPIO3: length 1.4
  BOTTOM w0.102: U3301.28 11.61,14 R3322.1
GPIO4: length 1.6
  BOTTOM w0.102: R3323.1 11.31,14.4 U3301.27
GPIO5_GC6_NVVDD_OR: length 2.4
  TOP w0.102: v1(142.37,78.62) 142.91,78.62 v2(142.98,78.69) 142.98,78.75 143.01,78.78 R8525.2
  BOTTOM w0.102: Q8509.5 v2(142.98,78.69)
GPIO5_GC6_PWR_1V: length 3.8
  BOTTOM w0.102: v1(138.96,78.16) 139.34,78.16 U8605.4 140.11,78.59 140.98,77.72 141.98,77.72 R8614.1
GPIO5_GC6_PWR_1V_A: length 7.7
  BOTTOM w0.102: R8614.2 142.94,77 143.27,77.33 144.02,77.33 145.51,75.84 v1(146.18,75.84) 146.24,75.84 146.33,75.93 146.33,77.17 146.92,77.76 U8604.1
GPIO5_GC6_PWR_B: length 23.2
  TOP w0.102: v1(139.7,75.38) 140.25,74.83 v2(140.57,74.83)
  L3 w0.102: v2(130.12,75.87) 130.65,76.4 138.28,76.4 138.34,76.46 138.87,76.46 138.95,76.54 139.67,76.54 140.57,75.64 v2(140.57,74.83)
  L6 w0.102: v2(130.05,69.49) 130.48,69.93 130.48,75.5 v2(130.12,75.87)
  BOTTOM w0.102: Q8601.D 129.64,69.9 v2(130.05,69.49) ; v2(140.57,74.83) 140.57,74.92 R8626.1 ; v2(130.12,75.87) 130.12,76.7 R8635.2
GPIO5_GC6_PWR_EN: length 80.5
  TOP w0.102: v2(140.61,57.43) 140.64,57.43 141.61,56.46 141.61,55.24 142.25,54.6 142.83,54.6 145.33,52.1 155.31,52.1 v2(158.76,55.55) ; R8525.1 142.15,79.27 v2(141.73,78.85)
  L5 w0.102: 140.04,57.99 140.04,59.78 139.85,59.97 139.85,66.47 140.77,67.39 140.77,69.57 140.67,69.67 140.67,74.33 141,74.65 141,75.01 140.67,75.34 140.67,75.62 141.82,76.77 141.82,78.77 v2(141.73,78.85) ; 140.04,57.99 139.78,58.26 136.2,58.26 134.58,59.88 134.58,60.28 134.33,60.53 133.23,60.53 127.23,66.54 127.23,70.45 127.73,70.95 v2(127.82,70.95) ; 140.04,57.99 v2(140.61,57.43)
  BOTTOM w0.102: Q8601.S 127.09,70.95 v2(127.82,70.95) 128.06,71.19 128.06,71.31 128.2,71.45 128.2,74.84 128.75,75.39 129.4,75.39 130.67,74.12 130.67,73.62 130.89,73.4 130.91,73.4 131.43,72.88 Q8612.5 ; 158.77,56.14 158.77,55.56 v2(158.76,55.55) ; v2(140.61,57.43) 140.61,56.92 v1(140.83,56.7) 141.5,56.7 R7933.2
GPIO9_ALERT: length 22.2
  TOP w0.102: v2(142.41,55.91) 142.83,55.91 143.35,55.39 143.35,54.74 144.42,53.68 147.59,53.68 148.96,52.3 153.71,52.3 155.97,54.56 155.97,54.58 156.21,54.81 156.85,54.81 v2(157.56,55.52)
  BOTTOM w0.102: GPU1.F8 158.18,55.55 158.15,55.52 v2(157.56,55.52) ; v2(142.41,55.91) 142.71,55.91 143.14,55.48 v1(143.14,55.23) 143.14,54.83 142.92,54.61 141.68,54.61 RN7910.4
GPIO10_FBVREF: length 20.7
  TOP w0.102: v2(157.58,52.03) 160.42,49.19 164.05,49.19 164.54,49.68 165.71,49.68 166.12,50.1 169.23,50.1 v2(171.78,52.65)
  BOTTOM w0.102: GPU1.C5 157.61,52.06 v2(157.58,52.03) ; v1(170.54,52.06) 171.13,52.65 v2(171.78,52.65) 172.31,53.18 Q8101.G 172.61,52.99 R7910.2
GPP_B22_GSPI1_MOSI: length 4.6
  TOP w0.102: v1(104.72,47.09) 104.98,47.09 v2(105.22,46.84) 105.63,47.26 105.63,48.95 104.92,49.66 R1553.1
  BOTTOM w0.102: v2(105.22,46.84) 105.21,46.84 104.86,47.19 CPU1.CA30
GPP_E3/CPU_GP0: length 1.2
  TOP w0.102: TP304.1 106.75,59.21 v2(106.75,59.7)
  BOTTOM w0.102: CPU1.CE9 106.78,59.81 106.74,59.77 106.74,59.7 v2(106.75,59.7)
GPP_H1_SFRM: length 73.6
  TOP w0.102: R1913.2 166.83,29.22 v1(166.83,30.22) 165.93,29.31 v2(165.93,28.95)
  L6 w0.102: v2(165.93,28.95) 165.7,28.72 165.61,28.72 165.27,29.06 164.74,29.06 164.24,28.56 162.82,28.56 162.82,28.56 162.38,28.56 162.21,28.73 161.64,28.73 161.12,28.21 153.53,28.21 151.82,26.5 147.37,26.5 146.86,27.02 143.91,27.02 143.64,26.74 142.5,26.74 141.46,27.78 141.46,28.37 140.35,29.48 139.95,29.48 137.96,31.47 134.98,31.47 132.84,33.62 132.84,34.88 124.68,43.04 124.54,43.04 122.39,45.19 116.82,45.19 114.54,42.92 113.59,42.92 111.62,44.88 109.74,44.88 109.31,45.32 109.31,45.72 v2(108.83,46.2)
  BOTTOM w0.102: v2(108.83,46.2) 108.83,46.2 108.83,46.2 109.14,45.89 CPU1.CJ32
GPP_H2_CLKREQ0: length 78.1
  TOP w0.102: v1(170.66,27.27) 170.36,27.57 R1912.2 170.44,28.18 171.15,28.89 v2(171.15,28.99)
  L6 w0.102: v2(108.83,47.47) 109.49,46.81 109.49,46.61 109.51,46.59 109.51,46.41 109.44,46.34 109.44,45.98 109.51,45.91 109.51,45.4 109.83,45.09 111.98,45.09 112.48,44.58 114.74,44.58 115.55,45.4 122.47,45.4 124.63,43.24 124.77,43.24 133.17,34.84 133.17,33.58 135.07,31.67 138.09,31.67 140.08,29.68 140.44,29.68 141.66,28.46 141.66,27.86 142.58,26.94 143.48,26.94 143.76,27.22 146.94,27.22 147.45,26.71 151.74,26.71 153.46,28.43 161.05,28.43 162.03,29.41 162.66,29.41 162.67,29.42 163.01,29.42 163.02,29.41 167.88,29.41 168.59,28.7 169.61,28.7 169.89,28.99 v2(171.15,28.99)
  BOTTOM w0.102: CPU1.CH29 108.46,47.84 v2(108.83,47.47)
GPP_H17_STRAP: length 15.8
  TOP w0.102: R1527.1 125.7,49.35 v1(125.11,48.76) 125.07,48.81 122.14,48.81 121.62,49.32 118.64,49.32 118.38,49.06 116.75,49.06 116.31,49.5 v2(116.31,49.83)
  BOTTOM w0.102: v2(116.31,49.83) 116.31,49.85 115.89,49.43 115.19,49.43 114.52,50.1 112.09,50.1 CPU1.CP26
GPP_H21: length 50.7
  L3 w0.102: v2(135.88,54.76) 135.7,54.76 135.32,55.14 134.96,55.14 134.36,54.54 134.36,48.06 v2(134.67,47.75)
  L6 w0.102: v2(134.67,47.75) 134.14,47.22 123.69,47.22 123.54,47.07 118.98,47.07 117.56,48.49 115.9,48.49 115.68,48.72 115.12,48.72 114.1,49.74 v2(108.19,49.74)
  BOTTOM w0.102: v2(135.88,54.76) 135.7,54.76 135.32,55.14 135.32,55.14 135.14,55.32 v1(134.36,55.32) 128.31,55.32 127.19,54.19 126.18,54.19 R1523.1 125.57,54.31 124.22,54.31 R1522.2 ; CPU1.CF25 107.56,49.98 107.56,49.79 107.66,49.69 108.14,49.69 v2(108.19,49.74)
GPP_H23: length 14.7
  BOTTOM w0.076: 112.91,49.4 112.75,49.56 112.39,49.56 arc(112.35,49.57) 112.31,49.58 arc(112.24,49.62) 112.17,49.63 112.1,49.63 arc(112.04,49.62) 111.98,49.58 arc(111.94,49.57) 111.9,49.56 111.5,49.56 111.42,49.48 110.77,49.48 CPU1.CM26
  BOTTOM w0.102: 112.91,49.4 114.13,49.4 114.52,49 117.97,49 118.29,48.69 R1514.1 119.06,47.44 121.75,47.44 R1513.2 122.36,46.97 122.62,46.71 122.62,46.65 123.18,46.08 v1(123.25,46.08)
GPPC_H18_BOOTMPC: length 5.1
  BOTTOM w0.076: 112.76,49.22 112.59,49.4 112.31,49.4 112.31,49.4 arc(112.28,49.42) 112.24,49.42 112.06,49.42 arc(112,49.41) 111.94,49.39 arc(111.87,49.36) 111.8,49.35 111.67,49.35 CPU1.CN27
  BOTTOM w0.127: R2119.1 115.22,48.61 v1(115.16,48.67) 115.12,48.72 114.31,48.72 113.86,49.17 112.82,49.17 112.76,49.22
GPPC_H18_VCCIO_LPM: length 27.2
  L8 w0.127: v2(123.69,45.5) 124.72,45.5 125.51,44.71 125.51,40.74 128.91,37.34 128.91,33.96 v2(129.36,33.51)
  BOTTOM w0.127: U4008.2 131.86,33.43 R4040.2 ; R2119.2 116.93,48.54 116.93,47.92 118,46.85 120.77,46.85 122.12,45.5 v2(123.69,45.5) ; R4040.2 130.18,33.43 R4041.2 129.42,33.45 v2(129.36,33.51) ; R4040.2 131,33.83 v1(130.53,34.29)
GPU_CLKREQ#: length 18.3
  TOP w0.102: v2(138.7,57.31) 138.25,57.31 137.58,56.64 137.58,55.57 139.33,53.82 Q7601.S
  BOTTOM w0.102: v2(138.7,57.31) 138.7,57.32 138.7,57.52 138.13,58.09 R7603.2 138.9,58.96 v1(139.35,58.96) 140.34,58.96 142.81,61.43 143.4,61.43 146.37,64.4 GPU1.AC6
GPU_EVENT#: length 24.3
  TOP w0.102: Q7906.D 138.36,58.46 137.29,57.38 v2(136.74,57.38)
  BOTTOM w0.102: v2(136.74,57.38) 136.92,57.38 137.74,56.56 v1(137.74,55.76) 137.74,54.96 137.07,54.29 136.52,54.29 136.49,54.32 136.21,54.32 136.21,54.32 135.64,54.32 135.59,54.27 133.75,54.27 133.11,54.91 128.67,54.91 127.31,53.55 127.31,51.2 127.11,51 127.11,49.26 R7948.2 126.49,48.56 125.76,47.82 R2003.1
GPU_EVENT_GPU#: length 25.6
  TOP w0.102: v2(139.99,57.29) 140,57.29 Q7906.S 140.23,56.55 v1(141.02,56.55)
  L8 w0.102: v2(139.99,57.29) 140.29,56.99 141.71,56.99 144.24,59.52 147.22,59.52 147.46,59.28 147.46,59.25 151.05,55.66 155.7,55.66 157.6,53.75 v2(157.6,53.18)
  BOTTOM w0.102: GPU1.D6 158.13,53.18 v2(157.6,53.18) ; R7949.2 139.66,56.97 v2(139.99,57.29)
GPU_EVENT_MCP#: length 22.7
  L6 w0.102: v2(124.36,47.65) 123.52,47.65 123.14,47.27 119.13,47.27 119.11,47.29 119.05,47.29 117.64,48.7 115.98,48.7 115.71,48.97 115.24,48.97 114.17,50.04 108.93,50.04 108.8,50.17 107.87,50.17 106.94,49.24 106.47,49.24 v2(106.08,48.86)
  BOTTOM w0.102: v2(124.36,47.65) 124.22,47.79 v1(124.22,48.57) 124.33,48.69 R2003.2 ; v2(106.08,48.86) 106.08,48.86 106.08,48.85 106.03,48.85 105.74,49.14 CPU1.CC27
GPU_PWR_LEVEL: length 3.5
  TOP w0.102: v1(22.04,26.05) 22.04,26.3 v2(22.31,26.57) 22.42,26.68 R2460.2 23.04,27.37 R2477.2
  BOTTOM w0.102: U2401.10 22.16,27.68 22.16,26.72 v2(22.31,26.57)
GPU_ROM_SCLK: length 15.8
  BOTTOM w0.089: GPU1.C12 162.37,56.05 162.37,55.5 162.55,55.32 162.55,54.74 167.36,49.94 v1(167.79,49.94) 170.19,49.94 171.91,48.21 172.62,48.21 R7921.1 R7920.2
GPU_ROM_SI: length 12.4
  BOTTOM w0.089: GPU1.B12 163.04,55.38 163.04,54.66 166.55,51.14 v1(168.04,51.14) 168.74,50.45 170.52,50.45 R7924.1 171.45,50.31 R7935.2
GPU_ROM_SO: length 10.4
  BOTTOM w0.089: R7918.2 R7932.1 171.12,51.59 169.39,51.59 v1(169.26,51.71) 168.27,51.71 166.64,51.71 163.38,54.97 GPU1.A12
GPU_THM_SMBCLK: length 195.5
  TOP w0.127: R6602.1 187.15,5.1 186.7,5.1 ; 186.7,5.1 185.67,5.1 184.15,3.58 166.57,3.58 165.3,2.3 163.66,2.3 163.19,1.84 v2(163.19,1.76) ; 186.7,5.1 v1(186.7,5.24)
  L5 w0.127: v3(62.65,2.89) 62.72,2.89 63.14,3.31 63.14,3.76 59.58,7.32 59.58,9.6 58.68,10.5 54.08,10.5 53.7,10.13 53.7,9.44 52.22,7.97 39.12,7.97 38.7,8.39 37.82,8.39 36.18,10.03 35.33,10.03 34.97,10.4 34.23,10.4 31.72,12.91 31.72,14.65 31.23,15.14 29.68,15.14 29.5,14.96 27.09,14.96 26.04,16.01 25.36,16.01 22.8,18.57 22.8,19.36 22.42,19.73 v3(22.36,19.73)
  L8 w0.127: v2(163.19,1.76) 163.1,1.76 163.01,1.66 162.12,1.66 162.07,1.71 145.87,1.71 145.77,1.71 133.4,1.71 132.8,1.47 65.15,1.47 64.3,2.32 64.3,2.78 63.92,3.15 62.92,3.15 v3(62.65,2.89)
  BOTTOM w0.127: R2406.1 21.81,31.11 21.8,30.72 22.72,29.8 22.72,29.48 22.88,29.33 22.88,28.52 22.97,28.43 U2401.12 22.97,26.9 23.01,26.86 23.01,26.28 22.71,25.99 22.71,23.79 23.83,22.67 23.83,21.03 22.53,19.73 v3(22.36,19.73)
GPU_THM_SMBDAT: length 195.3
  TOP w0.127: 184.61,3.67 184.26,3.32 166.68,3.32 165.4,2.05 164.3,2.05 v2(164.01,1.76) ; 184.61,3.67 v1(184.75,3.54) ; 184.61,3.67 185.78,4.84 R6601.1
  L5 w0.127: v3(63.13,2.55) 63.13,2.94 63.39,3.2 63.39,3.86 59.83,7.42 59.83,9.71 58.78,10.76 53.97,10.76 53.45,10.23 53.45,9.55 52.12,8.22 39.23,8.22 38.8,8.65 37.93,8.65 36.29,10.29 36.08,10.29 36.08,10.29 35.44,10.29 35.07,10.65 34.33,10.65 31.98,13.01 31.98,14.76 31.34,15.4 29.57,15.4 29.4,15.22 27.19,15.22 26.15,16.26 25.47,16.26 23.05,18.68 23.05,19.68 v3(22.42,20.31)
  L8 w0.127: v3(63.13,2.55) 63.13,2.72 63.31,2.9 63.82,2.9 64.05,2.67 64.05,2.21 65.05,1.21 132.85,1.21 133.45,1.46 145.77,1.46 145.87,1.46 161.96,1.46 162.01,1.41 162.92,1.41 163.01,1.31 163.38,1.31 163.82,1.76 v2(164.01,1.76)
  BOTTOM w0.127: R2405.1 21.55,31.09 21.55,30.61 22.47,29.69 22.47,29.38 22.62,29.22 22.62,28.47 22.57,28.42 U2401.11 22.57,26.94 22.76,26.76 22.76,26.39 22.46,26.09 22.46,23.68 23.57,22.57 23.57,21.13 22.75,20.31 v3(22.42,20.31)
GSEN2_INT1: length 102.7
  TOP w0.102: v2(192.56,29.18) R7003.1 192.66,30.05 U7002.12
  L3 w0.102: v2(192.56,29.18) 192.99,29.61 192.99,31.75 192.52,32.21 190.05,32.21 188.7,30.87 183.17,30.87 181.95,29.65 178.01,29.65 177.3,28.94 175.27,28.94 175.01,29.19 175.01,29.33 174,30.34 174,31.45 172.87,32.58 171.69,32.58 170.26,34.01 170.26,35.04 170.38,35.16 170.38,35.52 169.35,36.54 169.35,44.24 167.75,45.84 165.53,45.84 163.89,47.48 163.89,48.79 164.45,49.35 164.45,49.85 161.25,53.05 158.58,53.05 157.85,53.78 156.43,53.78 155.97,54.24 155.97,54.58 155.5,55.05 155.5,57.76 152.04,61.21 152.04,64.85 154.42,67.23 154.42,69.86 152.08,72.19 151.05,72.19 149.55,73.68 149.27,73.68 144.47,78.49 144.47,79.01 143.15,80.33 143.15,81.88 143.41,82.14 143.41,82.5 143.07,82.84 v2(143.07,84.92)
  BOTTOM w0.102: R7005.1 142.4,84.87 143.04,85.5 v1(143.23,85.5) 143.23,85.08 v2(143.07,84.92)
GSEN2_INT1_C: length 96.4
  TOP w0.102: R7003.2 190.9,29.95 190.77,29.82 v1(190.77,29.81) 190.77,29.8 191.31,29.26 v2(191.66,29.26)
  L3 w0.102: v2(191.66,29.26) 191.66,27.85 189.66,25.86 185.02,25.86 182.89,23.73 180.05,23.73 178.24,21.92 165.81,21.92 165.78,21.95 162.58,21.95 162.14,21.51 142.34,21.51 141.44,22.41 135.16,22.41 134.89,22.68 134.91,22.71 134.91,24.32 134.62,24.62 v2(134.62,27.98)
  L6 w0.102: v2(134.62,27.98) 135.02,28.37 135.02,28.8 134.43,29.39 133.89,29.39 132.71,30.58 129.69,30.58 128.85,31.42 128.85,33.7 126.28,36.27 123.15,36.27 122.24,37.19 119.89,37.19 119.25,37.83 114.75,37.83 v3(114.39,38.19)
  BOTTOM w0.102: R2025.2 114.34,38.24 v3(114.39,38.19)
GSEN2_INT1_ISH: length 16.6
  BOTTOM w0.076: 104.19,43.63 104.35,43.47 104.35,43.4 104.55,43.19 104.71,43.19 104.83,43.07 104.86,43.02 104.86,42.34
  BOTTOM w0.102: 104.19,43.63 103.92,43.63 103.7,43.84 103.7,44.15 103.65,44.19 CPU1.BW35 ; 104.86,42.34 104.89,42.31 104.89,41.14 104.65,40.9 104.65,38.07 105.77,36.94 v1(106.85,36.94) 108.03,36.94 108.14,36.83 110.94,36.83 112.06,37.94 112.57,37.94 R2025.1
GSEN2_INT2: length 102.8
  TOP w0.102: v2(192.56,31.57) R7004.1 192.76,30.55 U7002.11
  L3 w0.102: v2(143.85,84.89) 143.39,85.35 142.89,85.35 142.55,85.01 142.55,82.08 142.94,81.69 142.94,80.25 144.26,78.93 144.26,78.24 149.03,73.48 149.47,73.48 149.72,73.23 149.72,72.8 151.91,70.61 152.44,70.61 153.44,69.61 153.44,66.56 151.85,64.98 151.85,61.13 155.21,57.78 155.21,54.98 155.63,54.56 155.63,54.3 156.35,53.59 157.77,53.59 158.53,52.83 161.21,52.83 164.26,49.78 164.26,49.43 163.68,48.86 163.68,47.4 165.47,45.62 167.69,45.62 169.03,44.28 169.03,35.77 169.4,35.4 169.4,34.58 171.6,32.38 172.42,32.38 172.99,31.81 172.99,30.03 173.32,29.7 173.32,29.11 174.56,27.87 176,27.87 176.55,28.42 177.07,28.42 178.09,29.44 187.57,29.44 190.13,32.01 192.11,32.01 v2(192.56,31.57)
  BOTTOM w0.102: v1(143.51,87.28) 143.84,86.95 R7006.1 143.84,84.9 v2(143.85,84.89)
GSEN2_INT2_C: length 95.5
  TOP w0.102: v2(191.58,31.58) 191.11,31.58 v1(190.82,31.28) 190.82,31.24 191.31,30.75 R7004.2
  L3 w0.102: v2(191.58,31.58) 190.45,31.58 182.8,23.93 179.96,23.93 178.15,22.12 165.89,22.12 165.86,22.15 162.5,22.15 162.05,21.71 143.31,21.71 142.4,22.62 135.24,22.62 135.12,22.74 135.12,24.41 135.05,24.47 135.05,27.79 135.05,27.8 135.05,28.16 135.05,28.16 135.05,28.52 134.95,28.62 v2(134.59,28.62)
  L6 w0.102: v2(114.8,37.1) 115.29,37.58 117.83,37.58 117.88,37.63 118.23,37.63 118.28,37.58 119.07,37.58 119.67,36.98 122.15,36.98 123.07,36.07 126.19,36.07 128.64,33.62 128.64,31.19 129.46,30.38 132.62,30.38 134.11,28.89 134.19,28.89 134.46,28.62 134.61,28.62 134.61,28.62 v2(134.59,28.62)
  BOTTOM w0.102: v2(114.8,37.1) 113.94,37.1 R2026.2
GSEN2_INT2_ISH: length 17.8
  BOTTOM w0.076: CPU1.BW34 103.13,44.59 103.13,43.43 103.15,43.37 103.15,43.07 103.13,43.01 103.13,42.73 103.39,42.47 103.39,41.58
  BOTTOM w0.102: R2026.1 113.04,36.91 112.25,36.12 105.61,36.12 103.82,37.91 v1(103.82,38.84) 103.66,39.01 103.66,39.52 103.44,39.74 103.44,41.53 103.39,41.58
GSENSOR_CS: length 2.7
  TOP w0.102: v1(192.51,28) 193.33,28 R7016.1 193.4,28.09 193.99,28.68 U7002.2
GSENSOR_SDO: length 3.4
  TOP w0.102: R7002.1 195.85,27.95 v1(195.87,27.97) ; R7002.1 194.98,28.21 194.55,28.63 194.55,29.45 U7002.3 ; R7002.1 194.23,27.95 R7008.2
H_CPUPWRGD: length 15.9
  BOTTOM w0.102: CPU1.AR2 88.73,65.24 88.73,65.54 88.72,65.55 88.72,68.04 88.51,68.25 88.51,70.17 v1(88.71,70.36) 88.71,70.75 88.89,70.93 88.89,71.47 89.5,72.08 89.5,73.11 90.11,73.72 93.28,73.72 93.31,73.7 93.33,73.7 93.38,73.64 93.97,73.64 94.3,73.97 96,73.97 ED301.2
H_PECI: length 3.8
  TOP w0.089: v1(18.08,12.78) 18.12,12.82 C2405.1 18.97,13.14 v2(19.37,13.54) 19.74,13.17 R2437.1
  BOTTOM w0.089: U2401.94 v2(19.37,13.54)
HALL_VCC: length 13.1
  TOP w0.254: HALL1.1 3.45,50.01 10.45,50.01 11.19,49.26 v1(11.19,48.65) 11.19,48.04 12.11,47.12 R6745.2 12.47,47.08 C6715.1 13.29,47.16 R6744.2
HDA_BITCLK_CODEC: length 94.9
  TOP w0.089: v2(170.55,17.41) 171.4,17.41 v1(172.11,16.71) EC2710.1 174.45,16.15 174.8,16.15 175.02,16.37 175.9,16.37 R2723.1
  L3 w0.076: v3(163.4,23.41) 162.46,22.47 162.36,22.47 161.92,22.03 144.94,22.03 144.75,22.22 144.6,22.22 143.67,23.15 143.67,23.29 143.56,23.4 143.2,23.4 142.96,23.65 142.96,24.01 141.35,25.62 141.02,25.62 140.96,25.56 140.53,25.56 140.22,25.86 140.22,26.75 139.23,27.74 v2(138.4,27.74)
  L5 w0.089: v3(163.4,23.41) 164.87,23.41 168.2,20.08 168.2,19.37 168.44,19.12 169.15,19.12 170.55,17.72 v2(170.55,17.41)
  L6 w0.089: v2(138.4,27.74) 138.1,28.04 135.42,28.04 134.93,27.55 134.45,27.55 133.22,28.78 130.05,28.78 127.75,31.07 127.75,33.5 125.9,35.35 122.77,35.35 121.86,36.27 119.27,36.27 v2(119.08,36.46)
  BOTTOM w0.089: EC1901.1 119.25,37.19 119.25,36.63 v2(119.08,36.46) 119.07,36.46 118.97,36.36 118.92,36.31 116.83,36.31 115.68,35.16 115.17,35.16 114.09,34.08 112.79,34.08 112,33.28 111.63,33.28 111.62,33.28 103.2,33.28 100.62,35.86 100.62,36.43 100.36,36.69 R1920.1
HDA_BITCLK_CODEC_R: length 3
  TOP w0.089: R2723.2 v1(178.23,15.77) 178.5,15.77 178.9,15.36 U2701.5
HDA_BITCLK_CPU: length 4.9
  BOTTOM w0.089: R1920.2 100.36,38.96 v1(100.06,39.26) 100.06,39.29 99.97,39.39 99.97,41.57 99.43,42.11 99.43,42.76 CPU1.BN37
HDA_CODEC_SDIN0: length 3.3
  TOP w0.089: R2724.2 177.42,13.63 v1(178.23,13.63) 178.23,13.66 179.16,14.59 179.51,14.59 179.54,14.56 U2701.7
HDA_RST_N_CPU: length 7.5
  BOTTOM w0.089: TP1903.1 99.37,37.41 99.37,41.01 98.89,41.49 98.89,42.27 98.63,42.53 98.63,43.82 98.35,44.1 CPU1.BL35
HDA_SDIN0_CPU: length 101.2
  TOP w0.089: R2724.1 175.88,13.69 174.98,14.59 173.58,14.59 v1(172.69,15.48) v2(171.3,16.86)
  L5 w0.089: v2(169.76,20.69) 169.76,19.48 171.3,17.94 v2(171.3,16.86)
  L6 w0.089: v2(124.49,29.9) 124.49,29.9 124,29.41 124,26.9 126.75,24.15 128.89,24.15 129.58,24.83 136.82,24.83 140.26,21.4 148.14,21.4 148.35,21.19 153.56,21.19 154.29,21.92 157.99,21.92 158.05,21.98 161.76,21.98 161.8,22.02 163.32,22.02 163.33,22.01 168.44,22.01 v2(169.76,20.69)
  BOTTOM w0.076: CPU1.BN35 99.22,43.85 99.22,43.22 99.07,42.83 99.07,41.93
  BOTTOM w0.089: v2(124.49,29.9) 124.49,29.9 124.49,29.86 124.39,29.96 124.39,30.48 123.49,31.38 123.37,31.38 123.33,31.41 113.64,31.41 112.59,32.46 101.63,32.46 99.35,34.74 99.35,36.76 99.55,36.95 99.55,41.45 99.07,41.93
HDA_SDOUT_CODEC: length 9.5
  TOP w0.089: U2701.4 179.01,15.76 178.56,16.21 176.88,16.21 176.36,16.73 174.73,16.73 EC2709.1 173.6,16.51 172.96,17.15 v1(172.96,17.59) 172.96,18.53 R1921.1
HDA_SDOUT_CPU: length 98.9
  TOP w0.089: R1909.2 173.24,19.67 R1921.2 172.6,19.04 v2(172.32,19.04) ; R1512.2 125.53,31.4 v1(125.18,31.05) 125.18,31.04 125,30.87 v2(124.61,30.87)
  L6 w0.089: v2(172.32,19.04) 172.4,19.04 172.4,19.02 172.81,19.42 172.81,19.85 172.3,20.36 170.04,20.36 169.94,20.26 169.58,20.26 168.24,21.6 166.28,21.6 165.77,21.09 163.83,21.09 163.27,21.65 161.93,21.65 161.91,21.63 158.2,21.63 158.13,21.57 154.44,21.57 153.71,20.83 148.2,20.83 147.99,21.04 139.95,21.04 136.52,24.48 129.73,24.48 128.94,23.69 126.7,23.69 123.64,26.75 123.64,29.9 v2(124.61,30.87)
  BOTTOM w0.076: CPU1.BN36 99.38,43.17 99.25,42.82 99.25,42.01
  BOTTOM w0.089: v2(124.61,30.87) 123.7,31.77 119.1,31.77 118.58,32.29 117.83,32.29 117.77,32.35 117.42,32.35 117.39,32.32 113.23,32.32 112.72,32.83 101.8,32.83 99.73,34.9 99.73,41.53 99.25,42.01
HDA_SPKR_R: length 2.3
  TOP w0.254: R2741.2 168.71,4.59 v1(169.64,4.59) 170.8,4.59 D2703.1
HDA_SYNC_CODEC: length 6.1
  TOP w0.089: R1908.1 175.34,13.5 v1(175.48,13.5) 175.74,13.24 178.64,13.24 178.75,13.35 179.55,13.35 179.96,13.76 U2701.9
HDA_SYNC_CPU: length 98.2
  TOP w0.089: v2(168.99,15.43) 169.15,15.26 v1(171.47,15.26) 172.26,15.26 173.36,14.16 R1908.2
  L5 w0.089: v2(133.01,29.27) 134.57,29.27 135.33,28.51 136.09,28.51 136.22,28.64 138.77,28.64 140.88,26.53 141.55,26.53 142.06,26.02 144.14,26.02 144.53,26.41 144.53,26.65 144.89,27.01 146.66,27.01 147.27,27.62 150.11,27.62 150.42,27.31 151.97,27.31 152.15,27.49 154.38,27.49 154.48,27.39 158.31,27.39 159.81,25.88 159.81,25.69 161.2,24.3 161.37,24.3 161.92,23.75 161.92,23.26 164.21,20.97 164.42,20.97 168.26,17.13 168.26,16.15 v2(168.99,15.43)
  L6 w0.089: v2(118.63,36.92) 119.22,36.92 119.52,36.62 122,36.62 122.92,35.71 126.04,35.71 128.1,33.64 128.1,31.22 129.38,29.94 132.33,29.94 v2(133.01,29.27)
  BOTTOM w0.089: v2(118.63,36.92) 118.38,36.67 116.63,36.67 115.48,35.52 115.03,35.52 114.67,35.17 110.94,35.17 109.41,33.64 103.55,33.64 102.1,35.1 102.1,35.65 100.87,36.88 100.87,37.45 100.87,38.92 100.58,39.21 100.57,39.21 100.18,39.59 100.18,41.61 99.66,42.13 99.66,42.55 99.83,42.71 99.83,44.58 CPU1.BN34
HDMI_DDI_TX_CMC_N0: length 2.6
  TOP w0.102: C5708.2 23.05,49.97 23.04,49.97 22.69,49.97 22.68,49.97 22.54,49.97 v2(22.47,50.04) 22.23,49.8 21.9,49.8 R5707.1
  BOTTOM w0.102: v2(22.47,50.04) 22.41,50.1 22.31,50.1 22.18,50.22 RN5702.3
HDMI_DDI_TX_CMC_N1: length 2.9
  TOP w0.102: R5703.1 22.22,51.49 22.27,51.54 v2(22.71,51.54) 22.96,51.8 23.1,51.8 C5706.2
  BOTTOM w0.102: v2(22.71,51.54) 22.06,51.54 21.83,51.31 RN5702.1
HDMI_DDI_TX_CMC_N2: length 2.5
  TOP w0.102: R5705.1 22.51,54.92 v2(22.52,54.9) 22.54,54.92 C5704.2
  BOTTOM w0.102: RN5703.1 22.37,54.74 22.52,54.9 v2(22.52,54.9)
HDMI_DDI_TX_CMC_N3: length 2.7
  TOP w0.102: C5702.2 22.59,53.27 v2(22.52,53.2) 22.3,53.2 22.24,53.27 R5701.1
  BOTTOM w0.102: RN5703.3 22.07,53.65 v2(22.52,53.2)
HDMI_DDI_TX_CMC_P0: length 3.1
  TOP w0.102: C5709.2 23.07,49.54 v2(22.86,49.54) 22.06,49.54 R5708.1
  BOTTOM w0.102: v2(22.86,49.54) 22.84,49.56 22.09,49.56 22.01,49.64 RN5702.4
HDMI_DDI_TX_CMC_P1: length 2.7
  TOP w0.102: C5707.2 23.2,50.93 v2(22.47,50.93) 22.26,50.73 R5704.1
  BOTTOM w0.102: RN5702.2 22.36,50.73 22.47,50.83 v2(22.47,50.93)
HDMI_DDI_TX_CMC_P2: length 2.5
  TOP w0.102: R5706.1 22.12,54.16 v2(22.51,54.27) 23.01,54.16 C5705.2
  BOTTOM w0.102: v2(22.51,54.27) 22.52,54.27 22.52,54.26 22.09,54.26 21.98,54.15 RN5703.2
HDMI_DDI_TX_CMC_P3: length 2.8
  TOP w0.102: C5703.2 22.72,52.51 v2(22.64,52.58) 22.64,52.58 22.31,52.58 22.24,52.51 R5702.1
  BOTTOM w0.102: v2(22.64,52.58) 22.64,52.58 22.49,52.58 22.01,53.07 RN5703.4
HDMI_DDI_TX_CON_N0: length 13.3
  TOP w0.102: R5707.2 20.03,49.97 ER5716.1 20.01,49.97 ED5702.2 ED5702.9 17.6,49.97 17.33,49.7 16,49.7 13.4,52.3 13.4,52.35 11.19,54.55 11.19,54.93 10.93,55.19 10.74,55.19 HDMI1.3
HDMI_DDI_TX_CON_N1: length 13.2
  TOP w0.102: HDMI1.6 12.3,56.63 12.86,56.63 13.22,56.27 13.22,53.42 15.31,51.34 17.47,51.34 17.6,51.47 ED5702.6 ED5702.5 19.4,51.47 19.47,51.54 ER5717.1 20.43,51.54 20.48,51.49 R5703.2
HDMI_DDI_TX_CON_N2: length 24.8
  TOP w0.102: v2(16.93,54.32) 17.28,54.32 17.46,54.5 17.72,54.5 17.87,54.65 ED5701.6 ED5701.5 19.83,54.65 ER5715.1 20.56,54.97 20.61,54.92 R5705.2
  L8 w0.089: v2(16.93,54.32) 16.67,54.06 16.43,54.06 16.11,53.74 16.11,52.11 14.68,50.68 14.68,48.26 14.48,48.05 13.64,48.05 13,48.69 13,50.92 13.18,51.1 13.18,52.45 11.18,54.45 11.18,57.97 10.98,58.17 10.76,58.17 HDMI1.9
HDMI_DDI_TX_CON_N3: length 15.5
  TOP w0.102: HDMI1.12 12.22,59.71 12.4,59.71 12.92,59.2 12.92,57.77 14.47,56.22 14.47,53.11 15.22,52.35 16.94,52.35 17.59,53 17.84,53 17.99,53.15 ED5701.9 ED5701.2 19.6,53.15 19.77,53.32 ER5714.1 20.61,53.32 20.66,53.27 R5701.2
HDMI_DDI_TX_CON_P0: length 13.4
  TOP w0.102: HDMI1.1 10.69,54.96 10.84,54.96 10.96,54.83 10.96,54.46 13.17,52.25 13.17,52.21 15.9,49.47 ED5702.10 ED5702.1 19.64,49.47 ER5716.2 20.76,49.1 R5708.2
HDMI_DDI_TX_CON_P1: length 13.2
  TOP w0.102: HDMI1.4 12.13,56.4 12.77,56.4 12.99,56.17 12.99,53.33 15.21,51.11 17.47,51.11 17.6,50.98 ED5702.7 ED5702.4 19.73,50.98 ER5717.2 20.43,50.68 20.49,50.73 R5704.2
HDMI_DDI_TX_CON_P2: length 24.8
  TOP w0.102: R5706.2 20.64,54.16 20.59,54.11 ER5715.2 19.71,54.11 19.66,54.15 ED5701.4 ED5701.7 17.96,54.15 17.84,54.27 17.55,54.27 v2(16.93,53.65)
  L8 w0.089: HDMI1.7 10.71,57.98 10.9,57.98 10.99,57.89 10.99,54.37 12.99,52.37 12.99,51.18 12.81,50.99 12.81,48.61 13.56,47.86 14.56,47.86 14.87,48.18 14.87,50.6 16.3,52.03 16.3,53.66 16.51,53.87 16.71,53.87 v2(16.93,53.65)
HDMI_DDI_TX_CON_P3: length 15.4
  TOP w0.102: R5702.2 20.59,52.51 20.54,52.46 ER5714.2 19.83,52.46 19.64,52.65 ED5701.1 ED5701.10 17.98,52.65 17.86,52.77 17.68,52.77 17.04,52.13 15.13,52.13 14.99,52.26 14.24,53.01 14.24,56.13 12.69,57.68 12.69,59.1 12.31,59.49 12.22,59.49 HDMI1.10
HDMI_DDI_TX_N0: length 89.6
  TOP w0.102: C5708.1 24.73,49.56 25.57,49.56 25.8,49.32 26.1,49.32 26.2,49.43 26.2,49.79 26.3,49.89 26.5,49.89 v2(26.63,49.76)
  L3 w0.089: v2(26.63,49.76) 26.49,49.9 26.29,49.9 26.16,49.77 26.16,49.38 26.07,49.29 25.11,49.29 25.11,49.29 24.77,49.29 24.09,49.97 24.09,56.38 24.83,57.11 27.45,57.11 28.42,58.08 28.42,60.18 29.17,60.93 29.17,61.95 30.54,63.32 30.95,63.32 32.52,64.89 32.52,65.33 36.06,68.86 37.93,68.86 38.4,68.4 39.33,68.4 40.05,69.12 44.2,69.12 44.98,69.9 51.06,69.9 53.09,71.93 53.3,72.14 58.79,72.14 62.45,68.48 63.63,68.48 64.55,67.57 71.83,67.57 72.74,66.66 82.89,66.66 85.59,63.97 85.59,62.34 85.5,62.25 85.37,62.25 v3(85.13,62.49)
  BOTTOM w0.102: v3(85.13,62.49) 85.13,62.59 85.37,62.83 CPU1.AL5
HDMI_DDI_TX_N1: length 85.5
  TOP w0.102: C5706.1 24.59,51.22 25.29,51.22 25.46,51.06 25.92,51.06 v2(26.2,51.34)
  L3 w0.089: v3(84.11,62.59) 84.39,62.59 84.48,62.68 84.48,63.42 82.66,65.24 72.83,65.24 71.05,67.02 63.14,67.02 58.57,71.59 53.53,71.59 51.24,69.31 45.34,69.31 44.44,68.41 40.11,68.41 39.17,67.47 37.91,67.47 37.89,67.49 37.76,67.49 37.41,67.83 37.41,68.15 37.24,68.32 36.28,68.32 33.25,65.28 33.25,64.63 32.63,64.01 32.63,62.45 31.8,61.62 31.8,58.9 29.48,56.57 25.05,56.57 24.76,56.27 24.76,51.06 25.08,50.74 25.6,50.74 25.69,50.83 25.69,51.82 25.78,51.91 26.11,51.91 26.2,51.82 v2(26.2,51.34)
  BOTTOM w0.102: CPU1.AJ5 84.35,62.83 v3(84.11,62.59)
HDMI_DDI_TX_N2: length 73.3
  TOP w0.102: v2(25.3,55.06) 24.94,54.7 24.41,54.7 C5704.1
  L3 w0.089: v2(25.3,55.06) 26.18,55.06 26.6,55.48 28.89,55.48 32.23,58.82 32.23,61.33 35.2,64.3 35.2,65.67 36.64,67.11 39.32,67.11 40.15,67.95 45.52,67.95 46.53,68.95 51.04,68.95 51.47,68.52 53.27,68.52 54.89,70.14 59.27,70.14 62.78,66.63 70.69,66.63 72.56,64.76 82.45,64.76 83.12,64.09 83.12,62.82 82.92,62.62 82.49,62.62 v2(82.31,62.44)
  BOTTOM w0.102: CPU1.AF6 v2(82.31,62.44)
HDMI_DDI_TX_N3: length 70.3
  TOP w0.102: v2(25.9,53.39) 25.51,53 24.46,53 C5702.1
  L3 w0.089: v2(81.38,62.52) 81.1,62.25 80.77,62.25 80.64,62.12 80.27,62.12 78.86,63.53 55.88,63.53 52.17,67.24 50.59,67.24 49.92,67.91 46.5,67.91 45.68,67.08 44.8,67.08 44.26,66.53 36.84,66.53 35.75,65.45 35.75,64.07 32.85,61.17 32.85,58.63 29.43,55.2 29.43,53.65 28.87,53.1 28.46,53.1 28.12,53.43 26.95,53.43 26.59,53.08 26.21,53.08 v2(25.9,53.39)
  BOTTOM w0.102: v2(81.38,62.52) 81.38,62.52 81.38,62.52 CPU1.AE5
HDMI_DDI_TX_P0: length 89.6
  TOP w0.102: C5709.1 24.45,49.33 25.47,49.33 25.71,49.1 v2(26.63,49.1)
  L3 w0.089: v3(85.13,61.85) 85.33,62.06 85.58,62.06 85.78,62.26 85.78,64.04 82.97,66.85 72.82,66.85 71.91,67.76 64.63,67.76 63.71,68.67 62.53,68.67 58.87,72.33 53.22,72.33 52.96,72.07 50.98,70.09 44.91,70.09 44.12,69.31 39.97,69.31 39.25,68.59 38.48,68.59 38.01,69.05 35.98,69.05 32.33,65.41 32.33,64.97 30.88,63.51 30.47,63.51 28.98,62.03 28.98,61.01 28.23,60.26 28.23,58.16 27.37,57.3 24.75,57.3 23.9,56.46 23.9,49.89 24.69,49.1 25.03,49.1 25.03,49.1 v2(26.63,49.1)
  BOTTOM w0.102: CPU1.AL6 85.45,62.18 v3(85.13,61.85)
