# Allegro board 18769-1-MAR04-1554.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
Net_26308 on BOTTOM_-MB (solid shape): outline of 81 points within 132.13,3.34 142.63,17.28
Net_26309 on BOTTOM_-MB (solid shape): outline of 446 points within 99.02,3.66 122.24,12.96
Net_26310 on BOTTOM_-MB (solid shape): 76.93,5.46 76.93,5.34 76.06,4.47 76.06,3.88 75.97,3.79 75.54,3.79 75.26,4.07 75.26,4.63 75.34,4.71 75.56,4.71 75.96,5.11 75.96,5.64 76.74,5.64
Net_26311 on BOTTOM_-MB (solid shape): 80.35,6.28 80.35,5.9 80.23,5.77 79.74,5.77 79.74,5.78 79.59,5.78 79.59,5.8 78.42,5.8 78.42,5.62 78.19,5.39 77.18,5.39 77,5.57 77,5.8 75.83,5.8 75.83,5.69 75.78,5.64 75.78,5.14 75.53,4.88 74.76,4.88 74.51,5.14 74.51,5.9 74.89,6.28 75.78,6.28 75.83,6.23 75.83,6.2 75.86,6.2 75.91,6.15 76.8,6.15 76.84,6.2 77,6.2 77,6.35 77.18,6.53 80.1,6.53
Net_26312 on BOTTOM_-MB (solid shape): outline of 159 points within 0.51,5.46 3.06,26.3
Net_26313 on BOTTOM_-MB (solid shape): 89.77,7.67 89.94,7.63 90.1,7.67 90.11,7.68 90.39,7.68 90.64,7.42 90.64,6.41 90.39,6.15 89.05,6.15 89.05,6.25 87.88,6.25 87.88,6.06 87.72,5.9 86.45,5.9 86.32,5.77 86.2,5.77 86.2,5.8 84.98,5.8 84.94,5.77 84.04,5.77 83.79,6.03 83.79,6.52 83.92,6.66 85.29,6.66 85.29,6.65 86.46,6.65 86.46,6.79 86.7,7.04 87.72,7.04 87.88,6.88 87.88,6.65 89.05,6.65 89.05,6.67 89.24,6.67 89.54,6.96 89.54,7.68 89.76,7.68
Net_26314 on BOTTOM_-MB (solid shape): 97.09,12.02 97.09,7.81 97.09,7.81 97.09,7.33 96.02,6.25 91.3,6.25 90.88,6.68 90.88,11.27 91.66,11.27 91.66,11.52 92.32,11.52 92.32,11.27 92.57,11.27 92.59,11.27 93.76,11.27 93.76,11.27 94.87,11.27 94.87,11.52 95.53,11.52 95.53,11.27 95.79,11.27 95.82,11.27 96.07,11.27 96.07,11.53 95.82,11.53 95.79,11.52 94.62,11.52 94.62,11.27 93.76,11.27 93.76,11.52 93.51,11.52 93.51,11.27 92.85,11.27 92.85,11.52 92.59,11.52 92.57,11.52 91.41,11.52 91.41,11.27 90.88,11.27 90.88,12.18 91.02,12.33 91.14,12.33 91.15,12.34 94.03,12.34 94.07,12.37 96.74,12.37
Net_26315 on BOTTOM_-MB (solid shape): 22.67,7.2 22.67,6.45 22.54,6.33 19.98,6.33 19.59,6.72 19.59,7.72 19.76,7.9 21.97,7.9
Net_26316 on BOTTOM_-MB (solid shape): 166.12,10.49 166.12,7.97 165.11,6.96 163.16,6.96 162.7,7.42 162.7,9.55 163.39,9.55 163.41,9.53 163.41,7.96 163.54,7.83 164.53,7.83 164.6,7.9 164.61,7.9 164.78,8.08 164.78,9.79 164.78,9.81 164.55,10.04 164.55,10.55 164.68,10.67 165.93,10.67
Net_26317 on BOTTOM_-MB (solid shape): 173.55,9.76 173.55,8.33 173.57,8.31 173.57,8.25 173.63,8.25 173.96,7.92 173.96,7.5 173.77,7.3 172.59,7.3 171.84,8.05 171.84,8.25 171.86,8.25 171.86,9.39 171.84,9.39 171.84,9.7 171.97,9.83 173.48,9.83
Net_26318 on BOTTOM_-MB (solid shape): 8.17,12.15 8.17,12.02 8.24,11.95 8.24,11.41 8.28,11.41 8.28,10.69 7.14,9.56 7.14,8.98 7.13,8.96 7.11,8.91 7.09,8.86 7.09,8.8 7.09,8.75 7.1,8.69 7.11,8.64 7.14,8.59 7.17,8.55 7.2,8.51 7.24,8.47 7.29,8.44 7.34,8.42 7.39,8.41 7.45,8.4 7.5,8.4 7.56,8.41 7.61,8.42 7.64,8.44 7.79,8.44 7.88,8.35 7.88,7.79 7.79,7.7 7.31,7.7 7.22,7.79 6.19,7.79 6.12,7.85 6.12,8 7.14,8 7.14,8.25 6.88,8.25 6.88,8 6.12,8 6.12,9.25 7.47,10.59 7.52,10.58 7.57,10.58 7.62,10.58 7.67,10.6 7.72,10.62 7.76,10.64 7.79,10.68 7.83,10.72 7.85,10.76 7.87,10.81 7.87,10.86 7.88,10.91 7.87,10.96 7.86,10.99 7.86,11.33 7.89,11.36 7.89,11.41 7.9,11.41 7.9,11.9 7.97,11.97 7.97,12.17 8.15,12.17
Net_26319 on BOTTOM_-MB (solid shape): 160.16,10.62 160.16,9.96 160.54,9.58 161.33,9.58 161.43,9.48 161.43,8.08 161.38,8.03 159.65,8.03 158.56,9.12 158.56,10.64 158.68,10.75 160.03,10.75
Net_26320 on BOTTOM_-MB (solid shape): 162.45,10.39 162.45,8.08 162.37,8.01 161.79,8.01 161.58,8.21 161.58,9.68 161.53,9.73 161.53,9.74 161.48,9.78 160.54,9.78 160.36,9.96 160.36,10.47 160.62,10.72 162.12,10.72
Net_26321 on BOTTOM_-MB (solid shape): 142.67,9.83 142.89,9.83 143.02,9.7 143.02,9.65 143.71,8.97 143.75,8.97 143.91,8.81 143.91,8.78 144.13,8.56 144.13,8.23 143.98,8.08 143.85,8.08 143.85,8.09 143.58,8.09 143.23,8.43 143.23,8.45 143.03,8.73 142.69,8.75 142.68,8.74 142.33,8.74 142.2,8.87 142.2,9.71 142.33,9.83 142.67,9.83
Net_26322 on BOTTOM_-MB (solid shape): 164.38,10.55 164.38,10.01 164.66,9.73 164.66,8.13 164.55,8.03 163.77,8.03 163.59,8.21 163.59,9.56 163.53,9.61 163.53,9.74 162.72,9.74 162.6,9.86 162.6,10.62 162.85,10.88 164.05,10.88
Net_26323 on BOTTOM_-MB (solid shape): 181.52,11.25 181.57,11.2 181.64,11.15 183.07,9.72 183.07,9.39 183.07,8.39 183.01,8.33 181.25,8.33 181.18,8.39 181.18,9.36 181.36,9.53 181.37,9.53 181.55,10.09 180.97,10.17 180.94,10.14 180.8,10.27 180.8,10.32 180.8,10.33 180.8,10.85 181.19,11.25
Net_26324 on BOTTOM_-MB (solid shape): 183.54,10.95 185.31,10.95 186.55,9.71 186.55,8.35 186.52,8.33 184.73,8.33 184.7,8.36 184.7,9.33 184.6,9.42 183.55,9.42 181.54,11.44 181.54,11.83 181.61,11.91 182.58,11.91
Net_26325 on BOTTOM_-MB (solid shape): 6.57,12.51 6.57,11.14 5.1,9.67 5.1,9.64 4.68,9.22 4.63,9.22 4.58,9.22 4.53,9.2 4.49,9.18 4.44,9.15 4.41,9.11 4.38,9.07 4.36,9.02 4.34,8.97 4.34,8.9 4.29,8.9 4.01,8.62 3.46,8.62 3.21,8.37 3.08,8.37 3.07,8.36 2.26,8.36 1.87,8.75 1.87,9.44 2.14,9.44 2.14,9.19 2.4,9.19 2.4,9.44 2.45,9.47 2.45,9.73 2.2,9.73 2.2,9.47 2.14,9.44 1.87,9.44 1.87,10.01 1.97,10.11 2.26,10.11 2.87,9.51 2.88,9.47 2.91,9.42 2.94,9.38 2.98,9.34 3.03,9.3 3.08,9.28 3.13,9.26 3.19,9.25 3.24,9.25 3.3,9.26 3.33,9.27 3.86,9.27 6,11.4 6,11.84 6.03,11.87 6.03,12.47 6.08,12.52 6.56,12.52
Net_26326 on BOTTOM_-MB (solid shape): 25.7,10.79 25.7,9.08 25.58,8.96 22.04,8.96 21.5,8.43 19.73,8.43 19.53,8.63 19.53,9.42 19.74,9.63 19.97,9.63 20,9.62 20.03,9.61 20.05,9.61 20.39,9.61 21.33,9.61 21.33,9.87 21.08,9.87 21.08,9.61 20.39,9.61 20.44,9.62 20.47,9.64 20.5,9.66 20.53,9.69 20.55,9.72 20.56,9.75 20.66,9.85 20.66,10.28 21.05,10.67 21.11,10.67 21.14,10.62 21.16,10.57 21.2,10.53 21.23,10.49 21.28,10.45 21.32,10.43 21.38,10.41 21.43,10.4 21.48,10.39 21.54,10.4 21.59,10.41 21.64,10.43 21.69,10.45 21.73,10.49 21.77,10.53 21.8,10.57 21.83,10.62 21.85,10.67 22.81,10.67 22.83,10.62 22.86,10.57 22.9,10.53 22.94,10.49 22.99,10.46 23.04,10.43 23.09,10.42 23.15,10.41 23.2,10.41 23.26,10.42 23.31,10.43 23.36,10.46 23.41,10.49 23.45,10.53 23.49,10.57 23.52,10.62 23.54,10.67 24.93,10.67 25.13,10.88 25.61,10.88
Net_26327 on BOTTOM_-MB (solid shape): 77.48,12.56 77.48,8.64 77.34,8.49 76.95,8.49 76.49,8.95 77.13,8.95 77.13,9.2 76.88,9.2 76.88,8.95 76.49,8.95 75.09,10.34 74.76,10.34 74.51,10.6 74.51,10.94 74.55,10.97 74.57,10.99 74.59,11.02 74.61,11.06 74.61,11.09 74.61,11.11 74.61,11.44 74.61,11.46 74.61,11.5 74.59,11.53 74.57,11.56 74.55,11.59 74.51,11.61 74.51,11.65 74.42,11.73 74.08,11.73 73.95,11.87 73.95,12.14 74.61,12.14 74.61,12.39 74.36,12.39 74.36,12.14 73.95,12.14 73.95,12.43 74.4,12.88 77.16,12.88
Net_26328 on BOTTOM_-MB (solid shape): 64.69,10.5 64.69,9 64.41,8.72 62.33,8.72 62.14,8.91 62.14,8.93 62.11,8.94 59.65,8.94 59.51,9.07 59.51,10.3 59.82,10.6 61.02,10.6 61.26,10.36 61.27,10.34 61.32,10.26 61.39,10.22 61.41,10.21 61.47,10.15 62.57,10.15 62.6,10.12 63.09,10.12 63.32,10.04 63.54,10.15 63.66,10.15 64.14,10.63 64.57,10.63
Net_26329 on BOTTOM_-MB (solid shape): 28.76,10.88 28.8,10.82 28.85,10.76 28.88,10.69 28.85,10.62 29.14,9.98 29.4,10.63 29.37,10.7 29.4,10.77 29.44,10.83 29.47,10.88 29.48,10.92 35.67,10.92 35.99,10.6 35.99,10.06 35.84,9.91 35.82,9.92 35.49,9.81 35.38,9.48 35.39,9.46 35.09,9.17 34.09,9.17 33.99,9.18 33.89,9.17 30.98,9.17 30.79,9.36 30.43,9.46 30.15,9.2 30.14,9.17 29.49,9.17 29.47,9.18 28.44,9.18 28.41,9.21 28.41,10.75 28.58,10.92 28.75,10.92
Net_26330 on BOTTOM_-MB (solid shape): 6.63,12.68 6.59,12.65 6.03,12.65 6.01,12.63 5.88,12.63 5.88,12.17 5.91,12.17 5.91,11.93 5.87,11.89 5.87,11.46 3.81,9.39 3.16,9.39 2.97,9.58 2.97,9.79 3.12,9.94 3.52,9.93 3.54,9.93 3.58,9.93 3.61,9.95 3.65,9.97 3.67,10 3.69,10.03 3.71,10.06 3.72,10.1 3.72,10.15 3.8,10.23 3.8,10.71 4.09,10.71 4.22,10.43 4.48,10.43 4.48,10.69 4.34,10.97 4.09,10.97 4.09,10.71 3.8,10.71 3.8,10.86 3.8,10.88 3.81,10.92 3.81,10.94 3.81,11.42 4.29,11.9 5.02,11.9 5.06,11.92 5.1,11.95 5.13,11.98 5.16,12.02 5.17,12.05 5.28,12.16 5.28,12.28 5.37,12.37 5.37,12.83 5.46,12.92 6.63,12.92
Net_26331 on BOTTOM_-MB (solid shape): 114.15,12.89 114.16,12.89 114.27,12.79 114.57,12.79 114.57,12.79 114.82,12.8 115,12.96 115,12.97 115.13,13.1 115.13,13.32 115.25,13.44 117.58,13.44 117.6,13.46 118.4,13.46 118.55,13.31 118.55,12.51 118.48,12.44 118.47,12.44 118.34,12.37 118.24,12.26 115.11,12.26 114.93,12.09 114.93,10.35 114.94,10.34 114.94,10.32 114.69,10.07 112.76,10.07 112.68,10.08 112.6,10.07 109.72,10.07 109.6,9.95 109.6,9.58 109.48,9.45 109.14,9.45 109,9.58 109,12.2 109.07,12.26 110.92,12.26 111.18,12.52 111.18,12.67 111.18,12.68 111.22,12.8 111.21,12.92 111.22,13 111.29,13.05 111.53,13.17 111.66,13.4 111.71,13.46 111.8,13.46 111.95,13.43 112.11,13.45 112.18,13.44 112.23,13.38 112.77,13.01 113.18,13.5 113.21,13.58 113.29,13.61 113.44,13.61
Net_26332 on BOTTOM_-MB (solid shape): 128.41,18.62 128.41,18.29 128.39,18.27 128.39,16.48 128.41,16.46 128.41,15.34 128.47,15.28 128.47,13.48 129.6,12.35 131.33,12.35 131.42,12.26 131.4,12.23 131.5,11.68 132.04,11.59 132.08,11.6 132.84,10.84 132.84,10 132.74,9.9 127.84,9.9 127.01,10.73 127.01,10.86 126.97,10.95 126.97,10.96 126.97,12.58 126.95,12.6 126.95,12.95 126.61,13.29 126.59,13.32 126.57,13.34 126.3,13.6 126.31,13.61 126.31,13.71 126.35,13.75 126.35,16.59 126.92,17.16 126.92,18.48 127.27,18.83 128.21,18.83
Net_26333 on BOTTOM_-MB (solid shape): 145.56,16.75 145.56,15.5 145.42,15.36 145.09,15.36 144.98,15.25 144.98,11.44 143.88,10.35 143.83,10.37 143.77,10.38 143.72,10.38 143.66,10.37 143.61,10.36 143.57,10.34 142.87,10.34 142.65,10.56 142.65,13.66 142.95,13.95 142.95,15.46 144.69,15.46 144.69,15.72 144.44,15.72 144.44,15.46 142.95,15.46 142.95,16.38 144.69,16.38 144.69,16.63 144.44,16.63 144.44,16.38 142.95,16.38 142.95,17.13 143.13,17.32 143.19,17.31 143.25,17.3 143.3,17.31 143.36,17.32 143.42,17.33 143.47,17.36 143.52,17.39 143.54,17.41 144.9,17.41
Net_26334 on BOTTOM_-MB (solid shape): 121.18,12.21 121.18,11.48 121.14,11.48 121.14,10.77 120.98,10.61 115.25,10.61 115.14,10.72 115.14,11.87 115.38,12.11 118.24,12.11 118.27,12.14 118.36,12.14 118.53,12.31 118.56,12.31 118.56,12.33 118.68,12.46 118.68,12.55 118.91,12.78 120.61,12.78
Net_26335 on BOTTOM_-MB (solid shape): 88.57,12.35 88.57,11.98 88.52,11.94 88.11,11.94 88.11,11.94 87.86,11.94 87.61,11.69 86.55,11.69 86.4,11.84 86.4,12.2 86.54,12.34 86.56,12.35 86.94,12.35 86.96,12.34 87.13,12.3 87.3,12.34 87.31,12.35 87.62,12.35 87.73,12.46 88.47,12.46
Net_26336 on BOTTOM_-MB (solid shape): 70.8,13.23 70.8,12.14 70.56,11.9 69.1,11.9 69.07,11.92 69.03,11.94 68.99,11.94 68.97,11.94 68.59,11.94 68.57,11.94 68.53,11.94 68.5,11.92 68.47,11.9 68.29,11.9 68.26,11.92 68.22,11.94 68.18,11.94 68.16,11.94 67.78,11.94 67.76,11.94 67.72,11.94 67.68,11.92 67.65,11.9 67.33,11.9 67.28,11.95 66.75,11.95 66.7,11.9 66.04,11.9 65.96,11.97 65.96,12.35 70.36,12.35 70.36,12.89 70.11,12.89 70.11,12.35 65.96,12.35 65.96,13.09 66.02,13.15 70.36,13.15 70.36,13.4 70.11,13.4 70.11,13.15 66.02,13.15 66.29,13.42 66.31,13.42 66.48,13.59 70.44,13.59
Net_26337 on BOTTOM_-MB (solid shape): 65.42,13.69 65.42,12.88 65.32,12.78 64.85,12.78 64.75,12.69 64.74,12.68 64.72,12.65 64.72,11.97 64.64,11.9 64.08,11.9 64.05,11.93 57.57,11.93 57.51,11.96 57.44,11.98 57.06,11.98 57.03,11.97 56.97,11.96 56.74,12.19 56.74,12.64 56.92,12.83 57.03,12.83 57.05,12.81 57.36,12.7 57.64,12.87 57.7,12.93 57.7,13.08 57.7,13.14 57.7,13.34 58.22,13.87 61.23,13.87 61.28,13.92 65.19,13.92
Net_26338 on BOTTOM_-MB (solid shape): 3.92,14.87 4.33,14.87 5.22,13.98 5.22,13.97 5.86,13.34 6.61,13.34 6.64,13.31 6.64,13.12 6.56,13.05 5.27,13.05 5.15,12.93 5.15,12.21 4.97,12.03 4.26,12.03 3.95,12.34 3.95,13.07 4.14,13.07 4.14,12.81 4.4,12.81 4.4,13.07 4.4,13.1 4.4,13.35 4.15,13.35 4.15,13.1 4.14,13.07 3.95,13.07 3.95,13.98 3.91,14.01 4.4,14.01 4.4,14.27 4.15,14.27 4.15,14.01 3.91,14.01 3.87,14.06 3.86,14.1 3.84,14.14 3.82,14.18 3.78,14.21 3.75,14.24 3.7,14.26 3.66,14.27 3.64,14.27 3.09,14.27 2.9,14.45 2.9,14.46 2.9,14.93 3.01,15.04 3.76,15.04
Net_26339 on BOTTOM_-MB (solid shape): outline of 613 points within 166.41,11.95 174.41,31.78
Net_26340 on BOTTOM_-MB (solid shape): 97.12,13.64 97.12,13.01 96.86,12.76 90.89,12.76 90.64,13.01 90.64,13.37 91.66,13.37 91.66,13.63 92.32,13.63 92.32,13.37 92.57,13.37 92.59,13.37 93.76,13.37 93.76,13.38 94.87,13.38 94.87,13.63 95.53,13.63 95.53,13.38 95.79,13.38 95.82,13.38 96.07,13.38 96.07,13.63 95.82,13.63 95.79,13.63 94.62,13.63 94.62,13.38 93.76,13.38 93.76,13.63 93.51,13.63 93.51,13.37 92.85,13.37 92.85,13.63 92.59,13.63 92.57,13.63 91.41,13.63 91.41,13.37 90.64,13.37 90.64,13.9 91.02,14.28 96.48,14.28
Net_26341 on BOTTOM_-MB (solid shape): 134.17,17.89 134.17,14.12 133.06,13.01 129.15,13.01 128.6,13.56 128.6,14.09 131.65,14.09 131.65,14.03 131.66,13.97 131.68,13.91 131.71,13.85 131.74,13.8 131.78,13.75 131.82,13.71 131.87,13.67 131.92,13.64 131.98,13.62 132.04,13.6 132.1,13.59 132.16,13.59 132.23,13.6 132.29,13.62 132.34,13.64 132.4,13.67 132.45,13.71 132.49,13.75 132.53,13.8 132.56,13.85 132.59,13.91 132.61,13.97 132.62,14.03 132.62,14.09 132.61,14.15 132.6,14.21 132.58,14.27 132.55,14.33 132.51,14.38 132.47,14.42 132.42,14.46 132.37,14.5 132.32,14.52 132.26,14.54 132.2,14.56 132.13,14.56 132.07,14.56 132.01,14.54 131.95,14.52 131.9,14.5 131.84,14.46 131.8,14.42 131.76,14.38 131.72,14.33 131.69,14.27 131.67,14.21 131.66,14.15 131.65,14.09 128.6,14.09 128.6,15.33 128.6,15.34 128.6,18.31 129.15,18.86 133.2,18.86
Net_26342 on BOTTOM_-MB (solid shape): outline of 114 points within 125,13.68 138.07,21.68
Net_26343 on BOTTOM_-MB (solid shape): 4.34,16 4.68,16 4.68,15.77 4.73,15.64 4.87,15.58 5.2,15.58 5.36,15.42 5.36,14.83 5.37,14.82 5.37,14.77 5.86,14.27 5.86,14.17 5.9,14.12 6.6,14.12 6.64,14.08 6.64,13.91 6.57,13.84 5.87,13.84 4.48,15.23 4.46,15.23 4.26,15.43 3.77,15.43 3.62,15.57 3.62,16.1 3.7,16.18 4.16,16.18
Net_26344 on BOTTOM_-MB (solid shape): 196.23,15.58 196.23,15.05 196.05,14.87 196,14.87 195.84,14.83 195.72,14.72 195.15,14.72 194.87,14.44 194.86,14.43 194.71,14.34 194.62,14.19 194.62,14.18 194.43,14 193.86,14 193.62,14.23 193.62,14.92 194.52,15.82 195.99,15.82
Net_26345 on BOTTOM_-MB (solid shape): 143.58,18.65 143.58,17.79 143.32,17.53 143.17,17.53 143.04,17.4 142.36,17.4 141.31,17.4 141.03,17.13 141.03,17.1 141.01,17.07 141.01,14.52 140.93,14.44 137.69,14.44 137.22,14.92 137.22,15.8 137.39,16.17 137.22,16.54 137.22,16.75 137.49,17.18 137.22,17.62 137.22,17.9 138.62,19.31 142.91,19.31
Net_26346 on BOTTOM_-MB (solid shape): 12.36,15.91 12.39,15.9 12.43,15.89 12.45,15.89 12.83,15.89 12.85,15.89 12.89,15.9 12.92,15.91 12.95,15.93 13.1,15.93 13.13,15.91 13.17,15.89 13.21,15.88 13.23,15.88 13.61,15.88 13.63,15.88 13.67,15.89 13.7,15.91 13.73,15.93 14.25,15.93 14.39,15.79 14.39,15.4 14.08,15.1 12.75,15.1 12.67,15.11 12.29,15.11 12.22,15.1 11.93,15.1 11.86,15.11 11.48,15.11 11.46,15.11 11.42,15.1 11.39,15.09 11.36,15.07 11.33,15.04 11.31,15.01 11.29,14.98 11.29,14.94 11.29,14.88 11.06,14.65 9.97,14.65 9.92,14.71 9.92,14.88 9.96,14.92 10.63,14.92 10.74,15.03 10.74,15.34 12.25,15.34 12.25,15.59 12,15.59 12,15.34 11.74,15.34 11.74,15.59 11.49,15.59 11.49,15.34 10.74,15.34 10.74,15.42 11.06,15.73 11.14,15.73 11.26,15.86 11.33,15.88 11.36,15.9 11.4,15.93 12.33,15.93
Net_26347 on BOTTOM_-MB (solid shape): 8.34,17.67 8.34,16.99 8.23,16.87 8.23,16.01 8.23,15.46 8.16,15.39 7.98,15.39 7.9,15.48 7.9,16.19 7.89,16.19 7.89,16.93 7.64,17.18 7.64,17.6 7.71,17.68 7.97,17.68 7.98,17.69 8.32,17.69
Net_26348 on BOTTOM_-MB (solid shape): 116.61,20.09 116.61,16.15 116.6,16.13 116.17,15.7 114.58,15.7 114.48,15.8 114.48,16.86 115.51,16.86 115.51,18.42 114.48,18.42 114.48,20.12 114.7,20.34 116.36,20.34
Net_26349 on BOTTOM_-MB (solid shape): 37.58,17.99 37.58,17.45 37.52,17.39 37.46,17.4 37.08,17.4 37.02,17.39 36.96,17.36 36.95,17.35 36.85,17.35 36.84,17.36 36.59,17.45 36.34,17.35 35.32,17.35 35.17,17.51 35.17,17.94 35.34,18.12 37.45,18.12
Net_26350 on BOTTOM_-MB (solid shape): outline of 15589 points within 43.01,18.34 113.63,37.39
Net_26351 on BOTTOM_-MB (solid shape): 150.91,20.66 150.91,19.95 150.85,19.89 148.96,19.89 148.28,19.21 147.92,19.21 147.78,19.35 147.78,19.71 147.83,19.71 148.08,19.85 148.17,20.12 148.16,20.15 148.82,20.81 150.76,20.81
Net_26352 on BOTTOM_-MB (solid shape): 144.72,26.4 144.72,26.27 144.82,26.17 145.17,26.17 145.88,25.46 145.88,24.36 146.34,23.91 146.34,23.22 146.29,23.17 145.4,23.17 145.15,23.42 145.15,23.65 145.96,23.65 145.96,23.9 145.71,23.9 145.71,23.65 145.15,23.65 145.16,23.7 145.18,23.75 145.18,23.8 145.18,23.85 145.18,23.9 145.16,23.95 145.15,23.98 145.15,24.65 145.18,24.71 145.18,24.76 145.18,25.14 145.18,25.16 145.18,25.19 145.16,25.23 145.14,25.26 145.12,25.28 145.09,25.31 145.05,25.32 145.02,25.33 144.95,25.41 144.03,25.41 143.68,25.76 143.68,25.9 144.42,25.9 144.42,26.16 144.16,26.16 144.16,25.9 143.68,25.9 143.68,26.55 143.9,26.78 144.34,26.78
Net_26354 on BOTTOM_-MB (solid shape): outline of 191 points within 6.68,27.69 13.44,30.21
Net_26355 on BOTTOM_-MB (solid shape): 32.55,35.64 32.55,34.83 33.09,34.29 33.09,34.27 33.2,34.05 33.42,33.94 33.44,33.94 33.72,33.66 33.72,30.18 33.05,29.51 33.05,28.99 33.07,28.98 33.07,28.6 32.96,28.5 32.49,28.5 32.37,28.61 32.37,28.97 32.36,28.97 32.32,29.01 32.32,29.02 31.92,29.26 31.58,28.95 31.58,28.93 31.55,28.9 30.99,28.9 30.93,28.96 30.9,28.96 30.81,29.05 30.81,29.07 30.44,29.44 30.36,29.44 30.31,29.49 29.07,29.49 28.89,29.67 28.89,30.43 28.94,30.49 30.09,30.49 30.11,30.46 30.49,30.46 30.67,30.64 30.67,33.66 30.72,33.71 31.25,33.71 31.39,33.84 31.42,33.84 31.86,34.07 31.69,34.54 31.69,35.67 31.76,35.74 32.45,35.74
Net_26356 on BOTTOM_-MB (solid shape): 141.8,31.09 141.8,30.56 141.21,29.98 141.21,29.39 141.03,29.22 140.37,29.22 140.2,29.39 140.2,30.21 140.21,30.23 140.25,30.27 140.27,30.32 140.29,30.38 140.29,30.43 140.29,30.45 141.47,30.45 141.47,30.71 141.21,30.71 141.21,30.45 140.29,30.45 140.29,30.49 140.29,30.55 140.27,30.6 140.25,30.65 140.21,30.7 140.2,30.72 140.2,30.94 140.5,31.25 141.64,31.25
Net_26357 on BOTTOM_-MB (solid shape): 150.62,30.97 150.62,30.32 150.66,30.28 150.66,29.37 150.51,29.22 149.87,29.22 149.36,29.73 149.36,30.11 149.36,30.14 149.35,30.18 149.33,30.23 149.31,30.26 149.29,30.28 149.29,30.38 149.54,30.38 149.64,30.34 149.64,30.09 149.9,30.09 149.9,30.34 149.79,30.38 149.79,30.63 149.54,30.63 149.54,30.38 149.29,30.38 149.29,30.49 149.14,30.64 149.14,30.94 149.33,31.13 150.46,31.13
Net_26358 on BOTTOM_-MB (solid shape): outline of 246 points within 10.68,29.29 15.71,36.58
Net_26359 on BOTTOM_-MB (solid shape): 40.45,31.86 40.45,30.33 39.92,29.8 37.45,29.8 37.22,29.57 33.97,29.57 33.9,29.65 33.9,30.9 38.58,30.9 38.58,31.16 38.32,31.16 38.32,30.9 37.66,30.9 37.66,31.16 37.41,31.16 37.41,30.9 33.9,30.9 33.9,31.65 34.02,31.78 35.42,31.78 35.67,31.53 37.12,31.53 37.28,31.69 38.58,31.69 38.58,31.94 38.32,31.94 38.32,31.69 37.28,31.69 37.68,32.09 40.22,32.09
Net_26360 on BOTTOM_-MB (solid shape): 148.93,31.04 148.93,30.49 148.83,30.38 146.77,30.38 146.75,30.41 146.75,30.75 146.8,30.84 146.9,30.84 146.99,30.81 147.08,30.8 147.09,30.8 147.3,30.86 147.44,31.01 147.45,31.04 148.42,31.04 148.53,31.15 148.83,31.15
Net_26361 on BOTTOM_-MB (solid shape): outline of 180 points within 154.47,30.62 162.55,38.67
Net_26362 on BOTTOM_-MB (solid shape): outline of 277 points within 27.24,31.81 41.08,36.94
Net_26363 on BOTTOM_-MB (solid shape): outline of 251 points within 21.86,32.38 28.85,46.24
Net_26364 on BOTTOM_-MB (solid shape): 184.39,34.19 184.39,33.43 184.59,33.23 185.08,33.23 185.28,33.43 185.28,34.02 185.36,34.09 185.91,34.09 185.97,34.04 185.97,33.38 185.97,32.56 185.67,32.26 181.8,32.26 181.24,32.83 181.25,32.86 181.27,33.07 181.17,33.26 181.17,34.17 181.34,34.35 184.24,34.35
Net_26365 on BOTTOM_-MB (solid shape): 153.11,38.22 153.09,38.16 153.09,37.14 153.43,37.14 153.48,37.09 156.22,37.09 156.85,36.46 156.85,32.82 156.58,32.55 155.3,32.55 155.3,32.58 154.46,32.58 154.37,32.63 154.37,32.72 154.06,33.41 153.46,32.96 153.46,32.91 152.02,32.91 152.02,33.02 152.13,33.13 152.13,37.27 152.11,37.29 152.11,38.26 152.23,38.38 152.95,38.38
Net_26366 on BOTTOM_-MB (solid shape): 153.3,43.62 153.3,39.23 152.78,38.71 152.07,38.71 151.75,38.38 151.75,33.2 151.46,32.91 151.29,32.91 151.2,32.82 149.69,32.82 148.74,33.78 148.74,38.83 148.27,39.3 148.27,43.09 149.05,43.87 153.05,43.87
Net_26367 on BOTTOM_-MB (solid shape): outline of 147 points within 141.44,32.53 148.49,43.24
Net_26368 on BOTTOM_-MB (solid shape): 141.44,43.12 141.44,42.35 141.31,42.22 141.31,38.16 141.27,38.16 141.27,37.14 141.31,37.14 141.31,36.89 141.27,36.89 141.27,35.87 141.31,35.87 141.31,35.62 141.27,35.62 141.27,34.6 141.31,34.6 141.31,34.35 141.27,34.35 141.27,33.33 141.34,33.33 141.34,33.16 141.31,33.1 141.3,33.02 141.2,32.92 138.45,32.92 138.13,33.24 138.13,38.46 137.95,38.64 137.6,38.64 137.51,38.73 137.1,38.73 136.82,39.01 136.82,43.01 137.48,43.67 140.88,43.67
Net_26369 on BOTTOM_-MB (solid shape): 116.39,34.52 116.78,34.16 117.3,34.01 117.32,34.01 117.46,33.86 117.46,33.25 117.15,32.94 114.42,32.94 114.16,33.19 114.16,33.91 114.78,34.52
Net_26370 on BOTTOM_-MB (solid shape): 179.21,37.7 179.17,37.65 179.08,37.65 179.08,37.57 179.06,37.55 179.06,36.68 179.08,36.66 179.08,36.49 179.25,36.49 179.54,36.2 179.54,34.81 179.53,34.81 179.53,33.89 179.54,33.89 179.54,33.23 179.39,33.08 177.3,33.08 177.18,33.2 177.18,33.58 177.41,33.81 178.65,33.81 178.7,33.86 178.7,34.93 178.69,34.95 178.69,35.06 178.57,35.06 178.35,35.29 178.35,36.33 178.51,36.49 178.69,36.49 178.69,37.65 178.65,37.65 178.65,37.7 178.55,37.8 178.55,38.05 178.66,38.17 179.21,38.17
Net_26371 on BOTTOM_-MB (solid shape): outline of 243 points within 115.33,33.18 123.73,46.47
Net_26372 on BOTTOM_-MB (solid shape): 136.04,38.44 136.06,38.41 136.11,38.38 136.17,38.35 136.22,38.32 136.28,38.31 136.34,38.3 136.41,38.3 136.47,38.31 136.53,38.32 136.58,38.35 136.64,38.38 136.69,38.41 136.71,38.44 137.66,38.44 137.71,38.38 137.71,33.36 137.55,33.2 136.74,33.2 136.54,33.41 136.53,33.41 136.53,34.35 135.38,34.35 135.38,33.63 134.66,33.63 134.46,33.82 134.46,34.11 134.36,34.2 134.36,34.25 134.31,34.25 134.16,34.4 133.23,34.4 131.6,36.04 131.32,36.04 131.32,36.03 130.92,36.03 130.12,36.83 130.12,37.32 130.82,37.32 130.82,37.57 130.57,37.57 130.57,37.32 130.12,37.32 130.12,37.81 130.23,37.92 130.66,37.92 130.7,37.88 130.79,37.88 131.08,37.6 134.23,37.6 135.06,38.44
Net_26373 on BOTTOM_-MB (solid shape): 186.73,37.62 186.73,33.46 186.6,33.33 186.19,33.33 186.09,33.43 186.09,34.09 185.92,34.27 185.51,34.27 185.42,34.36 185.42,37.49 185.69,37.75 186.6,37.75
Net_26374 on BOTTOM_-MB (solid shape): outline of 367 points within 129.26,33.34 163.67,48.32
Net_26375 on BOTTOM_-MB (solid shape): 185.12,37.45 185.12,34.22 185.15,34.22 185.15,34.07 185.15,33.58 184.95,33.38 184.62,33.38 184.52,33.48 184.52,34.25 184.39,34.37 184.39,34.4 184.37,34.42 184.37,34.46 184.33,34.46 184.26,34.52 184.24,34.52 184.19,34.57 180.35,34.57 180.22,34.71 180.04,34.71 179.72,35.03 179.72,36.28 179.84,36.4 184.16,36.4 184.52,36.76 184.52,37.37 184.67,37.52 185.05,37.52
Net_26376 on BOTTOM_-MB (solid shape): 178.57,34.88 178.57,33.96 178.55,33.94 177.35,33.94 177.33,33.91 177.26,33.91 176.71,33.36 175.69,33.36 175.55,33.5 176.12,33.5 176.12,33.76 175.87,33.76 175.87,33.5 175.55,33.5 175.46,33.59 175.46,33.87 175.35,33.98 175.35,34.27 175.87,34.27 175.87,34.01 176.12,34.01 176.12,34.27 176.12,34.28 176.12,34.53 175.87,34.53 175.87,34.28 175.87,34.27 175.35,34.27 175.35,34.37 175.36,34.38 175.36,34.78 175.52,34.95 175.93,34.95 176.32,34.55 176.47,34.55 176.51,34.53 176.56,34.52 176.62,34.52 176.68,34.52 176.73,34.53 176.77,34.55 177.66,34.55 177.73,34.62 177.74,34.62 177.91,34.8 177.91,34.8 178.07,34.96 178.5,34.96
Net_26377 on BOTTOM_-MB (solid shape): outline of 108 points within 16.93,33.66 21.78,38.77
Net_26378 on BOTTOM_-MB (solid shape): 10.15,36.42 10.15,36.19 10.3,36.04 10.3,35.67 10.29,35.66 10.17,35.66 10.16,35.67 10.03,35.7 9.9,35.69 9.89,35.69 9.73,35.71 8.77,35.71 8.69,35.7 8.61,35.67 8.6,35.66 8.5,35.66 8.42,35.74 8.42,35.97 8.47,36 8.63,36 8.79,35.97 8.96,35.98 9.03,35.96 9.07,35.91 9.24,36 9.37,36.12 9.37,36.32 9.4,36.42 9.41,36.52 9.42,36.55 9.52,36.55 9.51,36.6 9.51,36.65 9.92,36.65
Net_26379 on BOTTOM_-MB (solid shape): 41.22,39.17 42.13,39.17 42.39,38.9 42.4,38.89 42.44,38.8 42.51,38.73 42.51,36.63 42.38,36.5 40.73,36.5 40.47,36.76 40.47,37.89 39.86,38.51 39.86,38.96 39.83,38.96 39.83,39.14 40.03,39.33 41.05,39.33
Net_26380 on BOTTOM_-MB (solid shape): 181.98,40.49 182.81,40.49 183.44,39.85 183.44,39.37 183.1,39.03 183.1,38.28 182.98,38.16 181.24,38.16 181.14,38.05 181.06,38.05 179.59,36.58 179.34,36.58 179.18,36.74 179.18,37.49 179.34,37.65 179.34,38.23 179.24,38.33 179.2,38.33 179.13,38.4 178.46,38.4 178.35,38.51 178.35,38.55 182.67,38.55 182.67,38.81 182.42,38.81 182.42,38.55 178.35,38.55 178.35,40.21 178.63,40.49 181.98,40.49
Net_26381 on BOTTOM_-MB (solid shape): 178.42,37.75 178.42,37.75 178.52,37.65 178.52,36.68 178.47,36.63 178.12,36.63 177.81,36.94 176.95,36.94 176.95,36.98 176.59,37.32 176.24,36.98 176.24,36.94 176.11,36.94 175.96,36.78 175.27,36.78 175.02,37.04 175.02,37.88 175.09,37.95 175.42,37.95 175.55,38.08 178.09,38.08
Net_26382 on BOTTOM_-MB (solid shape): 183.22,37.93 183.2,37.87 183.18,37.83 183.18,37.8 183.18,37.09 183.2,37.01 182.77,36.58 179.97,36.58 179.97,36.71 180.12,36.86 182.12,36.86 182.12,37.11 181.86,37.11 181.86,36.86 180.12,36.86 181.29,38.03 183.12,38.03
Net_26383 on BOTTOM_-MB (solid shape): outline of 139 points within 33.46,36.5 39.84,40.85
Net_26384 on BOTTOM_-MB (solid shape): 185.48,38.6 185.48,37.8 185.37,37.7 184.62,37.7 184.42,37.5 184.42,37.45 184.39,37.42 184.39,37.18 184.26,37.06 183.7,37.06 183.46,37.3 183.46,38.02 183.45,38.04 183.63,38.04 183.97,37.77 184.23,37.77 184.23,38.03 183.89,38.3 183.63,38.3 183.63,38.04 183.45,38.04 183.23,38.26 183.23,38.55 183.89,38.55 183.89,38.81 183.63,38.81 183.63,38.55 183.23,38.55 183.23,38.94 183.55,39.27 184.81,39.27
Net_26385 on BOTTOM_-MB (solid shape): 29.67,38.81 29.67,37.33 29.5,37.16 28.32,37.16 28.13,37.35 28.13,38.35 28.47,38.69 29.09,38.69 29.37,38.97 29.51,38.97
Net_26386 on BOTTOM_-MB (solid shape): 32.73,39.22 32.73,38.61 32.78,38.56 33.24,38.56 33.25,38.57 33.31,38.64 33.31,39.22 33.34,39.25 33.49,39.25 33.52,39.22 33.52,38.66 33.49,38.64 33.49,38.55 33.46,38.52 33.42,38.46 33.4,38.4 33.39,38.36 32.85,37.83 32.85,37.39 32.73,37.27 30.06,37.27 29.98,37.35 29.98,37.99 30.84,37.99 30.84,38.25 30.59,38.25 30.59,37.99 29.98,37.99 29.98,38.71 30.06,38.79 31.19,38.79 31.21,38.77 31.26,38.74 31.31,38.72 31.35,38.7 31.37,38.68 31.39,38.66 31.4,38.63 31.4,38.6 31.39,38.55 31.38,38.5 31.38,38.44 31.39,38.39 31.41,38.34 31.43,38.29 31.46,38.24 31.5,38.2 31.54,38.16 31.59,38.13 31.64,38.11 31.69,38.1 31.75,38.09 31.8,38.09 31.86,38.1 31.91,38.12 31.96,38.15 32.01,38.18 32.05,38.22 32.08,38.26 32.09,38.28 32.35,38.28 32.52,38.46 32.52,39.22 32.55,39.25 32.7,39.25
Net_26387 on BOTTOM_-MB (solid shape): 188.07,39.03 188.43,38.77 188.79,39.03 188.8,39.07 188.88,39.07 188.9,39.04 189.23,38.87 189.55,39.07 190.03,39.07 190.53,38.56 190.87,38.56 191.12,38.31 191.12,37.8 190.92,37.6 189.5,37.6 189.42,37.52 186.87,37.52 186.86,37.57 186.86,37.68 186.75,37.78 186.75,38.59 187.23,39.07 188.06,39.07
Net_26388 on BOTTOM_-MB (solid shape): outline of 120 points within 40.86,37.77 48.35,44.51
Net_26389 on BOTTOM_-MB (solid shape): outline of 116 points within 127.14,38.01 135.21,50.4
Net_26390 on BOTTOM_-MB (solid shape): outline of 237 points within 0.51,39.9 10.24,51.16
Net_26391 on BOTTOM_-MB (solid shape): 39.2,44.12 39.2,40.82 38.95,40.57 36.41,40.57 35.9,41.08 35.12,41.08 35.06,41.03 35.06,40.85 35.04,40.82 33.52,40.82 33.46,40.87 32.19,40.87 32.17,40.9 32.17,42.4 32.19,42.42 35.88,42.42 36.21,42.75 36.21,44.05 36.22,44.06 36.22,44.19 36.41,44.38 38.95,44.38
Net_26392 on BOTTOM_-MB (solid shape): outline of 103 points within 175.02,41.03 183.63,45.56
Net_26393 on BOTTOM_-MB (solid shape): 48.48,45.52 48.48,41.58 48.22,41.33 47.71,41.33 47.59,41.46 47.59,45.52 47.84,45.78 48.22,45.78
Net_26394 on BOTTOM_-MB (solid shape): 69.3,43.54 69.3,43.18 67.9,41.77 66.5,41.77 66.41,41.84 66.31,41.89 66.31,42 66.43,42.12 66.77,42.12 66.8,42.15 66.84,42.15 67.7,43 67.7,43.41 67.78,43.49 67.97,43.49 68.03,43.55 68.05,43.55 68.19,43.69 68.86,43.69 68.87,43.7 69.15,43.7
Net_26395 on BOTTOM_-MB (solid shape): outline of 150 points within 32.12,42.65 38.54,50.14
Net_26396 on BOTTOM_-MB (solid shape): outline of 441 points within 68.66,43.11 84.84,53.3
Net_26397 on BOTTOM_-MB (solid shape): 32.07,49.13 32.07,47.17 31.92,47.02 30.74,47.02 30.67,46.94 30.57,46.94 30.14,46.51 30.14,45.93 30.12,45.91 30.1,45.86 30.08,45.81 30.07,45.76 30.07,45.71 30.08,45.65 30.09,45.6 30.12,45.56 30.14,45.52 30.14,45.37 30.13,45.37 30.13,45.08 29.81,44.75 29.42,44.75 29.39,44.76 29.34,44.78 29.29,44.79 29.23,44.79 29.18,44.78 29.13,44.76 29.1,44.75 28.29,44.75 28.21,44.83 28.21,44.84 28.21,45.47 28.69,45.47 28.69,45.22 28.94,45.22 28.94,45.47 28.97,45.5 28.97,45.75 28.71,45.75 28.71,45.5 28.69,45.47 28.21,45.47 28.21,45.99 28.42,46.19 28.46,46.2 28.52,46.22 28.58,46.26 28.63,46.3 28.68,46.34 28.72,46.4 28.75,46.45 28.78,46.52 28.79,46.56 29.55,47.33 29.55,47.85 31.33,47.85 31.33,48.42 31.08,48.42 31.08,47.85 29.55,47.85 29.55,48.18 29.57,48.2 29.59,48.25 29.6,48.31 29.6,48.37 29.6,48.42 29.59,48.48 29.57,48.53 29.55,48.56 29.55,49.08 31.33,49.08 31.33,49.33 31.08,49.33 31.08,49.08 29.55,49.08 29.55,49.36 29.68,49.48 31.71,49.48
Net_26398 on BOTTOM_-MB (solid shape): outline of 5769 points within 175.22,45.17 192.29,86.34
Net_26399 on BOTTOM_-MB (solid shape): outline of 135 points within 19.52,45.06 21.6,55.22
Net_26400 on BOTTOM_-MB (solid shape): 26.2,48.7 26.2,48.33 26.19,48.33 26.19,46.77 26.4,46.77 26.4,46.77 26.96,46.77 27.09,46.64 27.09,45.32 27.06,45.29 26.4,45.29 25.97,45.73 26.61,45.73 26.61,45.98 26.35,45.98 26.35,45.73 25.97,45.73 25.35,46.35 25.35,47.83 25.26,47.83 25.26,47.83 24.45,47.83 24.37,47.91 24.37,48.14 24.07,48.44 23.05,48.44 23.03,48.46 22.99,48.5 22.95,48.54 22.9,48.56 22.85,48.58 22.79,48.59 22.74,48.6 22.62,48.72 22.62,49.03 22.76,49.17 22.81,49.16 22.87,49.16 22.92,49.16 22.97,49.17 23.02,49.19 23.05,49.2 23.13,49.2 23.43,49.51 25.39,49.51
Net_26401 on BOTTOM_-MB (solid shape): 32.55,46.49 32.55,46.14 31.69,45.28 30.82,45.28 30.65,45.44 30.69,45.48 30.78,45.75 30.65,46 30.65,46.75 30.8,46.89 32.15,46.89
Net_26402 on BOTTOM_-MB (solid shape): outline of 1665 points within 49.87,46.16 79.03,65.1
Net_26403 on BOTTOM_-MB (solid shape): 45.07,52.35 46.22,52.35 47.21,51.36 47.21,46.51 47.07,46.37 44.45,46.37 43.78,47.05 43.78,47.07 43.75,47.07 43.5,47.33 42.8,47.33 42.09,48.05 42.09,48.05 41.9,48.24 41.9,48.95 41.92,48.98 43.17,48.98 43.4,49.2 43.4,52.89 43.52,53.01 44.41,53.01
Net_26404 on BOTTOM_-MB (solid shape): 24.19,48.01 24.19,47.2 23.53,46.54 22.86,46.54 22.86,46.54 21.88,46.54 21.88,47.11 23.41,47.11 23.41,47.36 23.15,47.36 23.15,47.11 21.88,47.11 21.88,47.38 22.43,47.92 22.45,47.94 22.47,47.94 22.52,47.91 22.57,47.88 22.62,47.85 22.67,47.84 22.73,47.83 22.79,47.83 22.84,47.84 22.89,47.86 22.94,47.89 22.99,47.92 23.03,47.96 23.07,48 23.09,48.05 23.12,48.11 24.09,48.11
Net_26405 on BOTTOM_-MB (solid shape): outline of 86 points within 68.08,46.57 71.25,51.8
Net_26406 on BOTTOM_-MB (solid shape): 28.94,49.28 28.94,48.63 28.84,48.37 28.94,48.11 28.94,47.17 28.82,47.05 28.61,47.05 28.6,47.06 28.31,47.14 28.02,47.05 27.76,47.05 27.72,47.07 27.45,47.35 26.34,47.35 26.33,47.36 26.33,47.75 26.35,47.77 27.15,47.77 27.15,47.78 27.32,47.78 27.45,47.9 27.45,49.11 27.72,49.38 28.84,49.38
Net_26407 on BOTTOM_-MB (solid shape): 123.59,52.99 124.11,52.99 124.43,52.66 124.43,50.09 124.52,50.01 124.52,49.29 124.07,48.84 124.04,48.82 124,48.79 123.97,48.75 123.93,48.7 123.92,48.65 123.91,48.6 123.91,48.55 123.92,48.5 123.93,48.47 123.93,47.88 123.74,47.69 123.66,47.69 123.65,47.7 123.12,47.7 122.82,47.99 122.82,48.16 122.81,48.2 122.79,48.24 122.77,48.27 122.76,48.28 122.76,48.41 123.31,48.41 123.38,48.33 123.38,48.08 123.63,48.08 123.63,48.33 123.56,48.41 123.56,48.67 123.31,48.67 123.31,48.41 122.76,48.41 122.76,49.2 123.15,49.2 123.31,48.92 123.56,48.92 123.56,49.17 123.4,49.45 123.15,49.45 123.15,49.2 122.76,49.2 122.76,49.7 123.4,49.7 123.4,50.24 123.15,50.24 123.15,49.7 122.76,49.7 122.76,50.49 123.4,50.49 123.4,51.02 123.15,51.02 123.15,50.49 122.76,50.49 122.76,51.28 123.4,51.28 123.4,51.81 123.15,51.81 123.15,51.28 122.76,51.28 122.76,52.07 123.4,52.07 123.4,52.6 123.15,52.6 123.15,52.07 122.76,52.07 122.76,53.03 122.84,53.12 123.46,53.12
Net_26408 on BOTTOM_-MB (solid shape): outline of 140 points within 118.2,47.83 121.09,54.62
Net_26409 on BOTTOM_-MB (solid shape): outline of 86 points within 39.54,48.32 47.08,57.46
Net_26410 on BOTTOM_-MB (solid shape): 97.19,51.28 97.19,51.05 97.08,50.8 97.19,50.55 97.19,50.18 97.18,50.18 97.16,50.07 97.18,49.96 97.19,49.95 97.19,49.27 97.16,49.14 97.18,49.03 97.19,49.02 97.19,48.74 97.06,48.61 96.78,48.61 96.77,48.64 96.53,48.77 96.29,48.64 96.28,48.61 96.05,48.61 95.92,48.74 95.92,50.61 95.97,50.8 95.92,50.99 95.92,51.28 96.04,51.41 97.06,51.41
Net_26411 on BOTTOM_-MB (solid shape): outline of 299 points within 86.82,48.79 95.79,51.54
Net_26412 on BOTTOM_-MB (solid shape): 86.93,51.26 86.93,50.9 86.73,50.71 86.73,50.7 86.7,50.65 86.68,50.53 86.7,50.44 86.7,49.7 86.68,49.6 86.7,49.51 86.7,49.09 86.65,49.03 86.62,48.96 86.61,48.92 86.4,48.92 86.39,48.96 86.05,49.21 85.71,48.96 85.7,48.92 85.58,48.92 85,49.5 85,50.62 85.04,50.8 85,50.96 85,50.97 85,51.23 85.3,51.54 86.65,51.54
Net_26414 on BOTTOM_-MB (solid shape): 98.51,51.53 98.62,51.52 98.74,51.53 98.74,51.54 99.22,51.54 99.47,51.28 99.47,50.01 99.35,49.88 98.97,49.88 98.94,49.86 98.91,49.87 98.83,49.88 98.75,49.88 98.65,49.9 98.62,50 98.62,50.14 98.56,50.26 98.56,50.57 98.28,51.19 98.15,50.52 98.15,50.26 98.11,49.93 98.42,49.79 98.51,49.77 98.54,49.67 98.53,49.59 98.55,49.51 98.56,49.48 98.47,49.39 98.44,49.41 98.24,49.4 98.1,49.25 98.05,49.2 97.74,49.17 97.57,49 97.44,49 97.31,49.12 97.31,51.11 97.33,51.17 97.39,51.24 97.49,51.23 97.87,51.19 98.09,51.49 98.1,51.54 98.5,51.54
Net_26415 on BOTTOM_-MB (solid shape): outline of 213 points within 22.82,50.37 28.56,53.12
Net_26416 on BOTTOM_-MB (solid shape): 38.82,56.7 40.86,56.7 41.11,56.44 41.11,54.28 40.65,53.83 40.65,51.21 40.6,51.16 39.59,51.16 39.54,51.21 39.54,52.53 39.38,52.68 38.54,52.68 38.04,53.19 35.34,53.19 34.63,53.9 34.63,54.08 40.44,54.08 40.44,54.34 40.18,54.34 40.18,54.08 34.63,54.08 34.63,55 40.44,55 40.44,55.61 40.18,55.61 40.18,55 34.63,55 34.63,55.58 40.05,55.58 40.05,55.84 39.79,55.84 39.79,55.58 38.7,55.58 38.7,55.84 38.45,55.84 38.45,55.58 34.63,55.58 34.63,55.84 34.88,56.08 38.41,56.08 38.41,56.27 40.44,56.27 40.44,56.52 40.18,56.52 40.18,56.27 38.41,56.27 38.41,56.34 38.15,56.34 38.15,56.08 37.06,56.08 37.06,56.34 36.81,56.34 36.81,56.08 34.88,56.08 35.11,56.32 36.03,56.32 36.51,56.8 36.68,56.8 36.68,56.97 36.92,57.21 38.32,57.21
Net_26417 on BOTTOM_-MB (solid shape): outline of 2906 points within 144.09,51.44 162.98,70.11
Net_26418 on BOTTOM_-MB (solid shape): outline of 159 points within 141.06,51.32 150.29,62.32
Net_26420 on BOTTOM_-MB (solid shape): 106.59,52.68 106.59,52.14 106.58,52.13 106.54,51.96 106.58,51.8 106.59,51.79 106.59,51.66 106.46,51.54 105.09,51.54 105.04,51.58 104.97,51.63 104.74,51.85 104.74,51.86 104.69,51.93 104.63,51.99 104.6,52 104.6,52.33 104.63,52.34 104.7,52.4 104.75,52.49 104.75,52.5 105.06,52.81 106.46,52.81
Net_26421 on BOTTOM_-MB (solid shape): outline of 768 points within 99.41,51.92 105.87,58.65
Net_26424 on BOTTOM_-MB (solid shape): 178.38,58.25 178.38,58.23 178.45,57.95 178.71,57.83 178.74,57.81 178.76,57.78 178.76,57.75 178.75,57.71 178.71,57.69 178.37,57.4 178.62,57.04 178.63,57.04 178.71,56.96 178.6,56.85 178.59,56.85 178.4,56.53 178.65,56.26 178.72,56.22 178.74,56.16 178.85,55.91 179.1,55.8 179.16,55.78 179.2,55.71 179.5,55.45 179.8,55.72 179.84,55.79 179.9,55.81 180.08,55.86 180.21,55.99 180.3,56.05 180.39,55.99 180.52,55.85 180.7,55.8 180.76,55.78 180.8,55.71 180.82,55.64 180.76,55.59 180.74,55.59 180.43,55.42 180.41,55.07 180.41,54.97 180.32,54.92 178.31,54.92 178.23,54.96 178.21,55.06 178.22,55.25 178.13,55.43 178.13,55.56 178.19,55.87 177.94,56.06 177.88,56.1 177.86,56.16 177.85,56.2 177.87,56.24 177.9,56.25 178.2,56.54 177.94,56.86 177.88,56.89 177.86,56.96 177.75,57.21 177.49,57.3 177.47,57.3 177.43,57.34 177.43,57.41 177.42,57.46 177.43,57.55 177.51,57.59 177.55,57.59 177.81,57.84 177.83,57.84 178.15,57.95 178.21,58.28 178.2,58.29 178.2,58.35 178.28,58.35
Net_26425 on BOTTOM_-MB (solid shape): outline of 242 points within 175.22,55.62 184.44,63.98
Net_26426 on BOTTOM_-MB (solid shape): 118.27,57.22 118.27,56.74 118.22,56.69 117.76,56.69 117.56,56.49 117.56,56.35 117.56,56.08 117.43,55.95 116.34,55.95 116.29,56 116.29,56.43 117.05,56.43 117.05,56.64 116.29,56.64 116.29,57.09 116.32,57.12 116.92,57.12 117.1,57.3 118.19,57.3
Net_26427 on BOTTOM_-MB (solid shape): 19.73,58.5 20,58.38 20.28,58.5 21.61,58.5 21.74,58.37 21.74,57.59 20.68,56.53 19.49,56.53 19.35,56.63 19.19,56.66 19.16,56.66 18.35,57.47 18.35,58.31 18.54,58.5
Net_26428 on BOTTOM_-MB (solid shape): outline of 148 points within 101.64,57.02 108.18,62.01
Net_26429 on BOTTOM_-MB (solid shape): outline of 115 points within 31.99,56.95 34.47,62.62
Net_26430 on BOTTOM_-MB (solid shape): 104.05,58.52 104.05,57.54 104.01,57.52 103.92,57.46 103.85,57.38 102.54,57.38 102.48,57.47 102.39,57.54 102.39,58.52 102.49,58.61 103.95,58.61
Net_26431 on BOTTOM_-MB (solid shape): 37.07,60.43 37.25,60.25 37.27,60.23 37.31,60.19 37.37,60.17 37.42,60.15 37.48,60.14 37.53,60.14 37.59,60.14 37.65,60.16 37.7,60.18 37.75,60.21 37.79,60.25 37.83,60.3 37.85,60.33 37.87,60.35 37.9,60.37 37.93,60.37 37.96,60.36 37.99,60.35 38.05,60.3 38.01,60.24 37.98,60.18 37.97,60.13 37.96,60.07 37.96,60.01 37.97,59.95 37.99,59.9 38.02,59.85 38.04,59.82 38.04,59.26 38.11,59.19 38.11,59.14 38.11,59.09 38.13,59.03 38.15,58.98 38.17,58.94 38.2,58.89 38.24,58.86 38.28,58.83 38.33,58.8 38.38,58.78 38.43,58.77 38.48,58.76 38.53,58.77 38.8,58.5 39.79,58.5 39.94,58.35 39.94,58.04 40.09,57.89 40.16,57.89 40.16,57.81 40.53,57.81 40.53,57.51 40.3,57.28 38.67,57.28 38.34,57.61 36.92,57.61 36.77,57.76 38.41,57.76 38.41,58.02 38.15,58.02 38.15,57.76 36.77,57.76 36.66,57.87 36.66,58.7 37.06,58.7 37.06,58.96 36.81,58.96 36.81,58.7 36.66,58.7 36.68,58.7 36.68,59.64 36.66,59.64 36.66,60.11 36.67,60.18 37,60.51 37.07,60.51
Net_26432 on BOTTOM_-MB (solid shape): outline of 257 points within 95.97,58.23 100.98,62.01
Net_26433 on BOTTOM_-MB (solid shape): 45.86,59.67 45.86,58.43 45.71,58.27 45.1,58.27 44.97,58.4 44.86,58.4 44.85,58.41 44.61,58.45 44.4,58.35 44.21,58.35 44.19,58.35 44.12,58.38 44.05,58.4 44.03,58.4 43.98,58.45 43.98,58.86 44.08,58.96 45.02,58.96 45.3,59.24 45.3,59.62 45.38,59.7 45.83,59.7
Net_26435 on BOTTOM_-MB (solid shape): 24.64,59.79 24.64,59.58 23.97,58.91 23.96,58.91 23.86,58.84 23.79,58.74 23.78,58.71 23.48,58.71 23.43,58.71 23.35,58.71 23.25,58.81 23.25,58.98 23.33,59.06 23.33,59.13 23.46,59.27 23.49,59.27 23.56,59.26 23.72,59.27 23.79,59.34 23.82,59.36 23.86,59.41 23.91,59.41 23.92,59.4 24.05,59.38 24.17,59.44 24.28,59.54 24.34,59.63 24.34,59.73 24.34,59.76 24.39,59.81 24.62,59.81
Net_26436 on BOTTOM_-MB (solid shape): outline of 94 points within 18.12,58.73 24.85,61.39
Net_26437 on BOTTOM_-MB (solid shape): outline of 140 points within 157.42,58.81 165.98,71.07
Net_26438 on BOTTOM_-MB (solid shape): 119.33,61.06 119.33,59.17 119.13,58.97 118.11,58.97 117.96,59.13 117.96,59.38 118.58,59.38 118.58,59.91 118.32,59.91 118.32,59.38 117.96,59.38 117.96,60.25 118.15,60.44 118.46,60.44 118.5,60.46 118.54,60.48 118.57,60.5 118.6,60.54 118.62,60.57 118.63,60.61 118.65,60.64 118.65,61 118.82,61.16 119.22,61.16
Net_26439 on BOTTOM_-MB (solid shape): outline of 86 points within 95.56,59.03 98.58,61.41
Net_26440 on BOTTOM_-MB (solid shape): outline of 672 points within 78.89,59.16 94.01,62.97
Net_26441 on BOTTOM_-MB (solid shape): 54.32,61.32 54.32,60.81 54.51,60.62 55.43,60.62 55.51,60.53 55.51,60 55.33,59.81 54.31,59.81 54.22,59.72 54.22,59.24 54.09,59.11 53.07,59.11 52.92,59.26 52.92,59.43 53.83,59.43 53.83,59.68 53.57,59.68 53.57,59.43 52.92,59.43 52.92,59.6 52.87,59.65 52.87,59.7 52.97,59.8 53.51,59.8 53.76,60.05 53.76,60.71 53.66,60.81 52.26,60.81 52.18,60.89 52.18,61.37 52.24,61.42 54.22,61.42
Net_26442 on BOTTOM_-MB (solid shape): 93.92,61.03 94.04,60.9 94.21,60.84 94.23,60.84 94.39,60.68 94.57,60.68 94.77,60.6 94.97,60.68 95.28,60.68 95.41,60.55 95.41,60.17 94.95,60.17 94.69,60.23 94.5,60.03 94.49,60.02 93.99,59.52 93.92,59.46 93.87,59.4 93.63,59.16 92.41,59.16 92.32,59.2 92.32,59.3 92.34,59.5 92.25,59.69 92.25,59.83 92.28,59.94 92.27,60.03 92.3,60.12 92.66,60.22 92.76,60.58 92.86,60.61 93,60.61 93.12,60.68 93.25,60.68 93.4,60.83 93.42,60.83 93.62,60.88 93.76,61.03 93.77,61.06 93.91,61.06
Net_26443 on BOTTOM_-MB (solid shape): 51.9,62.03 51.9,60.15 51.78,60.03 51.37,60.03 51.29,60.1 51.29,60.29 51.24,60.33 51.24,62.01 51.4,62.16 51.78,62.16
Net_26445 on BOTTOM_-MB (solid shape): 25.77,63.13 25.77,63.11 25.97,62.86 26.29,62.93 26.3,62.94 26.35,62.94 26.36,62.93 26.58,62.84 26.79,62.93 26.8,62.94 26.85,62.94 26.86,62.93 27.02,62.84 27.2,62.87 27.24,62.88 27.31,62.8 27.3,62.77 27.27,62.62 27.32,62.47 27.32,62.32 27.27,62.14 27.32,61.97 27.32,61.82 27.32,61.48 27.63,61.34 27.65,61.34 27.72,61.32 27.75,61.25 27.85,61.02 28.07,60.93 28.09,60.93 28.1,60.92 28.23,60.92 28.26,60.88 28.26,60.81 28.26,60.8 28.23,60.71 28.22,60.61 28.22,60.59 28.1,60.46 26.78,60.46 26.73,60.51 26.73,60.84 26.74,60.84 26.74,60.89 26.84,61.29 26.44,61.42 26.43,61.41 26.22,61.41 26.21,61.42 25.91,61.4 25.77,61.13 25.77,61.11 25.68,61.01 25.4,61.01 25.24,61.17 25,61.17 24.85,61.32 24.83,61.32 24.82,61.32 24.82,61.46 24.83,61.48 24.87,61.58 24.88,61.68 24.87,61.71 24.92,61.75 24.95,61.74 25.35,61.87 25.31,62.29 25.29,62.31 25.2,62.4 25.17,62.49 25.22,62.56 25.39,62.8 25.3,63.08 25.28,63.15 25.3,63.22 25.33,63.26 25.64,63.26
Net_26446 on BOTTOM_-MB (solid shape): 73.31,64.58 73.31,63.01 73.27,62.71 73.52,62.55 73.54,62.55 73.74,62.35 74.54,62.35 75.2,61.69 76.47,61.69 76.77,61.53 77.07,61.69 78.36,61.69 78.62,61.58 78.87,61.69 79.27,61.69 79.52,61.59 79.76,61.69 80.12,61.69 80.2,61.6 80.2,61.4 79.96,61.16 79.94,61.15 79.87,61.13 79.81,61.09 79.24,61.09 79.06,61.16 78.88,61.09 78.32,61.09 78.14,61.16 77.96,61.09 77.4,61.09 77.22,61.16 77.04,61.09 76.47,61.09 76.29,61.16 76.11,61.09 75.55,61.09 75.37,61.16 75.19,61.09 74.83,61.09 74.68,61.24 74.68,61.37 74.69,61.38 74.73,61.53 74.69,61.67 74.68,61.68 74.68,61.73 74.48,61.93 72.39,61.93 71.97,62.35 71.97,62.8 72.47,63.3 72.49,63.31 72.64,63.42 72.69,63.61 72.68,63.61 72.68,64.59 72.81,64.72 73.17,64.72
Net_26447 on BOTTOM_-MB (solid shape): 35.57,63.98 35.57,63.92 35.63,63.79 35.76,63.73 35.9,63.73 35.98,63.66 35.98,62.14 35.93,62.13 35.6,61.82 35.81,61.41 35.83,61.36 35.79,61.32 35.76,61.31 35.71,61.3 34.79,61.3 34.66,61.42 34.66,62.26 34.35,62.57 34.35,63.07 35.14,63.07 35.14,63.28 34.35,63.28 34.35,63.99 34.4,64.04 34.4,64.09 35.47,64.09
Net_26448 on BOTTOM_-MB (solid shape): outline of 216 points within 180.31,62.63 189.61,68.97
Net_26449 on BOTTOM_-MB (solid shape): 109.87,65.59 109.87,65.43 109.55,65.11 109.55,65 109.53,64.98 109.53,64.93 109.47,64.84 109.45,64.74 109.45,64.65 109.51,64.48 109.67,64.4 109.74,64.34 109.74,64.25 109.8,63.89 110.17,63.9 110.57,63.9 110.85,63.62 110.85,63.6 110.85,63.53 110.87,63.43 110.9,63.41 110.93,63.37 110.97,63.34 111.02,63.29 111.54,63.29 111.71,63.11 111.71,62.95 111.7,62.94 111.65,62.94 111.5,62.79 110.19,62.79 110.18,62.8 110.06,62.83 109.94,62.83 109.92,62.82 109.81,62.93 109.81,62.94 109.75,63.03 109.66,63.09 109.65,63.09 109.4,63.34 109.29,63.34 109.28,63.35 109.16,63.4 109.03,63.41 109,63.4 108.82,63.59 108.82,64.03 108.9,64.11 108.9,65.1 109.02,65.23 109.04,65.23 109.1,65.24 109.16,65.27 109.22,65.27 109.61,65.65 109.8,65.65
Net_26450 on BOTTOM_-MB (solid shape): outline of 108 points within 87.28,63.09 95.92,64.74
Net_26451 on BOTTOM_-MB (solid shape): outline of 81 points within 22.01,63.09 24.32,66.43
Net_26452 on BOTTOM_-MB (solid shape): 70.99,65.8 70.99,63.8 70.89,63.7 70.62,63.7 70.37,63.96 70.37,64.69 70.43,64.9 70.37,65.11 70.37,65.93 70.48,66.05 70.74,66.05
Net_26453 on BOTTOM_-MB (solid shape): 69.2,66.19 69.2,65.91 69.4,65.71 69.52,65.71 69.57,65.66 69.57,65.39 69.53,65.35 68.84,65.35 68.03,64.54 68.03,63.85 67.98,63.8 66.33,63.8 66.23,63.9 66.23,65.55 66.92,66.24 69.14,66.24
Net_26454 on BOTTOM_-MB (solid shape): 26.63,65.02 26.63,64.5 26.61,64.46 26.58,64.45 26.41,64.4 26.29,64.26 26.29,64.25 26.27,64.23 26.27,64.1 26.14,63.98 25.94,63.98 25.93,63.98 25.79,64.01 25.65,63.98 25.64,63.98 25.51,63.98 25.38,64.1 25.38,64.21 25.51,64.34 25.51,65.21 25.81,65.5 26.14,65.5
Net_26455 on BOTTOM_-MB (solid shape): outline of 377 points within 148.96,63.73 160.08,84.03
Net_26456 on BOTTOM_-MB (solid shape): 112.33,66.39 112.33,66.19 112.69,65.83 112.69,65.1 112.52,64.92 112.16,64.92 112.03,64.79 110.86,64.79 110.84,64.81 110.84,65.01 110.93,65.1 110.96,65.1 111.11,65.25 111.11,65.28 111.23,65.4 111.23,65.76 111.24,65.77 111.24,65.88 111.87,66.51 112.21,66.51
Net_26457 on BOTTOM_-MB (solid shape): outline of 538 points within 2.16,67.04 152.75,89.49
Net_26458 on BOTTOM_-MB (solid shape): outline of 1516 points within 147.98,68.08 156.59,75.22
Net_26459 on BOTTOM_-MB (solid shape): 113,69.43 113,68.73 112.46,68.19 111.94,68.19 111.84,68.28 111.84,68.51 112.41,69.08 112.41,69.47 112.43,69.49 112.94,69.49
Net_26460 on BOTTOM_-MB (solid shape): 46.34,69.37 46.34,68.46 46.11,68.23 45.76,68.23 45.58,68.41 45.57,68.45 45.56,68.51 45.54,68.56 45.51,68.61 45.47,68.65 45.43,68.69 45.38,68.72 45.33,68.74 45.28,68.76 45.22,68.76 45.17,68.76 45.11,68.75 45.06,68.74 45,68.71 44.95,68.76 44.95,68.79 45.94,68.79 45.94,69.04 45.68,69.04 45.68,68.79 44.95,68.79 44.95,69.22 45.15,69.42 46.29,69.42
Net_26461 on BOTTOM_-MB (solid shape): 112.27,69.87 112.28,69.85 112.28,69.6 112.26,69.55 112.26,69.51 112.26,69.11 111.78,68.63 111.07,68.63 110.89,68.81 110.89,69.26 111.7,69.26 111.7,69.47 110.89,69.47 110.89,69.93 111.03,70.06 112.07,70.06
Net_26462 on BOTTOM_-MB (solid shape): outline of 94 points within 36.41,68.78 40.45,77.65
Net_26463 on BOTTOM_-MB (solid shape): 112.9,70.87 112.9,69.78 112.84,69.71 112.48,69.71 112.41,69.78 112.41,69.91 112.27,70.05 112.27,70.64 111.78,71.13 111.78,71.16 111.8,71.28 111.8,71.38 111.79,71.41 111.93,71.54 112.23,71.54
Net_26464 on BOTTOM_-MB (solid shape): outline of 146 points within 39.97,69.78 46.7,73.65
Net_26465 on BOTTOM_-MB (solid shape): 28.22,75.05 29.46,75.05 29.95,74.57 29.95,71.06 29.5,70.6 29.49,70.6 29.27,70.37 29.09,70.37 28.92,70.2 27.86,70.2 27.68,70.37 27.68,70.76 29.43,70.76 29.43,71.01 29.17,71.01 29.17,70.76 28.92,70.76 28.92,71.01 28.67,71.01 28.67,70.76 27.68,70.76 27.68,70.97 27.67,70.97 27.67,71.17 26.9,71.93 26.9,72.18 26.91,72.37 26.92,72.41 26.94,72.47 26.94,72.53 26.94,72.59 26.94,72.65 26.92,72.72 26.9,72.77 26.86,72.83 26.83,72.88 26.78,72.92 26.73,72.96 26.68,72.99 26.64,73.01 26.39,73.25 26.39,74.78 26.67,75.06 28.22,75.06
Net_26466 on BOTTOM_-MB (solid shape): 65.33,73.65 65.33,72.78 64.87,72.32 63.8,72.32 63.56,72.08 60.75,72.08 60.16,72.66 59.93,72.66 59.75,72.7 59.59,72.67 59.58,72.66 59.47,72.66 58.41,71.6 52.7,71.6 51.54,70.43 50.52,70.43 50.45,70.5 50.45,70.82 52,72.37 57.51,72.37 58.36,73.22 61.06,73.22 61.67,72.6 63.86,72.6 64.97,73.71 65.26,73.71
Net_26467 on BOTTOM_-MB (solid shape): outline of 1251 points within 170.81,71.35 180.14,77.28
Net_26468 on BOTTOM_-MB (solid shape): 181.19,76.16 181.26,76.13 181.29,76.06 181.37,75.87 181.56,75.77 181.57,75.77 181.64,75.7 181.64,75.68 181.62,75.61 181.55,75.57 181.38,75.48 181.3,75.31 181.26,75.25 181.2,75.22 180.95,75.12 180.84,74.87 180.82,74.81 180.76,74.77 180.5,74.44 180.82,74.17 180.84,74.17 180.94,74.07 180.94,71.68 180.88,71.59 180.77,71.61 179.98,72.39 179.95,72.5 180.04,72.57 180.2,72.64 180.3,72.8 180.3,72.81 180.4,72.91 180.42,72.91 180.72,73.28 180.39,73.62 180.37,73.62 180.31,73.68 180.3,73.7 180.22,73.88 180.04,73.97 179.98,74.01 179.95,74.07 179.9,74.25 179.76,74.37 179.71,74.46 179.76,74.55 179.9,74.68 179.95,74.87 179.98,74.93 180.04,74.97 180.24,75.08 180.3,75.29 180.3,75.31 180.51,75.52 180.51,75.71 180.56,75.8 180.66,75.8 180.96,75.81 181.1,76.09 181.1,76.11 181.15,76.16
Net_26470 on BOTTOM_-MB (solid shape): outline of 98 points within 50.08,71.76 53.12,75.85
Net_26471 on BOTTOM_-MB (solid shape): outline of 226 points within 71.49,72.29 88.52,79.77
Net_26472 on BOTTOM_-MB (solid shape): outline of 156 points within 157.31,72.4 161.89,87.97
Net_26473 on BOTTOM_-MB (solid shape): 37.81,75.62 37.81,74.86 36.86,73.92 36.3,73.92 36.3,73.86 36.03,73.59 36.03,73.08 35.78,72.83 35.22,72.83 35.16,72.89 32.99,72.89 32.98,72.9 32.64,72.9 32.48,73.06 32.48,73.34 32.6,73.46 32.6,74.99 32.98,75.37 36.03,75.37 36.41,75.75 37.68,75.75
Net_26474 on BOTTOM_-MB (solid shape): 131.74,74.65 131.75,74.61 131.76,74.58 131.78,74.55 131.81,74.52 131.84,74.5 131.87,74.49 131.91,74.48 131.93,74.48 132.31,74.48 132.33,74.48 132.36,74.49 132.4,74.5 132.43,74.52 132.46,74.55 132.48,74.58 132.49,74.61 132.5,74.65 132.5,74.72 133.42,74.72 133.66,74.47 133.66,73.79 133.21,73.33 133.21,72.99 133.01,72.79 132.44,72.79 132.1,73.13 132.84,73.13 132.84,73.38 132.58,73.38 132.58,73.13 132.1,73.13 131.8,73.43 131.13,73.43 130.99,73.58 130.96,73.58 130.85,73.7 130.85,73.72 132.5,73.72 132.5,73.97 132.25,73.97 132.25,73.72 131.99,73.72 131.99,73.97 131.74,73.97 131.74,73.72 130.85,73.72 130.85,74.2 130.7,74.34 131.08,74.72 131.74,74.72
