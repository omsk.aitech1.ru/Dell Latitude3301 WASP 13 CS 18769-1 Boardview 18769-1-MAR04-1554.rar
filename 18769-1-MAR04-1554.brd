# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCCSA_IMON: length 3.2
  TOP w0.203: PC4629.2 44.03,64.7 PR4644.1 43.56,63.99 v2(43.36,63.79) 43.26,63.68 v1(42.62,63.68)
  BOTTOM w0.203: PU4601.23 43.45,63.88 v2(43.36,63.79)
PWR_VCCSA_ISUMN: length 86.2
  TOP w0.203: v2(97.37,78.81) 96.65,79.53 87.78,79.53 87.7,79.61 87.43,79.88 75.2,79.88 71.31,75.99 71.31,74.16 70.7,73.55 70.7,73.53 70.68,73.5 70.68,70.89 67.32,67.54 64.86,67.54 60.67,63.35 55.85,63.35 52.74,66.46 52.74,68 53.91,69.17 53.91,70.11 53.73,70.29 52.82,70.29 v2(51.68,69.14)
  L5 w0.203: v2(51.68,69.14) 50.46,69.14 49.09,67.77 48.78,67.77 48.28,67.26 44.87,67.26 43.44,65.84 v2(42.51,65.84)
  BOTTOM w0.203: v2(97.37,78.81) 97.38,78.81 PR4611.1 ; PC4605.1 PR4620.1 41.85,68.13 PR4615.1 41.33,68.15 PC4603.2 40.93,68.55 v1(40,68.55) 39.14,68.55 PR4613.1 38.85,68.54 37.81,68.54 37.54,68.27 37.54,67.9 37.11,67.46 37.11,66.8 36.44,66.13 36.44,65.55 35.96,65.07 PR5004.1 ; PC4605.1 41.88,66.5 42.51,65.87 v2(42.51,65.84) ; PC4605.1 40.98,66.5 PR4618.2
PWR_VCCSA_ISUMN_P_1: length 0.8
  BOTTOM w0.203: PR4613.2 38.99,66.74 PC4608.2
PWR_VCCSA_ISUMN_P_2: length 77.6
  TOP w0.203: v2(52.29,68.95) 52.29,66.27 55.66,62.9 60.86,62.9 65.05,67.08 67.51,67.08 71.13,70.7 71.13,73.31 71.46,73.64 71.46,73.67 71.77,73.97 71.77,75.8 75.39,79.42 87.24,79.42 87.61,79.05 96.12,79.05 v1(96.66,78.51) 97.17,78 v2(97.4,78)
  L5 w0.203: v2(38.36,65.87) 38.42,65.92 41.47,65.92 45.19,69.65 45.85,69.65 46.24,70.04 52.16,70.04 52.36,69.84 52.36,69.02 v2(52.29,68.95)
  BOTTOM w0.203: v2(38.36,65.87) 38.44,65.79 PR4625.2 ; PR4611.2 97.45,77.95 97.41,78 v2(97.4,78)
PWR_VCCSA_ISUMN_R: length 77.9
  L5 w0.203: v2(52.97,69.01) 52.97,69.01 52.97,69.02 52.82,69.17 52.82,70.44 52.02,71.24 46.07,71.24 45.58,70.75 45.58,70.39 45.3,70.11 45.01,70.11 41.28,66.38 37.53,66.38 37.08,65.93 v2(37.08,65.91)
  L6 w0.203: v2(52.97,69.01) 53.52,69.01 54.93,70.41 63.08,70.41 64.43,71.76 65.39,71.76 74.23,80.6 100.13,80.6 101.85,78.88 v2(101.85,78.31)
  BOTTOM w0.203: v2(101.85,78.31) 101.85,77.97 PG5001.2 ; PR5004.2 37.08,65.16 v2(37.08,65.91) ; v1(52.46,69.48) 52.69,69.48 52.97,69.2 v2(52.97,69.01)
PWR_VCCSA_ISUMN_RC: length 0.8
  BOTTOM w0.203: PR4615.2 PC4611.1
PWR_VCCSA_ISUMNB: length 3.3
  BOTTOM w0.203: PU4601.28 43.46,65.88 43.08,66.26 42.98,66.26 v1(42.74,66.5) 42.74,67.36 PR4620.2 42.73,67.42 42.69,68.08 PC4611.2
PWR_VCCSA_ISUMP: length 6.2
  BOTTOM w0.203: PR5003.1 39.89,67.55 PC4608.1 40.14,66.48 PR4625.1 40.78,65.79 PR4618.1 41.82,65.61 PC4605.2 42.09,65.35 42.38,65.35 42.39,65.36 42.71,65.36 42.82,65.48 PU4601.27
PWR_VCCSA_ISUMP_R: length 74.8
  L5 w0.203: v2(53.3,69.55) 53.3,70.61 52.21,71.7 45.16,71.7 43.6,70.14 43.6,69.36 41.21,66.96 v2(40.42,66.96)
  L6 w0.203: v2(102.54,78.23) 102.54,78.83 100.32,81.06 74.04,81.06 65.2,72.22 64.24,72.22 62.89,70.87 62.89,70.87 54.62,70.87 v2(53.3,69.55)
  BOTTOM w0.203: PG5011.2 102.54,78.81 v2(102.54,78.23) ; v2(40.42,66.96) 40.68,67.22 PR5003.2 ; v1(53.47,70.17) 53.3,70.01 v2(53.3,69.55)
PWR_VCCSA_PWM: length 74.5
  TOP w0.203: v2(100.22,87.22) 100.22,87.31 v1(100.61,87.71) 101.28,88.38 103.05,88.38 103.49,87.94 PU5002.3
  L6 w0.203: v3(43.92,67.16) 43.92,67.96 43.59,68.29 43.59,70.06 45.62,72.09 48.45,72.09 50.65,74.29 50.65,74.47 51.85,75.67 53.15,75.67 54.18,76.7 56.78,76.7 56.95,76.54 57.43,76.54 57.77,76.88 57.77,76.88 57.8,76.9 57.8,77.29 63.87,83.36 64.47,83.36 65.29,84.18 65.29,84.99 65.14,85.14 65.14,86.44 66.74,88.04 88.82,88.04 88.86,88.08 99.34,88.08 100.22,87.2 v2(100.22,87.22)
  BOTTOM w0.203: PU4601.30 44.18,66.9 v3(43.92,67.16)
PWR_VCCSA_RTN: length 5.9
  BOTTOM w0.203: PC4613.1 42.25,64.39 42.34,64.39 42.58,64.63 42.58,64.73 v1(42.71,64.86) 42.86,65.01 43.67,65.01 43.74,65.08 PU4601.26
  BOTTOM w0.254: PC4613.1 41.79,64 PR4627.2 40.93,64.02 PC4616.1 39.36,64.7 PR4692.1
PWR_VCCSA_SW:
  vias: v1(105.17,79.08) v4(98.75,79.51) v4(99.32,78.68) v4(99.79,79.47) v4(100.18,78.66) v4(103.16,79.15) v4(103.9,78.76) v4(104.36,79.49)
PWR_VCORE_ALERT#: length 2.2
  BOTTOM w0.203: PU4601.36 46.77,68.07 47.64,68.94 PR4623.2
PWR_VCORE_BOOTA: length 3.8
  TOP w0.508: v2(69.33,87.23) 70.43,86.13 v1(70.59,86.13) 70.61,86.13 70.67,86.07 71.46,86.07 PR4704.2
  BOTTOM w0.305: v2(69.33,87.23) 69.45,87.23 69.77,86.92 PU4701.5
PWR_VCORE_BOOTA_RC: length 2.2
  TOP w0.305: PC4708.1 73.93,87.09 v1(73.96,87.12)
  TOP w0.635: PC4708.1 PR4704.1
PWR_VCORE_BOOTB: length 3.5
  TOP w0.305: v2(90.67,87.56) 91.56,86.67 v1(91.77,86.67) 92.77,86.67 PR4710.2
  BOTTOM w0.305: PU4702.5 v2(90.67,87.56)
PWR_VCORE_BOOTB_RC: length 2.4
  TOP w0.635: v1(95.35,86.65) 95.11,86.9 PR4710.1 94.3,86.92 PC4711.1
PWR_VCORE_BOOTRA: length 1.7
  TOP w0.508: PC4708.2 70.96,87.09 v2(70.77,87.28)
  BOTTOM w0.305: PU4701.7 v2(70.77,87.28)
PWR_VCORE_BOOTRB: length 2.4
  TOP w0.305: v2(91.61,87.6) 92.13,88.12 PC4711.2
  BOTTOM w0.305: PU4702.7 91.67,87.53 v2(91.61,87.6)
PWR_VCORE_COMP: length 4.5
  BOTTOM w0.203: PU4601.4 50.39,65.48 v1(51.36,64.51) 51.5,64.37 PR4626.2 PC4610.2
PWR_VCORE_COMP1: length 2.6
  BOTTOM w0.203: v1(53.3,65.26) 53.3,64.52 PR4626.1 53.29,64.23 PC4612.1 53.29,62.81 PC4651.1
PWR_VCORE_FB: length 5.1
  BOTTOM w0.203: PU4601.5 50.25,65.08 50.95,64.38 50.95,64.23
  BOTTOM w0.254: v1(50.98,63.31) 50.95,63.31 ; 50.95,63.31 50.95,62.43 PR4630.2 ; 50.95,63.31 50.95,64.23
PWR_VCORE_FB1: length 0.7
  BOTTOM w0.254: PC4614.1 53.12,61.96 PR4630.1
PWR_VCORE_FB2:
  vias: v1(54.11,60.22)
PWR_VCORE_FCCM#: length 71.9
  TOP w0.203: PR4712.1 90.03,85.48 89.68,85.13 87.49,85.13 86.33,86.28 v1(85.44,86.28) 84.76,86.28 84.47,86.58 76,86.58 74.59,87.98 67.37,87.98 v2(66.88,87.5)
  L6 w0.203: v2(48.6,61.65) 48.94,61.99 48.94,66.57 50.3,67.92 50.3,69.09 53.03,71.83 62.15,71.83 63.75,73.43 63.81,73.43 64.45,74.07 65.56,74.07 66.66,75.17 66.66,76.96 71.79,82.1 71.79,85.17 70.72,86.24 68.14,86.24 v2(66.88,87.5)
  BOTTOM w0.203: v2(48.6,61.65) 48.6,61.96 48.37,62.19 PU4601.11 ; PR4706.1 67.41,88.02 v2(66.88,87.5)
PWR_VCORE_FCCM#_RA: length 1.7
  BOTTOM w0.203: PU4701.2 68.27,86.92 68.14,87.05 68.14,87.95 PR4706.2
PWR_VCORE_FCCM#_RB: length 2.5
  TOP w0.203: v2(89.17,87.56) 89.33,87.72 89.84,87.72 v1(89.89,87.67) 89.89,86.89 PR4712.2
  BOTTOM w0.203: PU4702.2 89.15,86.88 89.15,87.54 v2(89.17,87.56)
PWR_VCORE_IMON: length 3.3
  TOP w0.203: PR4608.2 49.09,65.94 PC4604.2 49.39,65.87 v2(49.9,66.38) 49.95,66.32 v1(49.95,65.82)
  BOTTOM w0.203: PU4601.2 49.67,66.28 49.77,66.38 v2(49.9,66.38)
PWR_VCORE_ISEN1: length 18.8
  TOP w0.203: 49.33,63.35 49.74,63.77 51.47,63.77 53.39,61.84 53.39,58.29 51.76,56.66 50.89,56.66 50.6,56.95 PR4724.1 ; 49.33,63.35 v1(49.34,63.35) ; 49.33,63.35 49.46,63.22 PC4625.1 49.52,62.37 PR4721.1 49.41,61.49 49.41,61.06 v2(49.31,60.97)
  BOTTOM w0.203: v2(49.31,60.97) 49.36,60.97 ; 49.36,60.97 49.36,60.3 PR4669.2 ; 49.36,60.97 49.56,61.16 49.56,63.29 49.37,63.48 PU4601.9
PWR_VCORE_ISEN2: length 9.9
  TOP w0.203: PR4722.1 47.16,59.58 47.69,60.12 48.09,60.12 v1(48.78,59.43) 48.77,59.41 PR4635.1 49.5,58.56 PC4626.1 49.6,58.66 49.6,59.26 PR4723.1 49.65,59.95 48.83,60.76 48.83,60.81 v2(48.63,61.02)
  BOTTOM w0.203: PR4669.1 48.61,60.41 48.61,60.99 v2(48.63,61.02) 48.78,61.17 48.8,61.17 49.09,61.45 49.09,62.59 48.96,62.72 PU4601.10
PWR_VCORE_ISUMN: length 44.3
  TOP w0.203: PC4633.1 50.37,63.08 PC4625.2 50.75,62.43 v1(51.23,61.95) 52.94,60.24 52.94,59.52 51.98,58.56 v2(50.22,58.56) 50.6,58.18 PR4715.1 50.37,57.7 PC4626.2
  L6 w0.203: v2(50.22,58.56) 50.22,58.97 50.74,59.5 50.76,59.5 51.04,59.78 51.04,59.8 51.04,59.8 51.04,60.42 51.22,60.6 51.22,60.84 53.23,62.85 57.59,62.85 58.04,63.3 60.26,63.3 65.11,68.15 68.53,68.15 69.02,68.65 69.02,71.13 69.53,71.63 v2(69.53,71.8)
  BOTTOM w0.203: PC4630.2 49.64,57.76 PR4642.2 PR4645.2 48.36,57.39 PR4709.1 ; PC4630.2 PR4647.1 ; PC4630.2 PR4643.2 50.28,58.5 v2(50.22,58.56) ; v2(69.53,71.8) 69.53,72.56 69.75,72.78 PR4646.2
PWR_VCORE_ISUMN_GA: length 36.3
  TOP w0.203: v1(47.88,57.97) 47.89,57.98 v2(47.89,58.7) 47.83,58.64 PR4722.2
  L6 w0.203: v2(70.17,74.53) 70.17,74.54 69.65,75.05 69.36,75.05 68.79,74.48 68.79,73.99 64.07,69.27 63.55,69.27 58.5,64.22 51.74,64.22 49.8,62.27 49.8,60.61 v2(47.89,58.7)
  BOTTOM w0.203: v2(47.89,58.7) 47.94,58.65 PR4709.2 ; PG4709.2 70.72,77.55 70.42,77.25 70.42,74.79 v2(70.17,74.53)
PWR_VCORE_ISUMN_GB: length 54.7
  TOP w0.203: PR4724.2 PR4715.2 52.13,57.93 v2(52.56,58.36) ; v2(88.15,77.17) 88.15,76.78 v1(88.3,76.63)
  L6 w0.203: v2(88.15,77.17) 87.79,77.53 87.79,78.49 86.13,80.14 74.99,80.14 71.38,76.53 71.38,72.84 70.7,72.16 70.7,69.03 68.62,66.95 66.03,66.95 61.14,62.06 58.24,62.06 56.68,60.49 53.87,60.49 53.86,60.49 53.49,60.49 52.97,59.97 52.97,58.77 v2(52.56,58.36)
  BOTTOM w0.203: PG4715.2 87.52,77.81 v2(88.15,77.17)
PWR_VCORE_ISUMN_P_1: length 3.3
  BOTTOM w0.203: v1(54.32,57.06) 54.16,56.9 PC4654.2 PC4628.2 PC4653.2 PR4647.2
PWR_VCORE_ISUMN_P_2: length 33.6
  L6 w0.203: v2(70.19,71.8) 70.19,69.17 68.72,67.7 65.3,67.7 60.45,62.84 58.23,62.84 57.78,62.4 54.41,62.4 51.42,59.41 51.42,57.89 52.41,56.9 v2(54.86,56.9)
  BOTTOM w0.203: v2(70.19,71.8) 70.61,72.22 v1(70.61,72.49) PR4646.1 ; v2(54.86,56.9) 55.55,56.9 PR4641.2
PWR_VCORE_ISUMN_RC: length 0.8
  BOTTOM w0.203: PR4645.1 48.73,59.34 PC4623.1
PWR_VCORE_ISUMNB: length 6.2
  BOTTOM w0.203: PR4642.1 49.49,58.78 PC4623.2 49.5,59.64 49.92,60.02 49.92,60.03 50.05,60.16 v1(50.05,60.86) 50.05,63.35 49.53,63.88 PU4601.8
PWR_VCORE_ISUMP: length 13.7
  TOP w0.203: PR4716.1 51.36,60.17 v2(50.74,60.8)
  BOTTOM w0.203: PR4641.1 54.25,57.68 54.19,57.74 PC4654.1 PC4628.1 PC4653.1 PC4630.1 PR4643.1 PR4708.1 51.16,59.77 51.06,59.86 51.06,60.19 50.86,60.39 50.86,60.41 50.74,60.53 v2(50.74,60.8) 50.74,61.88 50.51,62.11 v1(50.51,62.18) 50.51,63.46 49.69,64.28 PU4601.7
PWR_VCORE_ISUMP_GA: length 33.4
  TOP w0.203: PR4721.2 50.38,61.44 49.97,61.04 v1(49.97,60.65) 49.97,60.5 50.49,59.98 v2(50.56,59.98)
  L6 w0.203: v2(69.51,74.51) 69.51,74.03 64.29,68.81 63.74,68.81 58.69,63.76 51.93,63.76 50.25,62.08 50.25,60.28 v2(50.56,59.98)
  BOTTOM w0.203: v2(50.56,59.98) 50.41,59.83 PR4708.2 ; PG4708.2 69.6,77.58 69.96,77.22 69.96,75.24 69.51,74.78 v2(69.51,74.51)
PWR_VCORE_ISUMP_GB: length 57.5
  TOP w0.203: v2(88.81,77.2) 88.81,77.75 v1(88.82,77.75) ; v2(52,59.27) 51.42,59.27 PR4716.2 51.26,59.31 50.52,59.31 PR4723.2
  L6 w0.203: v2(88.81,77.2) 88.63,77.02 88.63,76.97 88.35,76.69 87.76,76.69 87.33,77.12 87.33,78.3 85.94,79.68 75.18,79.68 71.83,76.34 71.83,72.65 71.16,71.97 71.16,68.84 68.81,66.5 66.22,66.5 61.33,61.6 58.43,61.6 56.87,60.03 53.68,60.03 53.43,59.78 53.43,58.25 52.95,57.77 52.19,57.77 51.88,58.08 51.88,58.93 52,59.05 v2(52,59.27)
  BOTTOM w0.203: PG4713.2 88.81,77.27 v2(88.81,77.2)
PWR_VCORE_NTC: length 3.7
  BOTTOM w0.203: PU4601.3 50.57,65.88 50.89,65.56 PR4616.2 51.49,65.65 v1(51.49,66.45)
PWR_VCORE_NTC1: length 43
  TOP w0.203: v1(51.46,65.53) 51.46,65.24 v2(51.79,64.91)
  L6 w0.203: v2(51.79,64.91) 51.79,68.29 51.19,68.89 51.19,69.34 53.22,71.37 62.34,71.37 63.94,72.97 65.31,72.97 67.58,75.25 67.58,76.14 72.25,80.81 72.25,85.36 70.91,86.7 70.5,86.7 70.14,87.05 v2(70.14,87.41)
  BOTTOM w0.203: PR4621.2 PR4616.1 v2(51.79,64.91) ; PR4617.1 71.47,87.64 71.27,87.84 70.58,87.84 v2(70.14,87.41)
PWR_VCORE_PROG1: length 1.5
  BOTTOM w0.203: PU4601.32 45.17,67.7 44.56,68.31 PR4629.1
PWR_VCORE_PROG2: length 2
  BOTTOM w0.203: PR4628.1 43.5,67.95 43.73,67.72 44.46,67.72 44.77,67.41 PU4601.31
PWR_VCORE_PWMA: length 49.5
  TOP w0.203: v1(65.57,86.83) 65.57,86.16 v2(65.67,86.06)
  L6 w0.203: v2(47.92,59.52) 47.43,59.52 45.73,61.22 45.73,61.65 46.04,61.95 46.04,66.4 46.7,67.06 46.7,70.39 46.67,70.42 46.67,70.82 47.23,71.38 48.74,71.38 50.9,73.54 60.02,73.54 62.79,76.31 63.84,76.31 64.1,76.58 64.26,76.58 66.87,79.19 66.87,85.05 65.85,86.06 v2(65.67,86.06)
  BOTTOM w0.203: v2(47.92,59.52) 47.92,60.61 48.12,60.81 48.12,61.88 47.97,62.03 PU4601.12 ; PR4702.1 64.54,86.41 64.88,86.06 v2(65.67,86.06)
PWR_VCORE_PWMA_RA: length 3.7
  BOTTOM w0.203: PR4702.2 65.4,87.44 PR4717.1 66.15,87.52 v1(66.23,87.43) 67.14,86.52 PU4701.1
PWR_VCORE_PWMB: length 65.2
  TOP w0.203: v2(66.21,86.77) 66.33,86.9 66.33,87.99 67.09,88.75 78.24,88.75 79.7,87.29 v1(84.06,87.29) 84.76,87.29 85.06,87 86.21,87 PR4711.1
  L6 w0.203: v2(66.21,86.77) 66.48,86.77 67.58,85.67 67.58,78.89 64.55,75.87 64.4,75.87 64.13,75.6 63.09,75.6 60.31,72.83 51.48,72.83 49.56,70.91 49.56,70.38 47.79,68.61 47.79,66.79 48.2,66.39 48.2,62.25 47.72,61.77 47.72,61.12 v2(47.49,60.89)
  BOTTOM w0.203: PU4601.13 47.57,61.88 47.75,61.7 47.75,61.15 v2(47.49,60.89)
PWR_VCORE_PWMB_RA: length 4.1
  TOP w0.203: v2(88.31,87.52) 88.51,87.32 PR4718.1 88.32,86.6 87.85,86.14 87.58,86.14 v1(87.55,86.11) 87.55,86.24 87.1,86.69 PR4711.2
  BOTTOM w0.203: PU4702.1 88.67,87.15 v2(88.31,87.52)
PWR_VCORE_RTN: length 11.7
  TOP w0.254: v2(50.06,64.58) 49.43,64.58 PR4685.1 49.11,65 PC4622.1
  TOP w0.381: v1(50.64,64.57) 50.08,64.57 v2(50.06,64.58)
  L3 w0.381: v2(50.06,64.58) 50.06,62.28 52.06,60.29 52.06,60.13 52.46,59.74 v2(52.46,59.73)
  BOTTOM w0.203: v2(50.06,64.58) 49.97,64.68 PU4601.6
  BOTTOM w0.254: PR4666.2 PC4619.2 52.82,58.98 52.82,58.98 52.67,59.13 52.67,59.49 52.46,59.67 52.46,59.74 v2(52.46,59.73)
PWR_VCORE_SCLK: length 2.4
  BOTTOM w0.203: PU4601.37 47.17,67.92 47.84,68.59 47.97,68.59 PR4624.2
PWR_VCORE_SDIO: length 2
  BOTTOM w0.203: PU4601.35 46.37,68.05 46.44,68.12 46.44,68.21 46.51,68.28 46.51,68.29 46.85,68.63 PR4622.2
PWR_VCORE_SNB1: length 2
  TOP w0.305: v1(67.4,81.29) 67.55,81.13 PC4710.1
  TOP w0.356: PC4710.1 68.29,80.27 PR4705.2
PWR_VCORE_SNB2: length 2.7
  TOP w0.635: PR4714.2 91.66,80.62 PC4713.1 92.73,81.26 93.24,80.75 v1(93.24,80.49)
PWR_VCORE_SWA: length 3.5
  TOP w0.305: v1(68.33,76.31) 68.16,76.48 PR4705.1
  TOP w0.356: PR4705.1 68.16,78.49 68.52,78.85 v2(69.25,78.85)
PWR_VCORE_SWB: length 2.3
  TOP w0.635: v1(93.81,77.32) 93.6,77.53 v2(93.06,77.53) 93.02,77.58 PR4714.1
PWR_VCORE_VCC: length 1
  BOTTOM w0.203: v1(45.97,68.28) PU4601.34
PWR_VCORE_VCCDA: length 3.3
  TOP w0.305: v1(69.03,86.6) 69.03,86.7 68.67,87.05 68.67,87.27 v2(68.63,87.32) 68.18,86.86 PC4709.1 68.14,86.86 PR4703.2
  BOTTOM w0.305: v2(68.63,87.32) 68.63,87.29 68.77,87.15 PU4701.3
PWR_VCORE_VCCDB: length 5.3
  BOTTOM w0.305: PR4713.2 86.91,86.67 86.91,87.39 PC4712.1 87.48,87.97 v1(87.66,87.97) 87.81,88.12 89.62,88.12 89.83,87.91 89.83,87.48 89.67,87.32 PU4702.3
PWR_VCORE_VIN: length 1.3
  BOTTOM w0.203: PU4601.33 45.57,68 45.2,68.37 v2(45.2,68.38)
  vias: v1(45.8,67.72)
PWR_VCORE_VRHOT#: length 2.8
  BOTTOM w0.203: PR4607.2 49.24,68.89 48.69,68.35 48.2,68.35 48.1,68.25 48.08,68.25 47.57,67.74 PU4601.38
PWR_VDDQ:
  vias: v1(46.73,40.6) v4(43.55,40.14) v4(43.57,39.02) v4(44.51,40.14) v4(44.54,39.02) v4(45.55,44.25) v4(45.55,43.11)
PWR_VDDQ_BOOT: length 3.8
  TOP w0.203: v2(34.44,38.22) 34.44,37.81 34.69,37.55 34.69,37.06 34.96,36.8 v1(34.96,36.8) 36,36.8 PR5111.1
  BOTTOM w0.203: PU5101.27 34.22,38.44 v2(34.44,38.22)
PWR_VDDQ_BOOTA: length 3.4
  TOP w0.203: PC5110.2 36.85,38.05 37.34,38.05 37.84,37.56 PR5111.2 37.99,36.48 v1(38.95,36.48)
PWR_VDDQ_BOOTB: length 2.2
  TOP w0.203: PC5110.1 35.42,38.1 v2(35.29,38.23) 35.29,38.48 v1(34.98,38.79)
  BOTTOM w0.203: v2(35.29,38.23) 35.02,38.51 PU5101.25
PWR_VDDQ_CS: length 1.9
  BOTTOM w0.203: PU5101.10 32.62,43.35 32.48,43.48 PR5102.2 33.12,44.4 v1(33.23,44.4)
PWR_VDDQ_EN: length 18.6
  TOP w0.102: v1(30.34,40.19) 30.34,41.05 v2(30.86,41.56)
  L3 w0.102: v2(28.58,32.36) 30.64,32.36 31.97,33.7 31.97,35.53 31.17,36.33 31.17,37.89 30.13,38.93 30.13,40.83 v2(30.86,41.56)
  BOTTOM w0.102: v2(30.86,41.56) 30.86,41.55 PU5101.6 ; PU5151.7 28.97,32.57 28.77,32.36 28.64,32.36 ; 28.64,32.36 v2(28.58,32.36) ; 28.64,32.36 28.3,32.02 PR5156.1 27.85,32.64 PR5152.2
PWR_VDDQ_FB: length 4
  BOTTOM w0.203: PR5105.2 29.77,40.14 30.57,40.14 30.6,40.11 31,40.11 31.24,40.35 PU5101.3
  BOTTOM w0.254: v1(29.26,41.08) 28.87,40.68 PR5106.1
  BOTTOM w0.381: PR5106.1 28.89,40.16 PR5105.2
PWR_VDDQ_PG: length 25.7
  TOP w0.203: v2(31.56,42.85) 31.87,43.16 31.87,43.32 v1(31.88,43.32)
  L3 w0.203: v2(35.98,61.75) 33.67,59.44 33.67,56.15 34.18,55.65 34.18,50.17 31.56,47.56 v2(31.56,42.85)
  BOTTOM w0.203: v2(35.98,61.75) 35.98,61.61 36.44,61.14 R4011.1 ; PR5104.2 29.32,42.89 31.51,42.89 31.55,42.85 ; 31.55,42.85 v2(31.56,42.85) ; 31.55,42.85 31.69,42.71 31.69,42.4 PU5101.8
PWR_VDDQ_PH:
  vias: v1(33.4,41) v2(32.45,41.53) v2(33.13,41.53)
PWR_VDDQ_SNB:
  vias: v1(36.14,42.44)
PWR_VDDQ_TON: length 2.5
  BOTTOM w0.203: PU5101.7 31.2,41.95 30.97,42.18 v1(30.17,42.18) PR5108.2
PWR_VDDQ_VCC: length 3.9
  BOTTOM w0.203: PR5101.2 30.6,43.95 30.6,44.51 v1(30.7,44.61) 30.84,44.75 31.39,44.75 PC5104.1 31.58,44.56 31.58,43.8 PR5102.1 32.22,43.17 PU5101.9
PWR_VDDQ_VDDQ: length 24.7
  L5 w0.305: v2(27.58,36.49) 28.31,35.76 29.12,35.76 29.13,35.77 29.57,35.77 29.58,35.76 29.96,35.76 30.05,35.67 30.49,35.67 30.61,35.79 41.48,35.79 v2(41.5,35.77)
  BOTTOM w0.203: PR5105.1 30.01,39.3 30.49,39.77 31.14,39.77 31.31,39.95 PU5101.2
  BOTTOM w0.305: v2(41.5,35.77) 42.79,35.77 43.52,36.5 43.98,36.5 44.67,37.19 PG5104.1 ; PR5105.1 29.3,39.3 28.97,38.97 28.36,38.97 27.71,38.32 27.71,38.3 27.58,38.17 v1(27.58,37.46) v2(27.58,36.49)
PWR_VDDQ_VLDOIN: length 1.4
  TOP w0.356: v2(33.76,38.29) 33.62,38.43 PC5103.1
  BOTTOM w0.203: v2(33.76,38.29) 33.76,38.29 33.82,38.34 PU5101.28
  vias: v1(32.94,38.23)
PWR_VDDQ_VTT:
  vias: v1(30.82,39.11)
PWR_VDDQ_VTTREF: length 0.6
  BOTTOM w0.203: PU5101.1 31.64,39.3 31.47,39.12 31.47,39.07 v2(31.46,39.07)
  vias: v1(32.19,40.25)
PWR_VGA_NVVDD_OR: length 2.7
  TOP w0.203: R8521.1 144.48,80.1 v2(144.52,80.14)
  BOTTOM w0.203: Q8504.D v2(144.52,80.14) 144.66,80.28 v1(144.66,80.85)
PWR_VGA_NVVDD_OR#: length 18.4
  TOP w0.203: v2(144.19,81.21) 143.77,81.21 v1(143.64,81.34)
  L6 w0.203: v2(150.78,78.99) 148.6,81.17 145.06,81.17 145.02,81.21 v2(144.19,81.21)
  BOTTOM w0.203: v2(150.78,78.99) 151.53,79.74 Q8605.G ; Q8509.6 142.33,79.91 142.65,80.23 142.67,80.23 142.71,80.27 143.02,80.27 143.63,80.87 Q8509.3 v2(144.19,81.21) ; Q8509.6 142.33,78.66 142.5,78.49 142.5,78.47 142.78,78.18 142.81,78.18 142.81,78.18 144.27,78.18 145.47,76.97 Q8504.G ; Q8509.6 142.22,79.66 R8541.2
PWR_VGA_NVVDD_PG#: length 3.2
  TOP w0.203: v1(147.69,80.43) 147.69,80.74 R8612.2 147.18,81.78 v2(146.9,82.05)
  BOTTOM w0.203: v2(146.9,82.05) Q8615.6 Q8615.5
PWR_VGA_NVVDDS_BOOT1: length 2.3
  BOTTOM w0.203: 148.34,29.85 148.28,29.9 148.24,29.9 148,30.13 v1(147.81,30.13) 147.72,30.13 147.27,29.68 PU8551.1
  BOTTOM w0.305: 148.34,29.85 148.75,29.85 PR8551.1
PWR_VGA_NVVDDS_BOOT1_A:
  vias: v1(150.3,30.85)
PWR_VGA_NVVDDS_BOOT2: length 2.1
  BOTTOM w0.203: PU8551.15 143.59,29.68 143.29,29.99 v1(143.05,29.99) 143.01,29.95 142.61,29.95 142.46,29.8
  BOTTOM w0.508: PR8573.1 142.46,29.8
PWR_VGA_NVVDDS_BOOT2_A:
  vias: v1(140.57,30.94)
PWR_VGA_NVVDDS_EN: length 70.4
  TOP w0.203: R8529.2 144.58,78.65 R8521.2 144.48,78.52 v1(143.6,77.64) 142.93,77.64 v3(142.73,77.44) ; C8525.1 147.33,29.28 147.33,29.09 147.67,28.75 147.77,28.75 147.8,28.72 148.33,28.72 v2(148.37,28.67)
  L3 w0.203: v2(143.76,60.1) 143.67,60.02 143.67,58.92 158.32,44.27 159.25,44.27 159.68,43.84 159.68,39.51 157.49,37.32 157.49,34.62 155.17,32.29 155.17,32.26 154.38,31.48 150.89,31.48 148.37,28.96 v2(148.37,28.67)
  L6 w0.203: v3(142.73,77.44) 142.73,76.64 142.86,76.51 142.86,75.58 142.11,74.84 142.11,63.26 143.78,61.59 143.78,60.13 v2(143.76,60.1)
  BOTTOM w0.203: v2(148.37,28.67) 148.34,28.7 147.71,28.7 147.53,28.88 PU8551.3
PWR_VGA_NVVDDS_HG1: length 17.7
  TOP w0.635: v4(153.94,32.95) 153.82,33.07 153.82,33.68 PU8553.1 ; v4(153.82,38.52) v1(153.82,39.27)
  L8 w0.635: v4(147.92,29.33) 147.92,30.71 150.14,32.93 153.95,32.93 153.95,32.95 v4(153.94,32.95) 153.82,33.07 153.82,38.52 v4(153.82,38.52)
  BOTTOM w0.203: PU8551.2 147.86,29.28 147.91,29.33 v4(147.92,29.33)
  BOTTOM w0.635: PU8552.1 153.82,37.81 v4(153.82,38.52)
PWR_VGA_NVVDDS_HG2: length 18.6
  TOP w0.635: PU8555.1 135.95,38.36 v4(136.37,38.78) v1(136.84,39.25)
  L8 w0.635: v4(136.37,38.78) 135.89,38.3 v4(135.89,32.87) 135.98,32.77 139.71,32.77 v4(143.2,29.28)
  BOTTOM w0.203: PU8551.14 v4(143.2,29.28)
  BOTTOM w0.635: PU8554.1 135.89,33.77 v4(135.89,32.87)
PWR_VGA_NVVDDS_LGATE1: length 12.3
  TOP w0.635: v4(147.93,32.91) 147.93,33.68 PU8553.8
  L8 w0.635: v4(147.92,38.54) 147.93,38.53 v4(147.93,32.91) 147.88,32.95 147.01,32.95 146.15,32.09 v4(146.15,31.2)
  BOTTOM w0.203: v1(147.75,32.27) 147.75,32.73 v4(147.93,32.91) ; v4(146.15,31.2) 146.14,31.2 145.81,30.87 PU8551.19
  BOTTOM w0.635: PU8552.8 147.92,37.81 v4(147.92,38.54)
PWR_VGA_NVVDDS_LGATE2: length 12.8
  TOP w0.635: v4(144.46,31.15) v1(143.8,31.15) ; PU8555.8 141.81,37.69 v4(141.81,38.65)
  L8 w0.635: 141.78,32.98 v4(141.78,32.97) ; 141.78,32.98 141.78,38.63 v4(141.81,38.65) ; 141.78,32.98 141.82,32.98 143.65,31.15 v4(144.46,31.15)
  BOTTOM w0.203: PU8551.17 145.01,30.85 144.72,31.15 v4(144.46,31.15)
  BOTTOM w0.635: v4(141.78,32.97) 141.78,33.77 PU8554.8
PWR_VGA_NVVDDS_OCSET: length 4.5
  TOP w0.203: v2(142.32,28.14) 142.32,28.92 v1(142.45,29.05) 141.88,29.05 PC8561.1
  BOTTOM w0.203: PU8551.12 143.69,28.48 143.34,28.14 143.28,28.14 143.2,28.07 142.83,28.07 142.75,28.14 v2(142.32,28.14) PR8564.1
PWR_VGA_NVVDDS_PG: length 117.6
  TOP w0.203: R8532.1 147.68,84.56 v2(147.68,84.93) 146.96,84.93 PR8557.2 ; v1(132.23,67.93) 132.15,68.01 v2(132.15,68.56)
  L3 w0.203: v2(144.38,60.11) 144.38,60.04 143.97,59.62 143.97,59.27 155.18,48.06 156.11,48.06 159.87,44.3 160.13,44.03 160.13,39.3 157.95,37.11 157.95,34.43 155.62,32.1 155.62,32.07 154.57,31.02 151.56,31.02 149.05,28.51 149.05,27.57 148.04,26.56 147.37,26.56 146.77,27.16 144.39,27.16 v2(143.01,28.53)
  L5 w0.203: v2(141.45,82.26) 141.8,82.26 143.04,83.49 145.06,83.49 146.27,82.29 146.27,80 145.77,79.5 145.77,78.11 v2(145.61,77.95)
  L6 w0.203: v2(145.61,77.95) 145.24,77.95 143.31,76.02 143.31,75.39 142.57,74.65 142.57,63.45 144.24,61.77 144.24,60.25 v2(144.38,60.11)
  L8 w0.203: v2(147.68,84.93) 146.35,83.6 143.57,83.6 142.2,82.23 141.44,82.23 141.44,82.25 141.44,82.26 v2(141.45,82.26) ; v2(132.15,68.56) 132.15,68.67 132.68,69.2 132.68,69.82 136.9,74.04 140.46,74.04 141.89,75.48 141.89,76.58 142.29,76.98 145.32,76.98 145.61,77.27 v2(145.61,77.95)
  BOTTOM w0.203: v2(143.01,28.53) 143.17,28.68 143.39,28.68 143.59,28.88 PU8551.13 ; v2(145.61,77.95) 145.39,78.17 R8617.1 ; Q8612.2 131.43,69.93 131.58,69.77 131.58,69.13 v2(132.15,68.56)
PWR_VGA_NVVDDS_PHASE1: length 4
  BOTTOM w0.203: PU8551.20 146.51,30.37 146.9,30.76
  BOTTOM w0.508: PC8556.2 148.6,31.08 v1(149.87,32.35) 149.87,33.35
  vias: v4(148.63,41.05) v4(148.63,39.98) v4(148.63,39.15) v4(149.26,43.06) v4(149.47,41.97) v4(150.1,43.04) v4(150.32,41.97) v4(150.99,43.06) v4(151.27,41.97) v4(151.83,43.03) v4(152.13,41.97) v4(152.67,43.03)
PWR_VGA_NVVDDS_PHASE2: length 8.9
  BOTTOM w0.203: PU8551.16 143.76,30.37 143.3,30.83 PC8569.2
  BOTTOM w0.508: 139.49,35.84 140.5,34.82 140.5,32.49 141.01,31.98 141.44,31.98 v1(141.63,31.79) 142.41,31.02 PC8569.2
  vias: v4(136.95,42.35) v4(137.79,42.35) v4(138.3,43.42) v4(138.7,42.3) v4(139.2,43.41) v4(139.53,42.28) v4(140.04,43.41) v4(140.4,42.3) v4(140.91,43.13) v4(141.21,41.51) v4(141.16,40.49) v4(141.16,39.55)
PWR_VGA_NVVDDS_PSI: length 5.1
  TOP w0.203: 147.52,28.14 147.55,28.12 148.14,28.12 148.42,27.84 PR8559.2 149.04,28.36 PR8522.2 ; 147.52,28.14 147.5,28.12 147.01,28.12 PR8563.1 146.92,28.74 PC8557.1 ; 147.52,28.14 v2(147.56,28.14)
  BOTTOM w0.203: v1(148.13,27.99) 147.98,28.14 v2(147.56,28.14) 147.52,28.14 147.18,28.48 PU8551.4
PWR_VGA_NVVDDS_PVCC: length 3.9
  BOTTOM w0.203: PU8551.18 145.41,31.22
  BOTTOM w0.508: 145.41,31.22 145.41,31.74 PR8556.2 144.26,32.14 PC8555.1 143.2,31.95 v1(143.13,32.02)
PWR_VGA_NVVDDS_REFADJ: length 2.9
  BOTTOM w0.203: PU8551.6 146.57,27.4 147.31,26.65 v1(147.95,26.65) PR8567.2
PWR_VGA_NVVDDS_REFADJ_R: length 5.1
  TOP w0.203: v1(148.85,23.71) 148.29,23.71 v2(148.21,23.78) 147.68,24.31 147.16,24.31 PC8565.1
  BOTTOM w0.203: PR8566.2 147.17,24.92 PR8568.1 147.92,24.93 PR8567.1 147.95,24.09 148.25,23.78 v2(148.21,23.78)
PWR_VGA_NVVDDS_REFIN: length 6.1
  TOP w0.203: v1(148.63,24.91) 148.62,24.89 PC8567.1 147.74,25.79 PR8570.1 147.72,26.2 147.37,26.56 146.49,26.56 v2(146.49,26.57)
  BOTTOM w0.203: PR8568.2 147.17,26.25 146.93,26.5 146.57,26.5 v2(146.49,26.57) 146.29,26.78 146.15,26.78 145.81,27.12 PU8551.7
PWR_VGA_NVVDDS_REFIN_R: length 1.8
  TOP w0.203: PR8570.2 146.07,25.81 PR8572.1 145.17,25.81 v1(145.12,25.77)
PWR_VGA_NVVDDS_TON: length 3.9
  TOP w0.203: PR8562.2 144.18,25.53 145.07,26.41 v2(145.07,26.58) 144.94,26.58 144.33,27.19 v1(143.84,27.19)
  BOTTOM w0.203: PU8551.9 145.01,26.58 v2(145.07,26.58)
PWR_VGA_NVVDDS_TON_1: length 3.2
  TOP w0.203: PR8562.1 143.64,24.66 PR8561.2 143.11,24.45 PC8554.1 142.86,23.49 v1(142.69,23.32)
PWR_VGA_NVVDDS_VID: length 4.2
  TOP w0.203: PC8560.2 147.71,27.25 v2(147.76,27.2) 147.76,27.17 148.05,26.88 148.4,26.88 v1(148.43,26.85) 148.48,26.85 148.95,26.37 PR8510.2
  BOTTOM w0.203: PU8551.5 146.9,27.69 147.33,27.26 147.7,27.26 v2(147.76,27.2)
PWR_VGA_NVVDDS_VREF: length 4.5
  TOP w0.203: PC8562.2 144.57,28.03 v1(145.3,27.29) 145.71,26.89 v2(145.71,26.57)
  BOTTOM w0.203: PR8566.1 146.37,25.86 145.81,26.42 145.81,26.47 v2(145.71,26.57) 145.71,26.71 145.41,27.01 PU8551.8
PWR_VGA_NVVDDS_VSEN1_N: length 2
  TOP w0.381: PR8569.1 143.41,26.33 143.85,26.33 v2(144.11,26.58)
  BOTTOM w0.203: PU8551.10 144.61,27.09 v2(144.11,26.58)
  vias: v1(145.58,24.37) v2(145.44,23.82)
PWR_VGA_NVVDDS_VSEN1_P: length 7.8
  TOP w0.203: PC8566.1 141.31,27.5 142.14,27.5 v1(142.18,27.55) 142.18,27.51 142.22,27.47 v2(142.74,27.47)
  BOTTOM w0.203: PU8551.11 143.92,28.02 143.54,27.64
  BOTTOM w0.381: v2(142.74,27.47) 142.91,27.64 143.54,27.64 ; v2(142.74,27.47) 143.11,27.1 PC8563.2 143.04,25.71 PR8517.2 ; v2(142.74,27.47) 141.99,26.73 141.99,26.71 PR8577.1 PR8571.1
PWR_VGA_S0_PG: length 7.1
  TOP w0.203: v2(140.85,86.25) 140.86,86.24 140.86,85.86 141.31,85.42 142.85,85.42 143.32,85.89 v1(143.74,85.89) PR8625.2 144.61,85.4 144.39,85.18 PR8623.1
  BOTTOM w0.203: PU8603.2 140.65,86.05 v2(140.85,86.25)
PWR_VPP1D8V: length 7.3
  TOP w0.305: PC5152.1 36.82,30.76 v1(36.53,30.48) 35.98,29.92 v2(35.98,29.86) ; PR5154.1 37.58,30.89 v2(38.01,30.46)
  TOP w0.508: PG5152.2 38.92,31.36 v2(38.01,30.46)
PWR_VPP1D8V_EN: length 5.1
  BOTTOM w0.203: v1(26.51,34.37) 26.52,34.37 26.67,34.52 27.61,34.52 PC5156.1 28.33,34.52 PR5151.1 28.99,34.57 PU5151.8 29.7,33.81 PR5153.2
PWR_VPP1D8V_FB: length 1.7
  BOTTOM w0.381: PU5151.2 35.04,32.57 35.75,33.28 v2(36.08,33.28)
  vias: v1(37.71,33.18)
PWR_VTT_EN: length 5.6
  BOTTOM w0.203: PU5101.5 31.13,41.15 31.06,41.08 30.45,41.08 30.44,41.08 30.01,41.08 29.57,41.52 27.66,41.52 v1(27.55,41.62) 26.89,41.62 PR5107.2
Q502_G: length 5.8
  BOTTOM w0.102: Q501.D 52.33,39.62 52.33,39.83 Q502.G v1(50.74,43.05) 50.9,43.21 R506.2
Q6204_G: length 4.1
  BOTTOM w0.254: R6510.2 124.49,15.09 v1(124.49,14.1) 124.55,14.04 Q6504.5 Q6504.2
Q6407_B: length 7.2
  TOP w0.102: v1(17.18,71.75) 16.78,71.35 v2(16.76,71.35) 16.96,71.15 16.96,70.69 R6426.1
  BOTTOM w0.102: Q6406.C 16.56,67.55 16.56,69.22 17.74,70.4 Q6407.B 16.88,71.35 v2(16.76,71.35)
Q6407_C: length 2.6
  TOP w0.102: R6413.1 16.47,72.65 v2(16.32,72.8) 16.27,72.85 v1(15.75,72.85)
  BOTTOM w0.102: v2(16.32,72.8) 16.9,72.22 Q6407.C
Q6701_G: length 10.6
  BOTTOM w0.102: Q6701.2 15.39,50.8 15.14,50.56 13.93,50.56 13.59,50.21 v1(13.59,47.91) 13.59,45.14 13.94,44.78 14.49,44.78 R6701.2 14.92,45.29 15.69,46.06 C6703.1
Q6701_G_D: length 11.8
  BOTTOM w0.102: Q6701.5 Q6701.6 16.06,53.06 16.45,52.68 16.45,50.9 15.55,50 15.55,49.1 v1(15.18,48.73) 14.49,48.05 R6702.2 15.24,47.78 C6701.2 15.67,47.75 16.07,47.36 16.9,47.36 17.46,46.8 17.46,45.41 D6701.A
Q7601_G: length 6.2
  TOP w0.102: 139.74,52.02 139.23,52.53 138.04,52.53 137.57,52.06 137.57,51.59 137.46,51.49 Q7901.5 ; 139.74,52.02 R7957.2 140.69,52.02 v1(140.73,51.98) ; 139.74,52.02 139.38,52.02 138.85,51.49 Q7901.2
RAM1_ZQ0: length 5.9
  TOP w0.102: RAM1.B3 46.58,25.41 46.53,25.37 46.53,25.01 46.27,24.75 46.27,24.33 46.18,24.24 45.4,24.24 44.67,23.5 v1(44.67,22.78) R1202.1
RAM1_ZQ1: length 6.6
  TOP w0.102: RAM1.B4 46.58,26.21 46.23,25.87 46.23,25.29 46.06,25.11 45.93,25.11 43.9,23.08 v1(43.9,21.68) R1201.1
RAM2_ZQ0: length 5.6
  TOP w0.102: v1(64.25,17.92) 64.23,17.92 ; 64.23,17.92 R1203.1 ; 64.23,17.92 64.43,18.12 64.43,18.27 65.41,19.24 65.41,21.11 65.65,21.36 65.65,21.42 65.71,21.48 RAM2.B3
RAM2_ZQ1: length 5.7
  TOP w0.102: R1204.1 v1(63.39,18.86) 63.39,19.63 64.93,21.17 65.06,21.17 65.36,21.48 65.36,22.12 RAM2.B4
RAM3_ZQ0: length 5.8
  TOP w0.102: RAM3.B3 84.58,21.62 84.58,21.26 84.28,20.97 84.28,19.16 84.09,18.97 84.09,17.83 83.57,17.31 v1(83.54,17.31) 83.18,16.95 R1302.1
RAM3_ZQ1: length 5.6
  TOP w0.102: RAM3.B4 84.31,22.15 84.31,21.57 84.11,21.37 84.02,21.37 83.44,20.78 83.44,18.6 v1(83.39,18.56) 82.69,17.85 R1301.1
RAM4_ZQ0: length 6.5
  TOP w0.102: R1304.1 101.06,16.92 v1(101.8,16.92) 101.8,16.95 102.83,17.98 102.83,20.17 103.22,20.57 103.29,20.57 103.46,20.74 103.46,21.27 103.81,21.62 RAM4.B3
RAM4_ZQ1: length 6.5
  TOP w0.102: RAM4.B4 103.51,22.17 103.51,21.58 103.29,21.37 103.17,21.37 102.42,20.62 102.42,18.26 v1(102.29,18.13) 101.99,17.84 100.96,17.84 R1303.1
RESET_OUT#: length 148.2
  TOP w0.127: ED1703.1 127.7,52.64 v2(128.02,52.32) 128.1,52.32 128.64,51.78 128.64,48.16 125.78,45.3 125.78,44.16 125.73,44.11 Q2602.G 125.17,42.61 v2(124.5,42.61)
  L3 w0.127: v2(27.86,11.35) 28.24,11.73 30.49,11.73 30.75,11.48 38.03,11.48 38.66,12.11 42.39,12.11 42.45,12.05 43.18,12.05 v2(43.69,11.53) ; v2(124.5,42.61) 126.42,40.7 126.42,37.21 125.91,36.7 125.91,31.44 124.94,30.48 124.94,27.88 124.31,27.25 124.31,25.84 123.13,24.66 123.13,19.96 123.21,19.88 123.21,15.35 123.2,15.34 123.2,14.97 123.21,14.96 123.21,13.89 v2(123.48,13.62)
  BOTTOM w0.127: v2(27.86,11.35) 27.77,11.44 U2401.73 ; R1706.1 127.86,52.48 v2(128.02,52.32) ; v2(123.48,13.62) 123.41,13.69 117.56,13.69 117.5,13.63 114.59,13.63 111.61,16.61 55.16,16.61 53.3,18.48 49.87,18.48 v1(44.47,13.08) 43.69,12.29 v2(43.69,11.53)
RTC_3P3_EN_D: length 3.2
  TOP w0.508: Q2510.D 22.51,10.58 22.55,10.54 22.55,9.4 v1(22.46,9.3) 22.24,9.09 R2511.2
RTC_3P3_EN_G: length 7.2
  TOP w0.102: Q2510.G 24.65,8.9 24.64,8.89 24.64,8.74 24.38,8.47 24.38,8.37 24.13,8.12 23.78,8.12 v1(22.97,7.3) 22.97,5.84 C2517.1 23.37,5.36 R2567.2
RTC_AUX_S5: length 162.6
  TOP w0.305: RN1801.2 117.16,25.57 117.17,25.55 ; RN1801.1 116.51,25.85 116.53,25.82 116.53,25.78 116.62,25.69 116.66,25.69 116.8,25.55 117.17,25.55 ; v2(117.41,25.31) 117.17,25.55
  TOP w0.508: v2(39.25,16.51) 38.09,15.36 38.09,14.73 38.61,14.22 38.61,12.5 37.33,11.22 37.33,9.48 35.65,7.8 35.65,5.08 33.75,3.19 24.71,3.19 23.93,2.41 21.84,2.41 21.82,2.44 21.48,2.44 20.82,3.1 20.82,5.42 20.9,5.51 20.9,5.54 v2(21.13,5.77) v1(21.13,6.82) 21.13,8.08 R2511.1 ; v2(113.75,56.44) 113.29,55.98 R2204.1
  L3 w0.356: 115.93,33.43 116.03,33.53 116.03,35.4 116.17,35.74 116.17,35.77
  L3 w0.381: 116.17,35.77 116.17,36.6 v2(116.71,37.14)
  L3 w0.508: 115.93,33.43 115.93,31.95 116.95,30.93 116.95,30.87 117.04,30.78 117.04,25.68 v2(117.41,25.31) 117.04,24.94 117.04,21.23 116.96,21.15 116.96,18.31 114.58,15.93 93.88,15.93 93.84,15.98 73.11,15.98 72.86,16.23 43.15,16.23 43.11,16.27 39.49,16.27 v2(39.25,16.51)
  L5 w0.508: v2(116.71,37.14) 116.12,37.73 115.75,37.73 113.61,39.87 113.61,40.53 112.6,41.54 112.6,42.48 111.05,44.03 111.05,49.82 111.59,50.37 111.59,54.74 112.77,55.91 113.22,55.91 v2(113.75,56.44)
  BOTTOM w0.305: v2(116.71,37.14) 116.71,37.31 R1730.1
  BOTTOM w0.508: v2(21.13,5.77) 21.27,5.63 Q2507.D
RTC_DET#: length 176.4
  TOP w0.127: v2(37.96,4.32) 37.96,6.04 41.31,9.39 41.48,9.39 43.23,11.13 43.23,12.83 43.51,13.11 43.51,13.97 v2(43.33,14.15)
  L5 w0.127: v2(118.98,21.63) 118.98,21.62 118.27,22.34 118.27,30.13 120.51,32.37 120.51,36.76 119.77,37.5 119.77,40.1 121.57,41.91 121.57,44.11 119.39,46.29 119.39,48.45 119.52,48.57 119.52,48.94 119.39,49.07 119.39,53.55 120.23,54.38 v2(120.97,54.38)
  L8 w0.127: v2(118.98,21.63) 118.98,17.54 119.02,17.51 119.02,17.06 119,17.04 119,17.01 118.86,16.86 118.82,16.86 118.7,16.74 118.69,16.74 118.5,16.54 118.5,16.5 118.47,16.47 118.47,14.92 118.22,14.68 118.22,14.68 117.73,14.19 115.55,14.19 115.05,14.69 108.49,14.69 107.74,13.94 95.55,13.94 94.82,14.67 73.13,14.67 72.34,15.46 44.47,15.46 43.33,14.32 v2(43.33,14.15)
  BOTTOM w0.076: CPU1.CP22 111.81,52.44 112.07,52.7 112.1,52.7 arc(112.19,52.71) 112.26,52.76 112.76,52.76 112.85,52.67 113.18,52.67 113.22,52.71 113.25,52.71 113.45,52.91 113.45,52.96 113.79,53.31
  BOTTOM w0.127: 113.79,53.31 113.79,53.46 115.16,54.83 119.75,54.83 R1519.1 120.96,54.38 v2(120.97,54.38) 120.97,53.85 R1554.2 ; Q2505.D 13.08,9.23 13.5,8.81 13.5,7.19 13.91,6.78 13.91,5.04 15.78,3.17 20.93,3.17 22.05,2.05 32.64,2.05 v1(34.61,4.01) 34.85,4.26 37.9,4.26 v2(37.96,4.32)
RTC_RST#: length 34.2
  TOP w0.127: v2(118.71,27.2) 118.23,27.2 v1(118.02,27.4) 117.2,28.23 G1801.2 117.06,28.33 116.51,27.78 RN1801.4
  L6 w0.127: v2(102.76,37) 102.93,36.83 103.1,36.83 103.36,36.57 103.36,34.22 105.08,32.5 112.83,32.5 115.43,29.9 115.51,29.9 118.21,27.2 v2(118.71,27.2)
  BOTTOM w0.076: 101.56,40.18 101.37,40.38 101.37,41.61 101.2,41.78 101.2,44.17 101.18,44.2 CPU1.BR34
  BOTTOM w0.127: v2(102.76,37) 102.27,37 101.59,37.68 101.59,38.32 C1806.1 102.02,39.25 101.6,39.67 101.6,40.14 101.56,40.18
RTC_VCC_C: length 10.2
  TOP w0.508: R2510.2 14.94,9.87 v1(14.94,8.79) 14.94,6.71 15.31,6.34 17.52,6.34 17.94,5.92 v2(17.94,5.45)
  BOTTOM w0.508: RTC1.1 17.21,3.92 17.95,4.66 17.95,5.44 v2(17.94,5.45)
RTCRST_ON: length 46.5
  TOP w0.102: v2(28.66,8.31) 28.79,8.18 28.79,6.28 27.14,4.62 v1(26.11,4.62) R2567.1 ; v2(18.31,3.68) 18.55,3.44 19.7,3.44 20.06,3.8 R2518.1
  L6 w0.102: v2(28.66,8.31) 28.66,8.72 28.29,9.09 28.29,14.15 27.84,14.6 27.84,15.8 27.01,16.62 27.01,18.68 26.68,19.01 26.68,19.37 27.91,20.6 27.91,24.05 27.19,24.76 v2(26.76,24.76)
  BOTTOM w0.102: v2(26.76,24.76) 27.09,25.1 29.36,25.1 30.68,26.41 30.68,26.83 30.57,26.94 U2401.31 ; v2(28.66,8.31) 28.66,7.81 27.52,6.66 26.89,6.66 24.48,4.26 24.3,4.26 24.05,4 24.05,3.82 23.01,2.79 21.67,2.79 20.75,3.7 Q2507.G 18.34,3.7 v2(18.31,3.68)
RUNPWROK: length 1.9
  BOTTOM w0.203: R2482.2 34.15,20.27 U2401.48
SATA_PCIE_LED#: length 13.4
  TOP w0.127: D6401.3 20.9,72.35 20.38,72.35 19.88,72.85 18.78,72.85 18.52,72.59 18.52,71.37 v1(16.91,69.76) 16.31,69.16 15.05,69.16 14.84,69.37 14.06,69.37 13.77,69.09 11.67,69.09 11.15,69.6 Q6403.S
SD_1P8_SEL: length 2.3
  BOTTOM w0.127: R3326.1 10.71,11.07 v1(10.68,11.1) 9.94,11.84 U3301.1
SD_CD_N: length 165
  L3 w0.127: v2(3.2,16.87) 3.2,16.99 2.76,17.43 2.39,17.43 1.47,16.51 1.47,7.75 2.12,7.09 4.38,7.09 4.54,7.26 6.57,7.26 8.07,8.76 8.07,9.44 8.83,10.2 10.55,10.2 13.42,13.08 14.75,13.08 17.07,15.39 17.07,16.19 18.42,17.54 20.19,17.54 21.09,18.43 23.72,18.43 24.44,17.72 27.66,17.72 27.89,17.95 27.89,18 28.6,18.71 36.76,18.71 36.85,18.8 42.81,18.8 42.82,18.79 59.01,18.79 60.1,17.69 73.47,17.69 73.72,17.44 94.44,17.44 94.49,17.39 110.95,17.39 115.58,22.02 115.58,29.92 114.47,31.04 114.47,33.58 113.3,34.75 113.3,36.8 111.42,38.68 111.42,42.15 v2(108.92,44.64)
  BOTTOM w0.127: v2(108.92,44.64) 108.92,44.64 108.92,44.64 108.47,44.19 CPU1.CH35 ; U3301.15 5.98,14.8 5.81,14.96 5.81,15.96 5.36,16.41 4.1,16.41 v1(3.77,16.74) 3.64,16.87 v2(3.2,16.87)
SD_CLK: length 148
  L3 w0.127: v2(110.16,41.83) 110.91,41.07 110.91,37.84 111.12,37.63 111.12,37.28 112.77,35.64 112.77,34.56 113.96,33.37 113.96,30.83 115.07,29.71 115.07,22.24 110.74,17.9 94.7,17.9 94.65,17.94 73.93,17.94 73.68,18.2 72.49,18.2 71.64,19.05 62.88,19.05 62.63,19.3 46.65,19.3 45.7,20.25 41.57,20.25 40.45,21.37 36.06,21.37 35.21,20.52 28.38,20.52 27.79,19.93 23.54,19.93 22.55,18.94 20.75,18.94 19.93,18.12 16.9,18.12 16.14,18.89 13.81,18.89 11.67,16.75 11.67,12.38 10.12,10.83 6.53,10.83 4.94,9.24 4.94,8.29 v2(4.19,7.54)
  BOTTOM w0.127: CPU1.CK36 109.83,43.38 109.83,42.73 110.16,42.4 v2(110.16,41.83) ; v2(4.19,7.54) 4.44,7.54 R3316.1
SD_CLK_R: length 5.2
  BOTTOM w0.127: U3301.6 7.67,10.98 v1(7.57,10.89) 7.49,10.89 5.59,8.98 C3313.1 5.15,8.03 R3316.2
SD_CMD: length 150.8
  L3 w0.127: v2(108.88,41.89) 108.88,42.08 109.5,42.7 109.91,42.7 111.17,41.45 111.17,37.94 111.38,37.73 111.38,37.39 113.02,35.75 113.02,34.67 114.21,33.48 114.21,30.93 115.33,29.82 115.33,22.13 110.84,17.65 94.59,17.65 94.55,17.69 73.83,17.69 73.57,17.95 72.38,17.95 71.53,18.8 66.93,18.8 66.18,18.05 60.1,18.05 59.11,19.04 46.49,19.04 45.54,19.99 41.68,19.99 41.47,19.99 40.35,21.11 36.17,21.11 35.32,20.26 28.49,20.26 27.9,19.67 23.64,19.67 22.66,18.69 20.86,18.69 20.04,17.87 18.39,17.87 15.93,15.41 15.83,15.41 15.2,14.78 15.2,13.96 14.57,13.33 13.1,13.33 10.28,10.51 7.62,10.51 7.49,10.38 7.49,9.45 7.32,9.29 7.11,9.29 6.98,9.41 6.98,10.38 6.85,10.51 6.6,10.51 5.87,9.78 5.87,8.42 6.16,8.14 6.82,8.14 v2(7.47,8.78)
  BOTTOM w0.076: CPU1.CH36 108.88,42.61
  BOTTOM w0.127: 108.88,42.61 v2(108.88,41.89) ; v2(7.47,8.78) 8,8.78 R3315.1
SD_CMD_R: length 2.2
  BOTTOM w0.127: U3301.4 8.47,10.35 8.24,10.12 8.24,9.88 R3315.2
SD_PWR_EN#: length 149.3
  L3 w0.127: v2(12.46,10.27) 13.5,10.27 15.61,12.38 20.85,12.38 22.85,14.38 22.85,15.77 23.78,16.7 29.54,16.7 30.43,17.59 34.37,17.59 35.6,16.37 36.89,16.37 38.13,17.62 38.31,17.62 38.48,17.78 42.39,17.78 42.4,17.77 43.04,17.77 44.13,16.68 73.04,16.68 73.3,16.42 94.02,16.42 94.07,16.38 111.61,16.38 113.01,17.78 114.5,17.78 115.38,18.67 115.38,20.19 116.6,21.41 116.6,30.6 115.48,31.71 115.48,34.01 115.32,34.17 115.32,36.78 v2(115.64,37.1)
  BOTTOM w0.127: CPU1.BW36 103.5,43.43 103.5,43.22 103.87,42.85 103.87,41.21 104.43,40.66 104.43,38 105.83,36.59 111,36.59 112.14,37.74 115.23,37.74 v1(115.27,37.78) 115.45,37.78 115.64,37.59 v2(115.64,37.1) ; R3329.1 12.53,11.03 12.54,11.02 R3325.2 12.54,10.35 v2(12.46,10.27)
SD_PWR_EN#_R: length 2.2
  BOTTOM w0.127: U3301.32 11.02,12.4 v1(11.25,12.63) 11.67,12.21 R3329.2
SD_RCOMP: length 3.3
  TOP w0.305: v2(110.01,45.52) 110.06,45.52 R1901.1
  TOP w0.356: v1(111.52,45.98) 111.41,46.09 R1901.1
  BOTTOM w0.305: v2(110.01,45.52) 109.96,45.52 109.65,45.21 CPU1.CK33 109.83,44.89 110.29,44.89 CPU1.CM34
SD_SDATA0: length 149.2
  L3 w0.127: v2(2.9,6.19) 3.24,6.53 5.32,6.53 5.49,6.37 7.54,6.37 8.53,7.35 9.15,7.35 10.44,8.63 10.44,9.27 13.73,12.57 15.05,12.57 17.58,15.1 17.58,15.98 18.5,16.9 21.61,16.9 21.86,17.14 23.22,17.14 23.28,17.2 23.57,17.2 23.57,17.21 28.27,17.21 29.19,18.13 38.1,18.13 38.26,18.29 42.6,18.29 42.61,18.28 43.39,18.28 44.48,17.18 73.25,17.18 73.51,16.93 94.23,16.93 94.28,16.88 111.4,16.88 112.8,18.29 113.87,18.29 114.61,19.03 114.61,20.14 116.09,21.62 116.09,30.13 114.98,31.25 114.98,33.8 113.81,34.96 113.81,37.02 113.3,37.53 113.3,39.63 v2(112.98,39.95)
  BOTTOM w0.127: v2(112.98,39.95) 112.79,39.77 v1(112.26,39.77) 110.79,41.23 110.79,42.37 110.4,42.77 110.4,43.02 110.47,43.09 110.47,43.39 110.06,43.8 CPU1.CL35 ; R3317.1 3.5,6.81 2.88,6.19 v2(2.9,6.19)
SD_SDATA0_R: length 5.9
  BOTTOM w0.127: U3301.7 7.27,11.1 5.55,9.38 5.55,9.3 4.7,8.45 4.47,8.45 3.78,7.76 R3317.2
SD_SDATA1: length 149.6
  L3 w0.127: v2(110.29,40.8) 110.66,40.43 110.66,37.73 110.87,37.52 110.87,37.14 112.51,35.5 112.51,33.02 113.71,31.83 113.71,30.72 114.82,29.61 114.82,22.34 110.63,18.15 94.8,18.15 94.76,18.2 74.04,18.2 73.78,18.45 72.59,18.45 71.74,19.3 67.09,19.3 66.74,19.66 46.64,19.66 45.8,20.5 41.68,20.5 40.56,21.62 35.96,21.62 35.11,20.77 28.27,20.77 27.69,20.18 23.7,20.18 23.43,20.18 22.45,19.19 20.57,19.19 20.24,18.86 19.67,18.86 19.39,19.14 12.83,19.14 11.42,17.73 11.42,12.49 10.01,11.09 6.43,11.09 3.27,7.93 v2(1.91,7.93)
  BOTTOM w0.127: CPU1.CL36 110.17,42.69 110.58,42.29 110.58,41.08 v2(110.29,40.8) ; v2(1.91,7.93) 1.91,7.45 2.47,6.9 R3318.1
SD_SDATA1_R: length 6.3
  BOTTOM w0.127: R3318.2 2.74,7.76 3.16,8.18 3.84,8.18 4.37,8.71 4.43,8.71 v1(4.65,8.92) 5.29,9.57 5.29,9.59 6.87,11.16 U3301.8
SD_SDATA2: length 146.7
  L3 w0.127: v2(8.78,7.88) 8.78,8.32 10.4,9.95 10.65,9.95 13.53,12.82 14.86,12.82 17.33,15.29 17.33,16.08 18.39,17.15 21.33,17.15 22.21,18.03 22.58,18.03 23.15,17.46 23.46,17.46 23.47,17.46 28.16,17.46 29.08,18.38 29.09,18.38 29.16,18.46 38.07,18.46 38.16,18.54 42.71,18.54 42.72,18.53 49.25,18.53 50.34,17.44 53.42,17.44 53.55,17.56 53.55,18.15 53.68,18.28 53.93,18.28 54.06,18.15 54.06,17.56 54.19,17.44 54.44,17.44 54.57,17.56 54.57,18.15 54.69,18.28 54.95,18.28 55.08,18.15 55.08,17.56 55.2,17.44 55.46,17.44 55.58,17.56 55.58,18.15 55.71,18.28 55.96,18.28 56.09,18.15 56.09,17.56 56.22,17.44 56.47,17.44 56.6,17.56 56.6,18.15 56.73,18.28 56.98,18.28 57.11,18.15 57.11,17.56 57.23,17.44 73.36,17.44 73.62,17.18 94.34,17.18 94.38,17.14 111.05,17.14 115.84,21.92 115.84,30.03 114.72,31.14 114.72,33.69 113.55,34.86 113.55,36.91 113.04,37.42 113.04,39.26 112.01,40.3 v2(112.01,40.99)
  BOTTOM w0.127: v2(112.01,40.99) 111.23,41.77 111.23,42.55 111.04,42.74 111.04,43.24 110.58,43.7 CPU1.CM35 ; v2(8.78,7.88) 8.91,7.88 v1(9.34,8.31) 9.88,8.86 R3319.1
SD_SDATA2_R: length 2
  BOTTOM w0.127: R3319.2 9.88,10.55 9.27,11.17 U3301.2
SD_SDATA3: length 146.9
  L3 w0.127: v2(111.96,41.93) 113.55,40.34 113.55,37.63 114.06,37.12 114.06,35.07 115.23,33.9 115.23,31.35 116.34,30.24 116.34,21.52 115.13,20.3 115.13,18.97 114.19,18.04 112.91,18.04 111.5,16.63 94.17,16.63 94.13,16.67 73.4,16.67 73.15,16.93 44.24,16.93 43.14,18.03 42.51,18.03 42.5,18.04 38.37,18.04 38.21,17.87 38.03,17.87 36.78,16.62 35.7,16.62 34.48,17.85 29.57,17.85 28.68,16.96 23.68,16.96 23.67,16.95 23.54,16.95 23.37,16.78 21.86,16.78 21.72,16.64 18.6,16.64 17.83,15.87 17.83,15.21 17.83,14.93 17.83,13.73 16.94,12.84 15.67,12.84 15.15,12.31 13.88,12.31 11.93,10.37 11.93,9.07 11.65,8.79 11.65,7.63 10.87,6.85 v2(8.78,6.85)
  BOTTOM w0.127: CPU1.CN35 111.49,43.87 111.49,43.21 111.67,43.03 111.67,42.76 111.66,42.75 111.66,42.23 v2(111.96,41.93) ; v2(8.78,6.85) 8.78,7.03 8.27,7.54 8.27,8.3 8.92,8.95 R3320.1
SD_SDATA3_R: length 1.8
  BOTTOM w0.127: R3320.2 8.87,10.06 v1(8.87,10.9) U3301.3
SD_WP: length 148
  L3 w0.127: v2(4.22,20.57) 8.21,20.57 8.73,21.1 11.28,21.1 12.98,19.4 19.28,19.4 20.71,20.83 25.87,20.83 25.88,20.82 26.25,20.82 26.27,20.83 26.82,20.83 27.21,20.44 27.58,20.44 28.17,21.03 35,21.03 35.85,21.88 40.66,21.88 41.78,20.76 46.25,20.76 47.03,19.97 66.78,19.97 67.2,19.56 71.85,19.56 72.17,19.23 90.32,19.23 90.47,19.08 105.22,19.08 105.73,18.57 110.69,18.57 114.57,22.45 114.57,29.5 113.45,30.62 113.45,31.72 112.26,32.92 112.26,35.4 110.62,37.04 110.62,37.42 110.19,37.84 110.19,40.24 109.82,40.6 109.82,41.28 v2(109.62,41.48)
  BOTTOM w0.076: CPU1.CK34 109.29,44.24 108.91,44.24 108.75,44.08 108.75,43.88 108.78,43.22 108.81,43.13 108.85,43.08 109.22,42.77
  BOTTOM w0.127: v2(4.22,20.57) 4.22,19.75 R3331.2 3.53,18.32 R3332.1 3.95,17.78 3.95,17.16 4.45,16.66 5.49,16.66 6.31,15.85 U3301.16 ; v2(109.62,41.48) 109.62,41.72 109.26,42.08 109.26,42.73 109.22,42.77
SIO_EXT_SCI#: length 12.7
  BOTTOM w0.076: CPU1.CP8 112.36,61.38 112.37,61.38 112.43,61.4 112.65,61.4 112.66,61.39
  BOTTOM w0.089: 112.66,61.39 114.05,61.39 114.87,62.21 115.58,62.21 116.01,62.64 v1(121.62,62.64) 122.56,62.64 123.45,63.53 R1608.2
SIO_EXT_SMI#: length 12.8
  BOTTOM w0.102: R402.2 123.6,64.55 122.7,63.65 122.7,63.39 v1(122.68,63.39) 122.38,63.09 121.23,63.09 121.19,63.04 115.07,63.04 113.81,61.78 CPU1.CP7
SIO_EXT_WAKE#: length 160.9
  TOP w0.102: v1(21.35,18.89) 21.78,18.45 21.78,17.93 22.13,17.58 v2(22.39,17.58) ; v2(114.9,58.27) 114.96,58.21 115.29,58.21 R2041.2
  L5 w0.102: v2(118.87,24.88) 118.87,24.89 119.27,25.28 119.27,28.7 119.39,28.82 119.39,29.18 119.39,29.18 119.39,30.83 120.79,32.23 120.79,40.79 121.82,41.81 121.82,45.96 120.5,47.27 120.5,52.72 121.4,53.62 121.4,54.64 120.93,55.1 120.93,56.75 119.41,58.27 v2(114.9,58.27)
  L8 w0.102: v2(22.39,17.58) 23.49,16.49 27.87,16.49 29.25,15.1 32.31,15.1 33.45,16.24 37.16,16.24 37.62,15.78 39.4,15.78 39.83,16.22 72.71,16.22 73.56,15.37 95.3,15.37 96.03,14.64 107.45,14.64 108.23,15.42 114.86,15.42 118.2,18.76 118.2,24.21 v2(118.87,24.88)
  BOTTOM w0.076: CPU1.CN12 111.51,58.34 112.09,58.34 112.16,58.27 arc(112.41,58.09) 112.71,58.02 114.75,58.02
  BOTTOM w0.102: v2(22.39,17.58) 19.17,20.81 18.89,20.81 18.48,21.21 18.16,21.21 17.9,21.47 U2401.116 ; v2(114.9,58.27) 114.9,58.17 114.75,58.02
SIO_PWRBTN#: length 117.2
  TOP w0.102: TP1714.1 102.56,48.25 v2(102.45,48.25)
  L8 w0.102: v2(102.45,48.25) 101.99,47.79 101.99,47.37 102.04,47.32 102.04,46.66 102.6,46.09 102.6,45.17 105.5,42.28 105.5,39.58 107.33,37.75 108.19,37.75 109.23,36.71 109.23,35.67 111.63,33.27 111.75,33.27 112.67,32.35 112.67,31.03 112.5,30.87 112.5,27.02 112.41,26.92 112.41,20.31 110.27,18.17 76.22,18.17 75.42,18.96 71.2,18.96 70.68,19.49 64.02,19.49 63.49,20.02 44.32,20.02 44.22,20.11 41.51,20.11 40.68,19.28 36.8,19.28 36.21,19.87 35.82,19.87 v2(35.39,19.44)
  BOTTOM w0.102: U2401.52 33.7,18.67 v1(33.81,18.78) 34.02,18.78 34.29,19.05 35.01,19.05 v2(35.39,19.44) ; CPU1.BU28 102.22,48.49 102.45,48.26 v2(102.45,48.25)
SIO_RCIN#: length 19.4
  TOP w0.089: R1820.2 115.7,36.45 114.88,36.45 113.37,37.96 113.37,38.44 110.63,41.19 110.63,42.42 110,43.05 107.25,43.05 105.68,44.62 v1(105.68,45.78) 105.21,45.78 105.21,45.79 105.07,45.79 104.83,46.02 104.83,46.38 103.68,47.54 v2(103.32,47.54)
  BOTTOM w0.089: v2(103.32,47.54) 103.02,47.84 CPU1.BV29
SKTOCC#: length 9.7
  BOTTOM w0.102: TP619.1 64.35,64.3 65.13,65.08 65.13,65.08 66.46,66.42 69.88,66.42 70.14,66.16 70.14,65.61 CPU1.E1
SM_INTRUDER#: length 26.6
  BOTTOM w0.076: CPU1.BR35 100.63,43.91 100.52,43.78 100.52,43.22 100.45,43.02 100.45,41.6 100.58,41.47
  BOTTOM w0.102: R1730.2 116.28,37.74 116.28,36.9 115.27,35.88 111.14,35.88 109.32,34.06 103.64,34.06 102.46,35.25 102.46,35.86 v1(101.4,36.92) 101.13,37.19 101.13,38.33 101.05,38.41 101.05,38.99 100.65,39.39 100.64,39.39 100.41,39.63 100.41,40.28 100.58,40.46 100.58,41.47
SM_PGCNTL: length 18.9
  BOTTOM w0.076: 66.19,42.31 66.77,42.31 67.53,43.07 67.53,43.48 67.71,43.66 67.9,43.66 68.1,43.85 68.79,43.85 CPU1.C35
  BOTTOM w0.254: Q501.G 53.38,37.57 v1(55.88,37.57) 58.51,37.57 62.04,41.1 64.97,41.1 66.19,42.31
SM_RCOMP_0: length 0.6
  BOTTOM w0.305: CPU1.BN28 99.02,48.25 98.83,48.25 98.79,48.21 v2(98.79,48.21)
SM_RCOMP_1: length 0.5
  BOTTOM w0.305: CPU1.BN27 99.53,49.41 v2(99.53,49.58)
SM_RCOMP_2: length 0.6
  BOTTOM w0.305: v2(98.81,47.58) 98.83,47.58 98.95,47.71 99,47.71 99.14,47.84 CPU1.BN29
  vias: v1(100.98,47.34)
SMBC_THERM_NV: length 39.8
  TOP w0.102: v2(143.01,52.81) v1(143.96,51.87) 145.33,50.5 148.38,50.5 148.72,50.16 155.04,50.16 157.32,52.44 159.6,52.44 160.73,51.32 160.73,51.06 162.34,49.45 162.77,49.45 162.93,49.6 v2(163.85,49.6) ; Q7901.4 136.91,52.29 v2(137.35,52.74)
  L5 w0.102: v2(143.01,52.81) 143.01,52.92 142.69,53.25 137.86,53.25 v2(137.35,52.74)
  BOTTOM w0.102: v2(163.85,49.6) 163.88,49.63 163.88,51.1 162.99,51.99 162.99,52.09 162.56,52.51 162.56,52.74 162.32,52.98 162.32,53.1 161.21,54.21 161.21,54.21 160.44,54.98 GPU1.D9 ; v2(137.35,52.74) 137.7,53.08 RN7901.4
SMBD_THERM_NV: length 30.7
  TOP w0.102: v2(159.34,53.84) 157.58,53.84 156.81,53.07 156.8,53.07 156.56,52.83 156.56,52.82 155.26,51.53 154.74,51.53 153.94,50.73 145.78,50.73 143.26,53.25 142.79,53.25 v2(142.36,52.81) ; Q7901.1 138.94,50.46 138.94,49.69 v2(138.82,49.57)
  L3 w0.102: v2(138.82,49.57) 139.25,49.57 142.36,52.68 v2(142.36,52.81)
  BOTTOM w0.102: GPU1.D8 159.34,53.84 v2(159.34,53.84) ; RN7901.3 139.07,52.62 139.46,52.23 v1(139.46,52.18) 139.81,51.84 139.81,50.53 138.85,49.57 v2(138.82,49.57)
SPI_CLK_CPU: length 105.3
  TOP w0.089: v1(178.27,23.78) 178.05,24 v2(178.05,24.69) ; R9138.1 179.06,30.18 178.81,30.43 177.6,30.43 v2(177.46,30.58)
  L6 w0.089: v2(108.41,42.32) 107.42,42.32 107.07,41.97 107.07,41.25 106.44,40.62 106.44,40.15 106.35,40.06 105.41,40.06 105.32,39.97 105.32,39.68 105.41,39.59 106.35,39.59 106.44,39.5 106.44,37.95 106.96,37.43 107.31,37.43 109.55,35.19 113.29,35.19 117.05,31.43 118.4,31.43 119.28,32.32 123.54,32.32 123.99,32.77 124.08,32.77 124.56,32.77 124.96,32.37 124.96,32.01 125.18,31.79 125.18,27.79 126.3,26.68 126.3,26.25 v2(126.86,25.69) 126.86,25.5 127.3,25.06 128.59,25.06 129.22,25.7 137.88,25.7 139.38,24.2 139.38,23.99 141.08,22.29 151.38,22.29 151.59,22.09 153.15,22.09 154.68,23.62 157.81,23.62 158.1,23.33 161.49,23.33 161.97,23.81 164.04,23.81 164.64,23.21 170.74,23.21 171.76,24.23 172.99,24.23 173.11,24.35 177.71,24.35 v2(178.05,24.69)
  L8 w0.076: v2(178.05,24.69) 178.05,25.02 179.03,26 179.03,29 v2(177.46,30.58)
  BOTTOM w0.089: EC2501.1 126.74,25.81 v2(126.86,25.69) 126.99,25.69 127.44,26.14 128.01,26.14 R2508.2 ; v2(108.41,42.32) 108.41,42.34 108.45,42.38 108.45,42.86 CPU1.CH37
SPI_CLK_PD: length 11.6
  BOTTOM w0.089: v1(36.73,69.25) 36.37,68.89 U7202.6 34.62,68.89 34.4,68.67 34.4,67.72 33.32,66.65 32.93,66.65 31.71,66.65 31.56,66.8 29.56,66.8 29.07,66.31 29.07,66.17 28.38,65.49 28.38,65.26 28.08,64.95 U7201.A3
SPI_CLK_ROM: length 2.7
  BOTTOM w0.089: v1(128.33,27.25) 129.06,26.51 R2508.1 129.56,26.82 BIOS1.6
SPI_CLK_ROM_TPM: length 2.2
  TOP w0.089: U9101.19 181.71,29.66 181.18,30.19 v1(181.12,30.19) 180.22,30.19 R9138.2
SPI_CS2#_IC: length 5.9
  TOP w0.089: U9101.20 181.54,29.16 181.16,29.55 178.76,29.55 R9130.2 178.37,29.05 v1(178.38,29.04) 177.59,29.04 R9148.2
SPI_CS_CPU_N0: length 43.4
  L6 w0.089: v2(107.87,41.45) 107.87,41.03 109.12,39.78 109.92,39.78 112.08,37.62 113.54,37.62 114.49,36.67 117.96,36.67 118.92,35.7 118.92,35.34 119.87,34.38 121.26,34.38 121.87,34.99 125.75,34.99 127.39,33.35 127.39,30.93 129.9,28.42 131.46,28.42 132.27,27.62 133.88,27.62 134.3,27.2 135.18,27.2 v2(135.55,27.57)
  BOTTOM w0.089: R2519.2 137.09,30.94 v1(137.09,30.61) 137.09,29.47 BIOS1.1 136.29,29.36 136.14,29.22 136.14,28.16 v2(135.55,27.57) ; v2(107.87,41.45) 107.87,41.51 107.63,41.76 107.63,43.08 CPU1.CG36
SPI_CS_CPU_N2: length 109.1
  TOP w0.089: R9130.1 v2(176.71,29.93) ; R9118.2 182.98,33 v1(181.72,33) v2(180.89,33)
  L6 w0.089: v2(108.76,41.03) 108.76,40.91 109.4,40.26 110.16,40.26 110.29,40.26 111.92,38.64 114.65,38.64 115.11,38.18 119.39,38.18 120.04,37.54 122.48,37.54 123.4,36.62 126.42,36.62 129.11,33.93 130.05,33.93 130.75,33.23 130.75,33.11 129.98,32.34 129.98,32.21 130.18,32.01 130.31,32.01 131.08,32.78 131.21,32.78 131.41,32.57 131.41,32.44 130.64,31.67 130.64,31.55 130.85,31.34 130.97,31.34 131.74,32.11 131.87,32.11 134.23,29.75 136.99,29.75 139.2,27.54 139.2,27.5 139.66,27.04 139.66,25.63 140.66,24.62 141.14,24.62 141.81,24.62 141.89,24.54 141.89,23.82 141.98,23.74 142.28,23.74 142.36,23.82 142.36,24.54 142.45,24.62 145.85,24.62 145.94,24.54 145.94,23.92 146.03,23.83 146.32,23.83 146.41,23.92 146.41,24.54 146.5,24.62 153.74,24.62 154.56,25.44 155.13,25.44 155.14,25.45 157.12,25.45 157.51,25.06 160.03,25.06 160.79,25.83 161.58,25.83 162.33,25.08 163.24,25.08 164.3,26.15 165.7,26.15 165.75,26.09 169.54,26.09 170.46,27.02 173.89,27.02 173.98,26.93 173.98,26.2 174.07,26.11 174.36,26.11 174.45,26.2 174.45,26.93 174.54,27.02 175.1,27.02 175.62,27.54 175.74,27.54 176.31,26.97 176.43,26.97 176.64,27.18 176.64,27.31 176.08,27.87 176.08,27.99 177.03,28.94 179.15,28.94 179.35,29.14 179.35,29.98 179.21,30.11 176.89,30.11 v2(176.71,29.93)
  BOTTOM w0.076: v2(108.76,41.03) 108.76,41.39 108.02,42.13 108.02,42.82 108.15,42.98 108.19,43.07 108.19,43.29 108.17,43.49 108.17,43.6 108.19,43.8 108.19,43.98 108.17,44.13 108.17,44.3 CPU1.CH34
  BOTTOM w0.089: v2(180.89,33) 179.6,33 178.23,31.63 177.89,31.63 176.71,30.45 v2(176.71,29.93)
