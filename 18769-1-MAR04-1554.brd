# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DN1: length 20.8
  TOP w0.14: v3(92.74,28.47) 92.43,28.07 RAM3.P11
  L3 w0.114: v3(92.74,28.47) 92.81,28.47 93.25,28.91 93.25,29.83 92.13,30.95 91.9,30.95 89.7,33.16 89.7,34.11 89.93,34.34 89.93,34.81 89.37,35.38 89.37,36.51 89.73,36.88 v3(90.01,36.88)
  BOTTOM w0.076: 90.42,40.47 90.42,40.48 90.45,40.5 90.45,40.55 90.46,40.57 90.46,40.62 90.13,40.95 89.81,40.95 89.48,41.28 89.48,42.4 89.75,42.67 89.75,43 89.72,43.08 89.72,43.36 89.73,43.39 89.75,43.45 89.75,44.12 CPU1.AV34
  BOTTOM w0.127: v3(90.01,36.88) 90.42,36.88 90.79,37.25 90.79,38.63 90.42,39 90.42,40.47
M_B_DQS_DN2: length 23
  TOP w0.14: v3(86.25,27.68) 86.25,27.97 86.15,28.07 85.93,28.07 RAM3.D11
  L8 w0.114: v3(86.11,46.21) 85.88,45.97 85.88,43.49 85.42,43.04 85.42,35.29 84.92,34.79 84.92,32.83 84.68,32.59 84.37,32.59 84.26,32.47 84.26,32.24 84.37,32.13 84.68,32.13 84.92,31.89 84.92,31.48 84.68,31.24 84.37,31.24 84.26,31.13 84.26,30.9 84.37,30.78 84.68,30.78 84.92,30.54 84.92,29.26 85.61,28.57 85.65,28.4 85.78,28.27 86.15,28.27 86.25,28.17 v3(86.25,27.68)
  BOTTOM w0.14: v3(86.11,46.21) 85.8,46.15 85.65,46.25 CPU1.AL31
M_B_DQS_DN3: length 22
  TOP w0.127: v3(90.82,28.46) 90.75,28.52 90.36,28.52 90.23,28.4 90.23,28.19 90.35,28.07 RAM3.L11
  L8 w0.114: v3(89.73,46.91) 89.48,46.91 89.38,46.81 89.38,45.33 89.89,44.82 89.89,43.15 90.68,42.37 90.68,34.37 90.8,34.25 90.8,33.39 90.56,33.15 90.37,33.15 90.25,33.04 90.25,32.81 90.37,32.69 90.56,32.69 90.8,32.45 90.8,28.48 v3(90.82,28.46)
  BOTTOM w0.14: CPU1.AU31 89.28,46.83 89.44,46.95 v3(89.73,46.91)
M_B_DQS_DN4: length 28.4
  TOP w0.127: 106.75,28.21 106.89,28.07 RAM4.G11
  TOP w0.14: 106.75,28.21 v3(106.75,28.48)
  L3 w0.114: v3(106.75,28.48) 106.75,28.24 106.65,28.14 106.46,28.14 106.23,28.37 106.23,30.46 105.99,30.7 99.24,30.7 95.54,34.4 95.54,35.71 95.37,35.89 95.37,36.57 95.26,36.67 95.1,36.67 v3(94.94,36.5)
  BOTTOM w0.076: CPU1.BB35 92.67,43.62 92.79,43.5 92.89,43.4 92.92,43.32 92.92,43.14 92.9,43.05 92.89,42.99 92.89,42.61 93.83,41.67 93.83,41.2 93.84,41.19
  BOTTOM w0.127: 93.84,41.19 93.84,38.18 94.45,37.56 95.15,37.56 95.17,37.54
  BOTTOM w0.14: v3(94.94,36.5) 95.17,36.27 95.34,36.27 95.44,36.37 95.44,37.27 95.17,37.54
M_B_DQS_DN5: length 29.9
  TOP w0.127: RAM4.P11 111.61,28.17 v3(111.91,28.47)
  L3 w0.114: v3(111.91,28.47) 111.73,28.29 111.59,28.29 111.48,28.41 111.48,28.88 111.21,29.14 111.21,30.59 107.72,34.08 102.27,34.08 101.79,34.56 101.79,36.3 101.4,36.69 100.7,36.69 100.59,36.81 100.59,37.13 100.35,37.37 99.94,37.37 99.7,37.13 99.7,36.81 99.58,36.69 99.13,36.69 98.38,37.44 98.38,37.65 98.13,37.9 98.13,39.78 97.69,40.22 97.26,40.22 v3(97.09,40.38)
  BOTTOM w0.076: 96.44,41.36 96.43,41.37 96.39,41.37 95.84,41.92 95.84,42.43 95.58,42.69 95.58,42.97 95.62,43.12 95.62,43.35 95.56,43.5 95.45,43.61 95.45,43.95 95.39,44.07 95.18,44.28 CPU1.BF34
  BOTTOM w0.127: v3(97.09,40.38) 96.8,40.38 96.67,40.51 96.67,41.13 96.44,41.36
M_B_DQS_DN6: length 29.5
  TOP w0.14: v3(104.79,28.45) 104.79,28.45 104.79,28.45 105.09,28.52 105.26,28.52 105.37,28.42 105.37,28.17 105.26,28.07 105.11,28.07 RAM4.D11
  L8 w0.114: v3(104.79,28.45) 104.79,28.45 104.79,28.45 104.8,28.26 104.7,28.15 104.55,28.14 104.28,28.33 104.24,28.48 104.24,29.36 103.5,30.1 99.41,30.1 97.96,31.54 97.96,31.71 98.42,32.16 98.42,32.5 98.14,32.77 97.77,32.77 97.33,32.33 97.17,32.33 96.15,33.36 96.15,41.05 95.45,41.75 95.45,42.71 94.02,44.14 93.76,44.14 93.32,44.58 93.32,45.4 93.61,45.69 93.61,45.93 v3(93.39,46.15)
  BOTTOM w0.14: CPU1.BC31 92.97,46.21 93.17,46.1 v3(93.39,46.15)
M_B_DQS_DN7: length 30.6
  TOP w0.14: RAM4.L11 109.51,28.07 109.51,28.07 109.4,28.17 109.4,28.42 109.51,28.52 109.79,28.52 v3(110.02,28.47)
  L8 w0.114: v3(110.02,28.47) 109.73,28.76 109.73,31.29 107.02,33.99 103.38,33.99 102.16,35.21 102.16,37.23 101.52,37.86 101.52,39.02 101.64,39.14 102.3,39.14 102.54,39.38 102.54,39.78 102.29,40.03 101.64,40.03 101.52,40.14 101.52,41.6 100.64,42.48 100.64,42.59 100.29,42.94 99.78,42.94 97.7,45.02 97.32,45.91 97.32,46.3 97.5,46.48 97.5,46.81 97.4,46.91 97.06,46.91 v3(97.06,46.9)
  BOTTOM w0.14: CPU1.BH31 96.53,46.41 96.62,46.32 97.03,46.32 97.13,46.42 97.13,46.83 v3(97.06,46.9)
M_B_DQS_DP0: length 20
  TOP w0.14: v3(88.23,27.66) 87.88,27.27 RAM3.G10
  L3 w0.114: v3(88.23,27.66) 87.49,27.66 86.87,28.28 86.87,30.93 86.29,31.51 86.29,32.92 86.17,33.03 86.12,33.03 85.88,33.27 85.88,33.68 86.12,33.92 86.17,33.92 86.29,34.03 86.29,40.27 86.68,40.66 86.96,40.66 v3(87.17,40.87)
  BOTTOM w0.076: CPU1.AP34 87.45,44.2 87.31,43.82 87.27,43.63 87.24,43.45 87.21,43.39 87.2,43.36 87.2,43.08 87.26,42.94 87.26,42.09 87.57,41.78 87.57,41.09 87.45,40.98 v3(87.17,40.87)
M_B_DQS_DP1: length 20.8
  TOP w0.14: v3(92.74,27.66) 92.43,27.27 RAM3.P10
  L3 w0.114: v3(92.74,27.66) 92.74,27.77 93.13,28.16 93.13,28.48 93.47,28.82 93.47,29.92 92.22,31.17 91.99,31.17 89.92,33.25 89.92,34.02 90.15,34.25 90.15,34.9 89.58,35.47 89.58,35.83 v3(90.01,36.26)
  BOTTOM w0.076: CPU1.AV35 90.1,43.82 89.9,43.33 89.9,43.12 89.93,43.03 89.93,42.6 89.66,42.33 89.66,41.35 89.89,41.13 90.21,41.13 90.64,40.69 90.64,40.5 90.65,40.49 90.65,40.47
  BOTTOM w0.127: 90.65,40.47 90.65,39.1 91.02,38.73 91.02,37.16 90.65,36.79 90.65,36.39 90.52,36.26 v3(90.01,36.26)
M_B_DQS_DP2: length 23
  TOP w0.14: v3(85.61,27.69) 85.61,27.69 85.93,27.27 RAM3.D10
  L8 w0.114: v3(86.11,46.82) 85.66,46.37 85.66,43.58 85.21,43.13 85.21,35.38 84.71,34.88 84.71,32.92 84.59,32.8 84.28,32.8 84.04,32.56 84.04,32.15 84.28,31.91 84.59,31.91 84.71,31.8 84.71,31.57 84.59,31.46 84.28,31.46 84.04,31.21 84.04,30.81 84.28,30.57 84.59,30.57 84.71,30.45 84.71,29.17 85.42,28.46 85.46,28.29 85.46,28.29 85.6,27.72 85.6,27.7 v3(85.61,27.69)
  BOTTOM w0.14: v3(86.11,46.82) CPU1.AL30
M_B_DQS_DP3: length 21.9
  TOP w0.14: RAM3.L10 90.48,27.27 90.81,27.64 90.81,27.67 v3(90.82,27.67)
  L8 w0.114: v3(90.82,27.67) 90.74,27.67 90.43,28.19 90.43,28.72 90.58,29.04 90.58,32.36 90.47,32.48 90.28,32.48 90.04,32.72 90.04,33.13 90.28,33.37 90.47,33.37 90.58,33.48 90.58,34.16 90.46,34.28 90.46,42.28 89.68,43.06 89.68,44.73 89.16,45.24 89.16,46.47 v3(88.81,46.91)
  BOTTOM w0.14: CPU1.AU30 v3(88.81,46.91)
M_B_DQS_DP4: length 28.5
  TOP w0.14: v3(106.75,27.68) 107.06,27.27 RAM4.G10
  L3 w0.114: v3(94.94,35.91) 95.2,35.74 95.33,35.59 95.33,34.31 99.15,30.49 105.9,30.49 106.02,30.37 106.02,28.28 106.33,27.97 v3(106.75,27.68)
  BOTTOM w0.076: 94.06,41.19 94.06,41.25 94,41.31 94,41.74 93.06,42.68 93.06,42.97 93.1,43.12 93.1,43.35 93.04,43.5 92.97,43.67 92.94,43.9 92.91,44.03 CPU1.BB34
  BOTTOM w0.127: 95.37,37.75 95.34,37.79 94.55,37.79 94.06,38.27 94.06,41.19
  BOTTOM w0.14: 95.37,37.75 95.64,37.48 95.69,37.43 95.74,37.32 95.74,36.25 95.46,35.98 v3(94.94,35.91)
M_B_DQS_DP5: length 29.8
  TOP w0.127: v3(111.92,27.66) 111.92,27.58 RAM4.P10
  L3 w0.114: v3(111.92,27.66) 111.5,28.08 111.26,28.32 111.26,28.79 110.99,29.05 110.99,30.5 107.63,33.86 102.18,33.86 101.57,34.47 101.57,36.21 101.31,36.48 100.61,36.48 100.37,36.72 100.37,37.04 100.26,37.16 100.03,37.16 99.91,37.04 99.91,36.72 99.67,36.48 99.04,36.48 98.17,37.35 98.17,37.56 97.92,37.81 97.92,39.69 97.6,40 97.35,40 v3(97.09,39.75)
  BOTTOM w0.076: 96.28,41.19 96.27,41.21 96.27,41.24 95.66,41.85 95.66,42.36 95.4,42.61 95.4,42.99 95.44,43.14 95.44,43.32 95.4,43.4 95.18,43.62 CPU1.BF35
  BOTTOM w0.127: v3(97.09,39.75) 97.09,39.76 96.44,40.41 96.44,41.03 96.28,41.19
M_B_DQS_DP6: length 29.5
  TOP w0.127: RAM4.D10 104.81,27.57 v3(104.81,27.67)
  L8 w0.114: v3(93.37,46.77) 93.06,46.38 93.01,46.24 92.99,46.06 93.11,45.78 93.11,44.49 93.67,43.93 93.93,43.93 95.23,42.62 95.23,41.66 95.94,40.96 95.94,33.27 97.08,32.12 97.42,32.12 97.86,32.56 98.05,32.56 98.2,32.41 98.2,32.25 97.75,31.79 97.75,31.45 99.32,29.88 103.41,29.88 104.02,29.27 104.02,28.45 104.1,28.21 104.38,27.99 104.41,27.97 104.83,27.65 104.83,27.67 v3(104.81,27.67)
  BOTTOM w0.14: CPU1.BC30 v3(93.37,46.77)
M_B_DQS_DP7: length 30.6
  TOP w0.14: v3(109.99,27.68) 109.66,27.27 RAM4.L10
  L8 w0.114: v3(109.99,27.68) 109.76,28.12 109.63,28.3 109.51,28.42 109.51,31.2 106.93,33.77 103.29,33.77 101.94,35.12 101.94,37.14 101.31,37.77 101.31,39.11 101.55,39.35 102.21,39.35 102.33,39.47 102.33,39.69 102.21,39.81 101.55,39.81 101.31,40.06 101.31,41.51 100.43,42.39 100.43,42.5 100.2,42.72 99.69,42.72 97.51,44.9 97.11,45.87 97.11,46.28 96.73,46.66 96.67,46.81 96.67,47.03 96.72,47.19 96.98,47.57 v3(96.99,47.58)
  BOTTOM w0.14: CPU1.BH30 96.6,47.19 96.98,47.57 v3(96.99,47.58)
M_B_ODT0: length 70.4
  TOP w0.114: RAM4.J8 108.36,25.67 108.01,25.31 v3(108.01,25.23)
  TOP w0.152: RAM3.J8 88.83,25.32 v3(88.83,25.25) ; R1315.2 98.64,22.94 v2(99.87,24.17)
  L3 w0.114: v3(88.83,25.25) 89.35,24.72 95.43,24.72 96.32,25.61 96.32,26.28 96.47,26.42 97.39,26.42 97.5,26.31 97.5,25.5 98.83,24.17 v2(99.87,24.17) 99.87,24.41 99.55,24.74 99.09,24.74 98.81,25.02 98.81,26.02 99.42,26.63 100.21,26.63 100.32,26.51 100.32,26.35 100.13,26.16 100.13,26 100.3,25.84 100.46,25.84 100.67,26.06 100.84,26.06 101.85,25.04 104.69,25.04 105.17,24.57 107.34,24.57 v3(108.01,25.23)
  L5 w0.152: v2(99.87,24.17) 99.78,24.26 99.44,24.26 98.92,24.79 98.92,25.39 99.07,25.55 100.01,25.55 100.16,25.7 100.16,26 100.01,26.16 99.07,26.16 98.92,26.31 98.92,26.61 99.07,26.77 100.01,26.77 100.16,26.92 100.16,27.22 100.01,27.38 99.07,27.38 98.92,27.53 98.92,27.83 99.07,27.99 100.01,27.99 100.16,28.14 100.16,28.44 100.01,28.6 99.07,28.6 98.92,28.75 98.92,29.52 98.77,29.67 98.04,29.67 97.9,29.81 97.9,30.31 97.9,30.41 97.44,30.87 97.44,31.08 97.53,31.17 97.53,31.39 97.31,31.6 97.1,31.6 97.01,31.52 96.8,31.52 96.58,31.73 96.58,31.95 96.67,32.04 96.67,32.25 96.45,32.47 96.24,32.47 96.16,32.39 94.62,32.39 93.02,33.99 89.31,33.99 88.01,35.29 88.01,35.51 88.24,35.74 88.24,36.13 88.02,36.35 87.74,36.35 87.45,36.06 87.24,36.06 86.93,36.37 86.93,37.66 87.08,37.81 87.21,37.81 87.36,37.96 87.36,38.27 87.21,38.42 87.08,38.42 86.93,38.57 86.93,39.18 86.71,39.4 86.71,40.77 86.56,40.92 86.34,40.92 v3(85.85,40.43)
  BOTTOM w0.076: CPU1.AL36 86.05,43.26 86.05,42.68 85.98,42.61 85.98,42.21 86.24,41.95 86.24,40.82 v3(85.85,40.43)
M_VREF_CA_DIMMA: length 53
  TOP w0.127: 52.03,33.95 52.03,33.32 51.45,32.74 51.45,32.23 v3(51.44,32.22) ; 70.78,31.04 70.58,30.84 70.58,28.73 70.31,28.46 69.97,28.46 69.96,28.46
  TOP w0.254: 69.96,28.46 v3(69.95,28.46) ; 52.32,34.24 52.03,33.95
  TOP w0.305: v3(51.44,32.22) 51.13,31.91 51.13,31.81 RAM1.J11 ; v3(69.95,28.46) 70.26,28.14 RAM2.J11 ; 52.32,34.24 52.49,34.41 C1215.1
  TOP w0.508: v2(64.89,36.88) R1224.1 R1222.2 R1223.1 ; C1230.1 70.78,31.04
  L3 w0.508: v2(61.17,25.84) 61.58,26.24 61.58,27.11 63.53,29.06 63.53,34.01 v2(64.89,36.88)
  L5 w0.114: v3(69.95,28.46) 69.96,28.46 69.96,28.44 69.5,28.9 68.12,28.9 67.88,28.66
  L5 w0.508: v2(61.17,25.84) 61.17,25.03 62.53,23.68 63.83,23.68 64.61,24.46 66.14,24.46 66.7,25.02 66.7,26.62 67.88,27.8 67.88,28.66
  L6 w0.508: v3(51.44,32.22) 52.14,32.91 52.14,33.2 53.74,34.8 62.9,34.8 64.89,36.79 v2(64.89,36.88)
M_VREF_CA_DIMMB: length 71.5
  TOP w0.127: 88.63,30.33 89.51,29.45 89.51,28.67 89.29,28.45 88.87,28.45 ; 108.97,29.72 108.97,29.28 108.88,29.19 108.88,29.19 108.72,29.03 108.72,29.02 108.69,29 108.69,28.74 108.69,28.74 108.69,28.4 108.36,28.07 RAM4.J11
  TOP w0.254: 108.97,29.72 108.97,30 108.67,30.3 108.67,31.72 C1315.1 ; 108.36,28.07 108.68,27.75 v3(108.68,27.67) ; C1330.1 88.63,31.75 88.63,30.33
  TOP w0.305: RAM3.J11 89.18,28.14 v3(88.86,28.46)
  TOP w0.508: v2(65.55,36.29) 65.62,36.22 65.62,34.56 65.9,34.29 R1323.1 R1320.2 R1321.1
  L6 w0.305: v3(88.86,28.46) 88.88,28.46 89.47,29.05 89.47,29.55 88.74,30.28 88.13,30.28 87.77,30.64 87.31,30.64 86.55,31.4 85.18,31.4 84.16,32.42 v2(84.16,33.46)
  BOTTOM w0.305: v3(108.68,27.67) 108.68,29.92 107.6,31 100.89,31 98.44,33.46 v2(84.16,33.46) 79.52,33.46 79.29,33.23 68.61,33.23 v2(65.55,36.29)
MASK_BASE_LEDS#: length 7.1
  TOP w0.127: U6402.4 10.09,72.08 11.91,72.08 v2(12.02,71.97) 12.02,72.12 v1(12.49,72.59)
  BOTTOM w0.127: Q6404.2 Q6404.5 12.27,71.16 12.2,71.09 R6419.2 v2(12.02,71.97)
MASK_SATA_LED#: length 77.5
  TOP w0.102: v2(14.51,28.83) 14.33,29.01 v1(13.87,29.01) ; v2(13.97,69.99) 14.13,70.15 14.13,71.38 R6406.2 12.76,71.96 12.33,71.53 10.65,71.53 Q6403.G
  L3 w0.102: v2(14.51,28.83) 14.51,30.44 14.98,30.91 14.98,39.79 13.35,41.42 13.35,42.89 11.72,44.52 11.72,47.52 11.37,47.87 11.37,49.27 12.2,50.1 12.73,50.1 13.76,51.12 13.76,52.58 13.34,53 13.34,64.9 13.76,65.32 13.76,67.52 13.97,67.73 v2(13.97,69.99)
  L5 w0.102: v3(30.81,17.15) 30.6,17.36 26.48,17.36 24.57,19.27 24.57,20.14 23.56,21.16 23.56,21.62 23.06,22.12 23.06,22.68 20.1,25.64 20.1,26.7 19.02,27.77 19.02,28.89 18.73,29.17 18.38,29.17 17.91,28.71 17.91,28.09 17.39,27.56 15.78,27.56 v2(14.51,28.83)
  BOTTOM w0.102: v3(30.81,17.15) 31.59,17.15 31.67,17.07 U2401.56
MCARD_PCIE#_SATA: length 17.6
  TOP w0.102: v1(22.12,16.95) 22.28,16.78 v2(22.28,16.34) 22.06,16.11 RN2405.8
  BOTTOM w0.102: v2(22.28,16.34) 22.98,17.04 22.98,18.95 26.02,21.99 28.63,21.99 29.48,22.84 31.27,22.84 31.49,23.07 U2401.41 33.21,23.07 33.61,23.47 R1605.2
ME_FWP: length 186.6
  TOP w0.102: v2(160.62,23.88) 160.62,19.77 159.98,19.14 159.98,14.46 159.95,14.43 159.95,14.32 157.74,12.11 157.33,11.7 157.33,10.64 157.24,10.55 157.24,4.71 156.75,4.21 v3(156.75,3.69) ; FSW1.3 174.57,22.21 v2(175.29,22.94) R9806.1 ; v1(23.83,3.74) 23.91,3.82 v2(24.48,3.82)
  L3 w0.102: v2(175.29,22.94) 174.23,24 171.86,24 171.06,23.21 164.47,23.21 163.65,24.02 161.66,24.02 161.49,24.19 160.93,24.19 v2(160.62,23.88)
  L5 w0.102: v2(24.48,3.82) 24.48,11.12 v2(24.72,11.36)
  L8 w0.102: v2(24.48,3.82) 25.51,3.82 27.12,5.43 36.35,5.43 36.36,5.42 56.62,5.42 56.68,5.35 57.45,5.35 59.97,7.88 69.73,7.88 69.93,8.08 80.1,8.08 85.45,2.72 87.54,2.72 87.54,2.72 87.71,2.72 87.94,2.5 109.33,2.5 109.67,2.16 132.24,2.16 132.48,2.41 145.48,2.41 155.68,2.41 156.76,3.5 156.76,3.68 v3(156.75,3.69)
  BOTTOM w0.102: v2(24.72,11.36) 24.97,11.61 U2401.80
ME_FWP_SW: length 6.6
  TOP w0.102: FSW1.2 176,23.71 R9806.2 176.52,23.37 v1(176.52,21.48) 176.52,21 R1909.1
ME_SUS_PWR_ACK_R: length 25.8
  TOP w0.102: v3(103.38,45.37) 103.38,45.37 103.38,45.35 103.34,45.31 103.34,44.15 106.35,41.14 107.1,41.14 108.35,39.9 109.81,39.9 111.81,37.9 112.48,37.9 113.86,36.52 R1738.2 114.25,35.55 114.25,34.83 113.87,34.45 113.15,34.45 112.54,33.83 112.54,33.47 112.79,33.22 113.15,33.22 113.31,33.38 113.69,33.38 113.95,33.13 113.95,32.85 v1(114.35,32.45) 114.93,33.03 114.93,34.57 114.91,34.6 R1708.2
  BOTTOM w0.102: v3(103.38,45.37) 103.38,45.37 103.38,45.35 103.33,45.35 102.73,44.76 CPU1.BV34
MEC_XTAL1_R: length 4.7
  BOTTOM w0.089: X2401.1 13.81,24.49 C2425.1 14.75,24.15 15.42,24.15 15.43,24.14 15.79,24.14 15.8,24.15 16.07,24.15 16.19,24.27 U2401.123
MEC_XTAL2: length 4.6
  BOTTOM w0.089: X2401.2 14.07,25.1 C2424.1 14.49,25.18 R2461.1 15.34,25.07 U2401.125
MEM_CHA_EN: length 18.6
  TOP w0.102: v2(109.88,46.16) 109.88,46.16 109.88,46.16 109.59,45.87 109.59,45.37 109.84,45.11 111.92,45.11 112.84,46.03 112.84,46.03 113.72,46.91 113.72,47.93 113.86,48.08 113.86,48.56 114.23,48.93 115.14,48.93 v1(115.49,49.29) 115.92,48.86 118.24,48.86 118.78,48.33 121.11,48.33 v2(121.56,48.77)
  BOTTOM w0.102: R2030.1 120.83,48.8 121.53,48.8 v2(121.56,48.77) 121.58,48.79 R2031.2 ; CPU1.CJ31 109.41,46.54 109.79,46.16 v2(109.88,46.16)
MEM_CHB_EN: length 15.1
  TOP w0.102: v2(120.93,49.89) 117.31,49.89 116.93,50.27 112.64,50.27 v1(112.09,49.71) 111.64,49.26 110.33,49.26 109.84,48.77 v2(109.84,48.67)
  BOTTOM w0.102: v2(120.93,49.89) 120.93,49.91 ; 120.93,49.91 120.85,50 120.61,50 120.25,50.36 R2032.1 ; 120.93,49.91 121.38,50.36 R2033.2 ; CPU1.CJ27 109.39,49.14 109.84,48.69 v2(109.84,48.67)
MEM_CONFIG0: length 17.5
  TOP w0.102: v2(120.94,52.55) 119.19,50.8 117.72,50.8 117.44,51.08 111.61,51.08 110.81,50.27 v1(110.81,50.27) 110.61,50.07 109.16,50.07 v2(107.94,48.85)
  BOTTOM w0.102: v2(107.94,48.85) 107.94,48.87 107.67,49.14 CPU1.CF27 ; R2016.2 122.09,52.82 121.21,52.82 v2(120.94,52.55) 120.74,52.75 R2015.1
MEM_CONFIG1: length 19.7
  TOP w0.102: v2(107.91,47.55) 108.4,48.04 108.4,48.91 109.36,49.87 110.91,49.87 111.92,50.88 117.36,50.88 117.64,50.6 119.8,50.6 v2(121.54,52.34)
  BOTTOM w0.102: R2018.2 121.94,51.94 v2(121.54,52.34) 121.23,52.02 v1(121.23,51.61) 120.73,51.61 120.36,51.98 R2017.1 ; v2(107.91,47.55) 107.62,47.84 CPU1.CF29
MEM_CONFIG2: length 16.3
  TOP w0.102: v2(121.31,51.03) 121.18,51.03 120.54,50.39 117.38,50.39 117.1,50.67 112.26,50.67 111.25,49.66 109.73,49.66 109.61,49.54 109.59,49.54 v1(109.56,49.51) 109.56,49.49 v2(108.88,48.81)
  BOTTOM w0.102: CPU1.CH27 108.48,49.14 108.81,48.81 v2(108.88,48.81) ; R2029.2 121.37,51.15 121.3,51.08 121.3,51.03 ; 121.3,51.03 121.27,51.06 120.37,51.06 120.25,51.18 R2022.1 ; 121.3,51.03 v2(121.31,51.03)
MEM_CONFIG3: length 17.7
  TOP w0.102: v2(121.58,49.89) 121.15,50.32 120.76,50.32 120.63,50.19 117.29,50.19 117.01,50.47 112.34,50.47 111.33,49.46 110.06,49.46 109.44,48.83 109.44,48.72 v2(108.85,48.13) 109,48.13 v1(109.35,47.79)
  BOTTOM w0.102: R2011.2 121.89,49.58 v2(121.58,49.89) 121.15,49.46 120.45,49.46 R2012.1 ; v2(108.85,48.13) 108.49,48.49 CPU1.CH28
MEM_CONFIG4: length 25.8
  TOP w0.102: v2(124.52,46.58) 123.16,47.93 118.88,47.93 118.17,48.65 116.72,48.65 116.07,48.65 116.07,48.65 114.76,48.65 114.68,48.73 114.32,48.73 114.07,48.48 114.07,47.99 113.92,47.85 113.92,46.53 113.26,45.87 113.26,45.87 111.88,44.49 110.19,44.49 109.28,45.39 109.28,46.89 109.82,47.42 v2(109.82,47.42)
  BOTTOM w0.102: v2(109.82,47.42) 109.82,47.42 109.59,47.19 CPU1.CJ30 ; R2014.1 121.88,48.12 122.04,47.95 R2013.2 122.41,47.93 122.82,47.52 123.58,47.52 v1(124.03,47.07) v2(124.52,46.58)
MESW1_B: length 4.3
  TOP w0.102: FSW1.1 175.67,26.71 R9804.1 v1(176.09,26.19) 176.09,25.73 176.63,25.19 R9805.2
MIC2_VREFO_R: length 10.3
  TOP w0.203: v2(186.87,13.53) 186.24,13.53 186.01,13.76 186.01,13.77 185.68,14.09 185.68,14.09 185.61,14.16 U2701.23
  TOP w0.254: RN2901.2 190.02,12.62 v2(190.39,12.98) 190.69,12.68 RN2901.1
  L8 w0.254: v2(190.39,12.98) 189.68,13.69 187.69,13.69 187.53,13.53 v2(186.87,13.53)
  BOTTOM w0.203: v2(186.87,13.53) v1(186.87,10.82)
MIC_CAP: length 2.2
  TOP w0.203: U2701.15 182.51,12.33 182.48,12.3 182.48,11.51
  TOP w0.254: 182.48,11.51 182.48,10.75 C2715.1
MIC_GND: length 3.3
  TOP w0.305: R5512.1 52.43,79.25 52.79,79.61 v2(52.95,79.61)
  TOP w0.356: R5512.1 51.66,78.94 v1(51.41,79.19)
  BOTTOM w0.203: v2(52.95,79.61) 53.24,79.61 53.6,79.25 LCD1.38
MODEL_ID: length 5.1
  TOP w0.102: R2441.1 17.72,18.31 v1(17.72,17.55) ; R2441.1 17.59,19.18 C2407.1 ; R2441.1 18.5,18.44 v2(18.62,18.57) 18.99,18.57 R2442.2
  BOTTOM w0.102: U2401.109 18.52,18.67 v2(18.62,18.57)
MSATA_DEVSLP_R: length 10.8
  TOP w0.102: v2(120.46,27.62) 120.47,27.62 120.09,28 120.09,29.03 AFTP6301.1 119.65,29.46 118.48,29.46 R6301.2
  BOTTOM w0.102: SSD1.38 116.22,25.14 117.04,25.96 119.1,25.96 120.46,27.33 v2(120.46,27.62)
MUX_HPD_CON: length 3.5
  TOP w0.102: U7101.23 20.57,39.76 20.53,39.81 v1(20.53,39.87) 20.53,39.87 20.57,39.92 20.57,41.27 20.15,41.69 R7149.1
N12P_JTAG_TCK: length 11.4
  BOTTOM w0.102: GPU1.AE5 144.61,64.93 143.7,65.84 142.63,65.84 139.33,62.54 135.85,62.54 TP7906.1
N12P_JTAG_TDI: length 10.8
  BOTTOM w0.102: TP7905.1 139.64,63.3 143.14,66.81 143.63,66.81 144.52,65.92 144.97,65.92 145.36,65.53 GPU1.AE6
N12P_JTAG_TDO: length 11.6
  BOTTOM w0.102: TP7901.1 139.46,73.97 143.37,70.06 143.37,67.76 143.4,67.73 143.4,67.44 144.26,66.57 144.26,66.46 144.54,66.18 145.23,66.18 145.31,66.1
N12P_JTAG_TMS: length 8.2
  BOTTOM w0.102: GPU1.AD6 146.25,64.78 145.59,64.78 144.46,63.65 144.46,63.62 140.47,59.63 TP7902.1
N12P_JTAG_TRST: length 8.7
  BOTTOM w0.102: GPU1.AG4 142.63,65.46 138.72,61.55 v1(137.98,61.55) 137.53,61.55 R7912.1
N12P_XTAL_OUTBUFF: length 27.7
  TOP w0.102: v1(161.12,56.17) 161.12,55.62 v2(161.05,55.55)
  L8 w0.102: v2(142.61,54.14) 142.68,54.07 152.68,54.07 152.74,54.01 153.08,54.01 153.14,54.07 153.8,54.07 153.89,53.98 154.22,53.98 154.44,54.2 154.84,54.2 157.74,51.3 159.6,51.3 160.15,50.74 160.49,50.74 160.82,51.07 160.82,52.4 161.05,52.63 v2(161.05,55.55)
  BOTTOM w0.102: R7902.1 143.64,53.11 R7917.2 142.8,53.95 v2(142.61,54.14) ; v2(161.05,55.55) 161.06,55.55 GPU1.C10
N17S_F22: length 5.2
  TOP w0.102: v2(165.75,63.75) 165.47,63.46 163.05,63.46 v1(162.99,63.4) 162.14,62.55 R7809.1
  BOTTOM w0.102: v2(165.75,63.75) 166.29,63.75 166.31,63.76 GPU1.F22
N17S_J22: length 10.9
  TOP w0.102: v2(164.62,65.01) 165.07,65.01 165.21,65.15 165.39,65.15 165.63,65.39 165.63,65.57 165.77,65.72 165.94,65.72 166.18,65.95 166.18,66.12 167.29,67.23 168.1,67.23 168.13,67.26 v1(172.43,67.26) 172.82,67.26 173.33,66.76 R7808.1
  BOTTOM w0.102: GPU1.J22 164.6,65.56 164.6,65.03 v2(164.62,65.01)
NB_MODE#: length 6.1
  BOTTOM w0.102: U2401.34 31.63,25.87 31.33,26.17 31.33,26.55 31.43,26.66 33.04,26.66 v1(33.51,27.13) 34.55,27.13 34.88,27.46 34.88,27.82 R2002.2
NB_MUTE#: length 207.4
  TOP w0.102: v2(177.33,23) 177.33,21.85 177.97,21.21 R2717.2 177.98,20.56 R2712.1 ; v3(157.32,3.56) 157.32,4.49 157.45,4.61 157.45,10.47 157.54,10.56 157.54,11.62 157.82,11.91 160.15,14.24 160.15,14.34 160.19,14.37 160.19,19.05 160.92,19.79 160.92,23.36 v2(161.32,23.75) ; v2(17.57,8.31) 17.35,8.09 v1(17.35,7.67)
  L3 w0.102: v2(177.33,23) 176.84,22.51 174.92,22.51 173.63,23.8 171.94,23.8 171.14,23 164.38,23 163.57,23.82 161.38,23.82 v2(161.32,23.75)
  L6 w0.102: v2(18.31,22.5) 17.31,21.51 17.31,16.64 17.03,16.36 17.03,13.83 17.87,12.99 17.87,10.31 17.57,10.01 v2(17.57,8.31)
  L8 w0.102: v2(17.57,8.31) 17.57,8.31 18.21,8.31 19.77,6.75 19.77,5.65 20.86,4.56 23.09,4.56 24.26,3.39 25.68,3.39 27.52,5.22 36.26,5.22 36.28,5.21 56.53,5.21 56.59,5.15 56.93,5.15 56.93,5.15 57.53,5.15 60.06,7.68 69.82,7.68 70.02,7.88 80.01,7.88 85.37,2.52 87.63,2.52 87.85,2.29 109.25,2.29 109.58,1.96 132.32,1.96 132.57,2.21 145.72,2.21 145.87,2.21 156,2.21 157.32,3.52 v3(157.32,3.56)
  BOTTOM w0.102: U2401.119 18.21,22.67 18.31,22.57 v2(18.31,22.5)
NCT7718_DXN: length 84.7
  L3 w0.254: v2(126.91,74.88) 126.48,74.45 122.85,74.45 122.32,74.99 119.7,74.99 119.28,75.4 119.28,76.12 118.03,77.38 114.24,77.38 112.27,79.34 111.64,79.34 111.64,79.34 110.47,79.34 109.14,78.01 109.14,75.56 107.71,74.13 98.05,74.13 96.92,75.26 96.92,77.41 v2(95.76,78.57)
  L5 w0.254: v2(129.83,55.83) 129.83,55.82 130.29,55.36 130.29,53.8 130.24,53.75 130.24,50.09 130.1,49.95 130.1,45.81 128.89,44.6 128.89,44.2 128,43.31 127.6,43.31 127.42,43.13 v2(126.85,43.12)
  L8 w0.254: v2(126.91,74.88) 126.89,74.88 126.83,74.83 126.83,73.8 126.48,73.44 126.48,61.61 125.51,60.65 125.51,59.03 126.82,57.73 126.82,56.42 127.88,55.36 129.54,55.36 129.83,55.65 v2(129.83,55.83)
  BOTTOM w0.254: C2606.2 95.68,79.97 95.68,79.5 Q2603.E v2(95.76,78.57) ; U2601.3 127.61,41.1 C2607.2 127.29,41.47 126.8,41.96 126.8,42.42 126.8,42.42 ; v2(126.85,43.12) 126.76,43.02 126.76,42.46 126.8,42.42 ; 126.8,42.42 v1(126.77,42.42)
NCT7718_DXP: length 88.4
  TOP w0.254: v1(95.28,77.38) 95.28,77.48 v2(95.64,77.84)
  L3 w0.254: v2(95.64,77.84) 96.41,77.07 96.41,75.05 97.84,73.62 107.92,73.62 109.64,75.35 109.64,77.8 110.68,78.84 111.85,78.84 112.06,78.84 114.03,76.87 117.82,76.87 118.78,75.91 118.78,75.19 119.49,74.48 122.11,74.48 122.64,73.94 126.69,73.94 127.42,74.67 v2(127.42,75.44)
  L5 w0.254: v2(126.84,43.83) 127.37,43.84 127.39,43.82 127.79,43.82 128.38,44.42 128.38,44.81 129.59,46.02 129.59,50.16 129.73,50.3 129.73,53.96 129.78,54.01 129.78,55.15 129.17,55.76 v2(129.17,55.87)
  L8 w0.254: v2(129.17,55.87) 128.09,55.87 127.33,56.63 127.33,57.94 126.02,59.24 126.02,60.44 126.98,61.4 126.98,73.23 127.6,73.85 127.6,75.26 v2(127.42,75.44)
  BOTTOM w0.254: v2(95.64,77.84) 95.08,77.28 Q2603.C 93.86,78.23 Q2603.B 93.86,80.21 C2606.1 ; U2601.2 126.96,40.24 127.1,40.38 127.1,40.69 C2607.1 126.29,41.5 126.29,42.14 126.25,42.18 126.25,43.23 126.84,43.82 v2(126.84,43.83)
NRB_BIT: length 16.2
  TOP w0.102: v2(106.12,47.52) 106.55,47.95 106.55,48.97 106.87,49.29 107.13,49.29 108.1,50.26 v1(108.44,50.26) 108.46,50.27 110.23,50.27 110.26,50.31 110.29,50.31 110.54,50.56 110.6,50.56 110.86,50.82 110.86,50.83 111.07,51.04 111.08,51.04 111.34,51.3 v2(117.83,51.3)
  BOTTOM w0.102: CPU1.CE29 106.32,47.6 106.22,47.6 106.12,47.5 106.12,47.52 v2(106.12,47.52) ; R1502.2 117.71,51.18 v2(117.83,51.3) 117.69,51.44 R1503.1
OVERT_GPU#: length 23.6
  TOP w0.102: v1(141.96,55.43) 142.04,55.43 v2(142.42,55.04)
  L8 w0.102: v2(142.42,55.04) 142.43,55.04 142.43,55.02 142.86,55.02 143.57,54.31 144.89,54.31 144.89,54.31 145.25,54.31 145.25,54.31 145.5,54.31 147.88,56.7 148.7,56.7 150.04,55.35 154.85,55.35 157.43,52.77 158.69,52.77 v2(160.32,51.15)
  BOTTOM w0.102: v2(142.42,55.04) 142.21,55.25 141.66,55.25 RN7910.3 ; v2(160.32,51.15) 159.94,51.53 GPU1.A6
OVP_UVP_REF_VDD: length 10.4
  TOP w0.254: PR44A2.1 151.15,27.72 PR44B7.1 151.46,29.06 v3(151.93,29.06) ; PR44C6.2 164.47,31.06 163.77,31.76 v1(162.14,31.76) 161.77,31.38 v3(161.61,31.38)
  L8 w0.254: v3(151.93,29.06) 153.49,29.06 154.85,30.43 v3(156,30.43)
P2800_VGA_DXN: length 2.3
  TOP w0.102: TP7903.1 162.24,56.11 161.62,56.72 v2(161.08,56.72)
  BOTTOM w0.102: v2(161.08,56.72) 161.08,57.26 GPU1.E12
P2800_VGA_DXP: length 1.2
  TOP w0.102: v2(160.5,57.26) 160.53,57.29 161.06,57.29 TP7904.1
  BOTTOM w0.102: v2(160.5,57.26) 160.5,57.88 GPU1.F12
PANEL_BKEN: length 107.1
  TOP w0.127: v2(23.16,24.54) 23.16,24.47 22.35,23.66 v1(22.35,23.64) 21.42,22.71 D2401.3 ; RN5501.3 58.93,85.14 58.15,84.35 v2(58.15,83.04)
  L5 w0.127: v2(58.15,83.04) 58.15,81.04 56.16,79.05 53.96,79.05 53.85,78.94 51.86,78.94 51.78,79.01 47.58,79.01 47.55,78.99 38.3,78.99 36.46,77.14 26.54,77.14 v2(25.31,78.37)
  L6 w0.127: v2(23.16,24.54) 23.13,24.57 23.13,25.56 23.15,25.58 23.15,27.11 22.86,27.4 22.86,30.02 22.18,30.7 22.18,38.91 23.07,39.8 23.07,42.69 22.39,43.37 22.39,43.94 22.4,43.94 22.4,45.93 22.39,45.94 22.39,46.46 21.15,47.7 21.15,54.96 22.1,55.91 22.1,58.62 20.35,60.37 20.35,62.87 18.94,64.27 18.77,64.27 18.19,64.86 18.19,65.64 18.91,66.36 18.91,69.06 18.65,69.32 18.24,69.32 17.23,70.32 17.23,71.72 18.82,73.31 19.61,73.31 21.06,74.76 21.06,76.51 22.92,78.37 v2(25.31,78.37)
PANEL_BKEN_EC: length 8.1
  TOP w0.127: v1(24.31,19.96) 23.54,20.73 D2401.1 23.53,21.03 v2(23.13,21.44)
  BOTTOM w0.127: v2(23.13,21.44) 18.59,21.44 18.58,21.46 18.29,21.46 17.88,21.87 U2401.117
PANEL_MONITOR: length 67.5
  TOP w0.102: v2(23.57,25.02) 23.98,25.02 25.11,26.15 31.56,26.15 32.88,27.47 32.88,32.24 32.33,32.79 32.33,34.17 32.34,34.18 32.34,34.55 31.37,35.51 31.37,37.11 29.99,38.5 29.99,41.17 29.77,41.39 29.77,43.01 31.51,44.74 31.51,44.75 31.66,44.9 v1(31.66,47.28) 34.03,49.64 34.03,63.91 34.81,64.7 34.81,65.36 34.81,65.72 34.81,65.72 34.81,66.47 35.74,67.4 36.85,67.4 36.86,67.41 36.97,67.41 37.27,67.71 37.27,67.93 37.83,68.49 38.17,68.49 38.2,68.46 39.14,68.46 41.07,70.39 41.07,70.41 41.11,70.44 41.11,71.39 41.03,71.47 41.03,71.49 40.12,72.4 R5536.2
  BOTTOM w0.102: U2401.20 26.17,26.71 24.49,25.02 v2(23.57,25.02)
PANEL_PWRGD: length 9.2
  TOP w0.102: v2(42,75.32) 41.16,74.48 Q5508.C 40.24,74.34 C5558.1 39.99,74.1 39.99,73.44 R5536.1 40.78,73.31 R5558.1 41.38,73.19 R5535.2
  BOTTOM w0.102: v1(42.24,74.15) 42,74.39 v2(42,75.32) 43.75,77.07 Q5510.C
PBAT_CHG_SMBCLK: length 195.8
  TOP w0.127: v2(112.18,3.28) 112.17,3.28 111.73,2.83 111.36,2.83 111.08,3.11 111.08,3.17 110.95,3.3 110.89,3.3 109.4,4.8 109.4,6.24 110.32,7.16 115.76,7.16 115.99,7.39 115.99,7.49 115.77,7.72 ED4306.3 115.69,7.96 114.82,8.83 114.04,8.83 113.76,9.11 113.76,11.17 113.53,11.41 112.99,11.41 EC4309.1 112.75,11.24 RN4302.1 ; RN2402.3 20.89,26.88 20.98,26.79 20.98,26.4 21.46,25.91 v2(21.48,25.91)
  L3 w0.127: v2(112.18,3.28) 112.17,3.28 111.42,4.03 110.59,4.03 109.13,5.49 108.65,5.49 103.04,11.1 90.56,11.1 89.68,11.99 81.49,11.99 80.84,12.64 70.88,12.64 70.26,12.01 61.37,12.01 59.94,10.59 52.12,10.59 51.86,10.33 39.76,10.33 39.46,10.64 38.68,10.64 38.38,10.33 30.62,10.33 29.71,9.42 23.97,9.42 23.7,9.15 23.7,9.12 v2(23.13,8.55)
  L6 w0.127: v2(21.48,25.91) 21.56,25.99 21.67,25.99 21.82,25.85 21.82,24.23 22.43,23.62 22.43,21.15 22.9,20.68 22.9,11.91 22.36,11.38 22.36,10.22 23.32,9.26 23.32,8.74 v2(23.13,8.55)
  BOTTOM w0.127: v2(21.48,25.91) 21.48,26.01 21.87,26.4 21.87,26.77 21.77,26.86 U2401.9 ; v2(112.18,3.28) 112.18,2.9 112.69,2.4 113.52,2.4 113.82,2.1 113.86,2.1 114.17,1.79 114.45,1.5 136.15,1.5 137.25,2.6 145.3,2.6 146.43,1.48 146.48,1.48 146.49,1.47 149.48,1.47 149.49,1.47 152.67,1.47 155.69,4.49 156.73,4.49 157.59,5.35 157.59,5.86 158.12,6.39 158.12,11.75 v1(157.97,11.9) 158.12,12.04 158.12,12.79 157.9,13.01 157.74,13.01 157.64,13.11 157.61,13.11 157.6,13.12 156.9,13.12 156.73,13.29 PR4489.1
PBAT_CHG_SMBDAT: length 196.2
  TOP w0.127: ED4305.3 115.7,9.86 ; 115.7,9.86 116.25,9.31 116.25,7.29 115.87,6.91 110.42,6.91 109.65,6.13 109.65,4.9 111,3.55 111.27,3.55 v2(111.54,3.28) ; 115.7,9.86 115.7,9.53 115.25,9.09 114.14,9.09 114.02,9.21 114.02,11.27 113.63,11.66 113.06,11.66 EC4310.1 112.74,11.89 RN4302.2 ; RN2402.4 21.54,26.7 v2(21.42,26.58)
  L3 w0.127: v2(111.54,3.28) 111.54,3.55 111.32,3.77 110.48,3.77 109.02,5.23 108.55,5.23 102.93,10.85 90.46,10.85 89.57,11.73 81.38,11.73 80.73,12.38 70.99,12.38 70.36,11.76 61.47,11.76 60.05,10.33 52.22,10.33 51.97,10.08 39.65,10.08 39.35,10.38 38.79,10.38 38.48,10.08 30.72,10.08 29.82,9.17 24.08,9.17 23.95,9.04 v2(23.95,8.55)
  L6 w0.127: v2(21.42,26.58) 21.64,26.36 21.67,26.36 22.07,25.95 22.07,24.33 22.68,23.72 22.68,21.26 23.15,20.79 23.15,11.81 22.62,11.27 22.62,10.32 23.58,9.36 23.58,8.93 v2(23.95,8.55)
  BOTTOM w0.127: U2401.8 21.37,26.63 v2(21.42,26.58) ; v2(111.54,3.28) 111.58,3.24 111.58,3.14 112.58,2.14 113.42,2.14 113.72,1.84 113.75,1.84 113.91,1.69 114.35,1.25 136.25,1.25 137.36,2.35 145.2,2.35 146.33,1.22 146.38,1.22 146.38,1.22 149.59,1.22 149.59,1.22 152.78,1.22 155.79,4.23 156.83,4.23 157.85,5.25 157.85,5.76 158.37,6.28 158.37,12.9 157.98,13.29 v1(157.9,13.37) 157.25,13.37 157.07,13.37 156.38,14.07 PR4488.1
PBAT_PRES1#: length 34.3
  TOP w0.102: v2(110.84,12.84) 110.61,13.06 110.61,13.8 111.27,14.46 112.42,14.46 AFTP4309.1 ; v2(88.17,13.01) 87.68,13.5 R4327.2
  BOTTOM w0.102: v2(88.17,13.01) 88.87,13.01 v1(89.09,13.23) 91.39,15.52 109.13,15.52 110.31,14.34 110.31,13.36 v2(110.84,12.84) 110.57,12.57 108.36,12.57 108.21,12.42 BATT1.7
PBAT_PRES#: length 154
  TOP w0.102: ED4304.3 81.43,13.93 85.65,13.93 EC4306.1 86.15,14.12 R4327.1 86.15,13.5 86.97,12.68 v2(87.13,12.68) ; v2(110.79,4.65) 110.32,5.13 v1(110.29,5.13) ; R2415.2 29.52,26.75 v2(29.61,26.66)
  L3 w0.102: v2(110.79,4.65) 110.79,4.76 109.57,5.98 109.04,5.98 103.42,11.6 90.77,11.6 89.88,12.48 88.09,12.48 87.88,12.68 v2(87.13,12.68) 86.68,13.13 70.68,13.13 70.05,12.5 61.57,12.5 61.16,12.5 59.74,11.08 53.52,11.08 53.51,11.09 51.63,11.09 51.37,10.83 40.09,10.83 39.78,11.14 38.48,11.14 38.24,10.89 38.17,10.83 30.25,10.83 29.78,10.36 v2(29.13,10.36)
  L6 w0.102: v2(29.13,10.36) 29.23,10.36 29.86,10.99 29.86,15.56 29.61,15.81 v2(29.61,26.66)
  BOTTOM w0.102: v2(110.79,4.65) 110.79,4.63 111.65,3.77 112.85,3.77 114.03,2.59 114.06,2.59 114.66,2 135.94,2 137.56,3.61 137.64,3.61 137.97,3.94 143.94,3.94 144.79,3.1 145.51,3.1 146.61,2 PR4498.1 ; U2401.29 29.77,26.82 v2(29.61,26.66)
PCH_BATLOW#: length 12.6
  TOP w0.102: v2(102.63,42.44) 102.28,42.09 102.28,41.6 103.06,40.82 103.74,40.82 107.01,37.55 107.59,37.55 108.32,36.82 108.64,36.82 v1(108.95,36.51) 109.62,35.84 R1723.1 109.62,35.54 R1722.2
  BOTTOM w0.102: CPU1.BV36 102.73,42.54 v2(102.63,42.44)
PCH_DPWROK: length 36.6
  TOP w0.127: v2(128.79,54.42) 128.33,54.87 v1(128.33,54.96)
  L6 w0.127: v2(128.79,54.42) 127.61,54.42 126.87,55.16 124.68,55.16 124.66,55.14 124.32,55.14 124.3,55.16 123.41,55.16 123.35,55.22 114.23,55.22 113.57,55.89 109.48,55.89 109.1,55.52 107.89,55.52 106.37,54 106.37,52.71 106.16,52.5 106.16,51.85 104.33,50.02 102.57,50.02 100.64,48.09 v2(100.64,46.87)
  BOTTOM w0.127: v2(100.64,46.87) 100.64,46.86 100.55,46.86 100.22,47.19 CPU1.BP30 ; R1704.2 129.22,54.12 128.92,54.42 v2(128.79,54.42)
PCH_PLTRST#: length 70.6
  L5 w0.102: v2(132.6,51.39) 132.12,50.91 132.12,39.77 128.67,36.33 126.94,36.33 125.01,34.4 125.01,34.04 125.33,33.72 125.33,32.15 125.13,31.95 125.13,29.51 124.89,29.27 v2(124.45,29.27)
  BOTTOM w0.102: v2(124.45,29.27) 124.45,29.27 124.45,29.26 124.03,29.69 124.03,30.33 123.34,31.01 123.22,31.01 123.18,31.05 113.44,31.05 112.39,32.1 101.31,32.1 98.26,35.14 98.26,36.83 99.19,37.76 99.19,40.87 98.58,41.49 98.58,41.87 97.34,43.1 97.34,43.92 97.07,44.19 CPU1.BJ35 ; R1713.2 134.13,49.14 134.23,49.24 134.23,50.83 v1(134.07,50.99) 133.67,51.39 v2(132.6,51.39)
PCH_POPIRCOMP: length 0.6
  BOTTOM w0.203: CPU1.BW25 102.83,50.42 v2(102.83,50.49)
PCH_RSMRST#: length 194.1
  TOP w0.102: TP2402.1 29.14,28.93 v2(29.14,28.93)
  L3 w0.102: v2(123.62,69.35) 123.73,69.35 129.18,63.9 129.59,63.9 131.81,61.67 131.81,58.48 133.18,57.11 133.18,53.95 132.83,53.6 v2(132.76,53.6)
  L5 w0.102: v2(29.14,28.93) 28.23,29.83 24.35,29.83 v2(23.33,30.85) ; v2(119.36,73.21) 118.93,73.21 118.55,72.83 115.51,72.83 113.19,70.51 107.35,70.51 106.22,71.64 97.5,71.64 96.87,72.27 78.31,72.27 76.52,70.48 64.48,70.48 58.78,76.19 53.23,76.19 51.38,78.03 47.98,78.03 47.81,77.86 46.62,77.86 46.34,77.58 46.34,77.14 45.38,76.18 41.89,76.18 39.69,73.98 39.69,69.12 39.23,68.65 38.35,68.65 37.79,69.22 36.45,69.22 33.92,71.75 33.92,71.89 33.61,72.21 33.47,72.21 33.08,72.6 31.71,72.6 29.94,70.82 27.78,70.82 26.99,70.03 26.99,68.75 26.01,67.77 23.19,67.77 21.77,66.35 20.08,66.35 19.02,65.29 v2(18.88,65.29)
  L6 w0.102: v2(119.36,73.21) 119.36,73.15 123.16,69.35 v2(123.62,69.35) ; v2(23.33,30.85) 22.8,31.39 22.8,34.96 23.74,35.9 23.74,45.89 21.64,47.98 21.64,48.55 21.82,48.73 21.82,54.93 22.59,55.7 22.59,60.02 21.58,61.03 21.58,63.03 21.02,63.58 20.45,63.58 18.88,65.15 v2(18.88,65.29)
  BOTTOM w0.102: R1702.2 132.48,53.79 132.68,53.6 v2(132.76,53.6) ; U2401.27 28.97,28.69 29.14,28.85 v2(29.14,28.93) ; R6425.1 18.88,64.08 v2(18.88,65.29)
PCH_SATA_LED#: length 153.8
  TOP w0.127: v2(20.56,72.8) 22.02,74.25 D6401.1
  L5 w0.127: v2(19.34,63.24) 21.45,65.35 23.34,65.35 24.94,66.95 26.36,66.95 27.85,68.45 33.94,68.45 34.44,68.94 37.72,68.94 38.25,68.41 39.13,68.41 39.13,68.41 39.33,68.41 39.93,69.02 39.93,73.88 41.9,75.85 46.54,75.85 47.86,77.17 47.86,77.57 48.08,77.79 51.28,77.79 53.2,75.87 58.71,75.87 64.34,70.24 77.36,70.24 79.15,72.03 96.43,72.03 97.37,71.09 97.37,68.3 100.59,65.08 109.26,65.08 114.15,69.96 120.46,69.96 123.6,66.82 v2(123.6,66.37)
  L8 w0.127: v2(20.56,72.8) 20.64,72.8 21.04,72.39 21.04,66.45 19.34,64.75 v2(19.34,63.24)
  BOTTOM w0.076: 113.09,62.07 113.05,62.03 111.8,62.03 111.71,62 CPU1.CN7
  BOTTOM w0.127: v1(124.01,66.85) 123.6,66.45 v2(123.6,66.37) R1606.2 123.6,65.4 121.62,63.41 115.07,63.41 113.73,62.07 113.09,62.07
PCH_TCK: length 2.1
  TOP w0.102: TP314.1 78.62,63.08 v2(78.62,61.94)
  BOTTOM w0.102: v2(78.62,61.94) 78.38,62.18 CPU1.W6
PCIE_RCOMPN: length 3.5
  TOP w0.127: R1604.1 107.36,63.93 v1(107.36,63.36) 106.9,62.9 106.9,62.87 106.79,62.76 106.79,62.37 106.37,61.95 v2(106.37,61.87)
  BOTTOM w0.127: CPU1.CE6 106.47,61.87 v2(106.37,61.87)
PCIE_RCOMPP: length 3.6
  TOP w0.127: R1604.2 106.86,64.28 107.1,64.03 107.1,63.63 106.99,63.51 106.99,63.35 106.65,63.01 106.65,62.98 106.54,62.87 106.54,62.6 106.45,62.51 v2(106.31,62.51)
  BOTTOM w0.127: v2(106.31,62.51) 106.26,62.57 106.26,62.99 106.39,63.11 106.65,63.11 106.78,62.99 CPU1.CE5
PCIE_WAKE#_CPU: length 19.7
  TOP w0.102: v3(112.17,37.2) 112.23,37.14 RN1704.3
  L5 w0.102: v3(112.17,37.2) 111.2,37.2 110.59,37.82 109.28,37.82 108.06,39.04 108.06,40.42 107.4,41.08 107.4,41.93 106.67,42.65 105.04,42.65 104.47,43.22 103.66,43.22 101.72,45.17 101.72,45.53 102.04,45.85 102.04,47.16 v2(102.42,47.55)
  BOTTOM w0.102: CPU1.BU30 102.02,47.19 102.37,47.55 v2(102.42,47.55) ; v1(111.79,36.83) v3(112.17,37.2)
PD4403_A: length 4.7
  BOTTOM w0.102: v1(138.94,23.15) 139.02,23.06 PQ4408.B 140.19,23.06 141.46,21.79 PD4403.A
PD4403_K: length 2.7
  BOTTOM w0.102: v1(144.49,20.69) 144.49,21 PD4403.K 145.92,21.79 146.32,22.2 PR4485.2
PD_IRQ1: length 2.1
  TOP w0.127: v1(29.84,63.06) 29.84,63.43 v3(29.7,63.57) 29.48,63.35 R7224.2
  BOTTOM w0.089: v3(29.7,63.57) 29.67,63.57 29.6,63.64 U7201.C1
PD_OVP_TRIP_P1: length 7.1
  TOP w0.127: R7243.2 20.03,63.05 R7250.2 20.38,62.69 v2(20.82,62.69) 21.16,62.35 v1(21.16,61.69)
  BOTTOM w0.127: U7201.E10 24.33,62.4 23.25,62.4 22.79,62.86 20.98,62.86 v2(20.82,62.69)
PD_VBUS_C_CTRL1: length 16.4
  TOP w0.254: Q7406.5 20.77,68.41 20.46,68.1 v2(20.46,67.51) ; v2(22.49,68.28) 23.37,68.28 23.62,68.03 Q7405.2
  L3 w0.254: v2(20.46,67.51) 21.23,68.28 v2(22.49,68.28)
  L8 w0.254: v2(22.49,68.28) 22.49,68.23 24.34,66.38 24.34,63.17 23.28,62.11 v2(22.64,62.11)
  BOTTOM w0.089: v2(22.64,62.11) 22.91,61.84 23.89,61.84 23.91,61.87 24.24,61.87 24.27,61.84 24.37,61.84 U7201.G10
  BOTTOM w0.254: v1(22.7,67.76) 22.7,68.07 v2(22.49,68.28)
PD_VBUS_C_CTRL1_A: length 3.6
  TOP w0.254: Q7405.1 22.97,67.1 23.4,66.67 23.69,66.67 24.11,66.25 v1(24.33,66.25) 24.47,66.25 25.06,66.84 Q7404.3
PD_VBUS_C_CTRL1_R: length 5.2
  TOP w0.254: R7426.2 24.57,70.03 23.86,70.03 23.64,70.25 v1(23.58,70.25) ; v1(23.58,70.25) 23.62,70.21 Q7405.5 ; v1(23.58,70.25) 23.45,70.13 22.44,70.13 R7410.1 22.41,70.05 22.97,69.49 Q7405.6
PD_VBUS_C_EN: length 16.7
  TOP w0.254: v2(22.95,73.97) 23.07,73.85 U7419.A3
  L3 w0.254: v2(21.76,67.11) 21.76,67.39 22.14,67.77 22.7,67.77 23,68.07 23,68.74 24.62,70.35 24.62,71.01 23.6,72.03 23.6,73.32 v2(22.95,73.97)
  BOTTOM w0.254: v2(21.76,67.11) 21.68,67.11 21.42,67.37 Q7407.3 ; R7422.1 22.26,70.46 R7427.2 21.49,71.24 v1(22.54,71.24) 23.36,72.06 23.36,73.56 v2(22.95,73.97)
PD_VBUS_C_EN_A: length 14.4
  TOP w0.254: v1(19.09,68.35) 18.98,68.35 v2(18.46,68.87) ; Q7405.3 24.27,67.9 24.63,68.25 v2(24.68,68.25) ; v2(25.85,68.92) 25.82,68.92 25.82,69.07 25.75,69.13 R7425.2
  L3 w0.254: v2(25.85,68.92) 25.82,68.92 25.82,68.6 25.48,68.25 v2(24.68,68.25)
  L5 w0.254: v2(24.68,68.25) 24.68,68.25 24.06,68.87 22.57,68.87 22.5,68.8 22.08,68.8 22.01,68.87 v2(18.46,68.87)
  BOTTOM w0.254: v2(18.46,68.87) 18.29,69.04 R7408.1 ; v2(18.46,68.87) 18.68,68.66 Q7407.5 ; v2(18.46,68.87) 18.9,69.31 Q7407.6
PDB_R: length 3.1
  TOP w0.102: U2701.40 180.76,17.65 179.61,18.8 v1(179.61,18.97) 178.89,19.7 R2712.2
PECI_CPU: length 180
  TOP w0.089: v2(14.79,3.46) 16.55,3.46 18.7,5.6 18.7,6.53 18.7,6.53 v1(18.7,9.32) 18.7,10.56 19.74,11.6 R2437.2
  L3 w0.076: v2(27.71,41.04) 27.83,41.04 28.84,42.05 28.84,46.88 28.46,47.25 28.46,50.26 30.9,52.7 32.07,52.7 33.44,51.32 v2(33.44,50.48)
  L5 w0.089: v2(10.01,26.86) 10.01,27.35 12.21,29.55 13.55,29.55 16.45,32.45 16.45,40.28 17.97,41.8 20.4,41.8 20.49,41.72 21.74,41.72 22.49,40.96 24.11,40.96 25.16,42.01 25.92,42.01 26.89,41.04 v2(27.71,41.04)
  L6 w0.089: v2(72.82,68.58) 72.82,73.38 72.44,73.75 v2(72.44,74.25)
  L8 w0.076: v2(72.82,68.58) 72.82,67.41 72.01,66.61 72.01,65.15 67.7,60.85 58.27,60.85 57.25,59.83 53.28,59.83 52.92,60.2 51.66,60.2 50.45,58.98 48.76,58.98 48.07,58.29 45.69,58.29 45.01,57.6 42.8,57.6 42.5,57.9 42.5,57.92 42.18,58.25 40.14,58.25 35.07,53.18 35.07,52.16 33.44,50.53 v2(33.44,50.48) ; v2(10.01,26.86) 10.03,26.86 10.03,26.15 9.11,25.23 9.11,22.1 6.52,19.52 6.52,19.49 6.27,19.24 6.24,19.24 5.63,18.63 5.63,11.74 9.27,8.1 9.27,6.94 12.75,3.46 v2(14.79,3.46) ; v2(72.44,74.25) 72.53,74.17 80.4,74.17 80.64,74.41 84.08,74.41 84.96,73.54 92.82,73.54 v2(93.54,74.25)
  BOTTOM w0.089: CPU1.AR1 88.37,67.61 87.96,68.01 87.96,70.4 88.16,70.59 88.16,71.53 88.89,72.25 88.89,73.28 89.88,74.27 93.51,74.27 v2(93.54,74.25)
PEX_TERMP: length 5.6
  BOTTOM w0.102: GPU1.AF25 155.89,77.2 155,78.08 152.87,78.08 v1(152.77,78.18) R7601.1
PIRQA#: length 91.3
  TOP w0.102: v2(177.53,32.17) 177.88,31.82 R9123.2 ; R2053.2 124.91,39.36 v1(124.86,39.31) 124.48,39.31 v2(124.18,39.61)
  L6 w0.102: v2(177.53,32.17) 176.86,31.5 176.54,31.5 175.88,30.84 175.88,28.83 174.92,27.87 174,27.87 173.48,28.39 170.02,28.39 169.3,27.67 168.31,27.67 167.46,28.52 165.52,28.52 165.18,28.86 164.82,28.86 164.32,28.35 162.74,28.35 162.74,28.35 162.38,28.35 162.38,28.35 162.3,28.35 162.13,28.53 161.72,28.53 161.2,28.01 153.61,28.01 151.75,26.14 142.81,26.14 141.26,27.69 141.26,28.29 140.27,29.28 139.87,29.28 137.88,31.27 134.9,31.27 131.01,35.16 131.01,36 127.39,39.61 v2(124.18,39.61) 123.89,39.61 123.19,40.32 117.3,40.32 114.91,42.71 114.19,42.71 114.17,42.69 113.41,42.69 111.42,44.68 109.66,44.68 108.9,45.44 108.9,45.52 108.61,45.81 108.27,45.81 107.3,44.84 106.95,44.84 106.11,45.67 v2(106.11,46.25)
  BOTTOM w0.102: CPU1.CC32 106.01,46.25 v2(106.11,46.25)
PLTRST#_CPU: length 210.4
  TOP w0.127: R6604.1 174.49,31.29 v2(175.23,31.29) 175.73,31.29 ED1702.1 ; R6103.2 167.86,21.42 167.86,19.35 AFTP6108.1 168.57,18.63 169.04,18.63 v2(169.08,18.6) ; U9101.17 182.11,31.14 v2(182.16,31.2)
  L3 w0.127: v2(133.78,50.07) 133.78,55.28 134.92,56.42 134.92,60.66 135.19,60.93 135.19,64.27 v2(132.67,66.79) ; v2(182.16,31.2) 181.67,30.7 178.35,30.7 177.63,31.42 175.81,31.42 175.68,31.29 v2(175.23,31.29)
  L5 w0.127: 162.97,23.5 161.72,24.75 161.28,24.75 160.65,25.38 160.65,25.57 158.47,27.76 154.63,27.76 154.53,27.86 151.99,27.86 151.97,27.84 151.62,27.84 151.38,28.09 151.38,28.19 150.42,29.15 149.74,29.15 148.82,28.23 148.16,28.23 147.8,28.59 147.17,28.59 146,27.42 144.32,27.42 143.29,26.39 142.21,26.39 140.9,27.71 140.6,27.71 139.3,29.01 135.98,29.01 135.85,28.88 135.48,28.88 132.84,31.52 v2(129.36,31.52) 128.91,31.96 128.91,34.57 129.17,34.83 130.42,34.83 134.1,38.5 134.1,42.24 134.17,42.32 134.17,44.43 134.2,44.45 134.2,49.29 133.78,49.7 v2(133.78,50.07) ; 162.97,23.5 162.97,22.82 163.41,22.38 165.36,22.38 166.99,20.75 166.99,19.97 168.36,18.6 v2(169.08,18.6) ; 162.97,23.5 162.97,23.72 164.31,25.06 164.31,31.07 163.19,32.18 163.19,33.16 164.35,34.31 167.09,34.31 167.85,33.56 167.89,33.56 169.05,32.4 174.12,32.4 v2(175.23,31.29)
  L8 w0.127: v2(196.75,5.2) 196.01,5.95 196.01,6.61 194.25,8.37 190.82,8.37 190.62,8.37 189.93,7.68 189.34,7.68 189.14,7.68 188.11,6.65 179.6,6.65 179.49,6.76 179.49,8.02 179.23,8.29 178.8,8.29 178.12,8.97 178.12,18.44 176.13,20.43 176.13,30.39 v2(175.23,31.29)
  BOTTOM w0.127: v2(196.75,5.2) 196.66,5.3 IO2.20 ; C1701.1 132.58,49.07 R1713.1 132.64,49.29 133.05,49.7 133.42,49.7 v2(133.78,50.07) 133.65,50.2 v1(132.63,50.2) 132.01,50.2 R1715.1 ; U7601.2 134.25,75.7 134.25,72.73 132.87,71.34 132.87,68.18 132.67,67.98 v2(132.67,66.79) ; SSD1.50 116.9,28.14 118.2,29.44 118.77,29.44 118.78,29.45 119.39,29.45 120.46,30.52 123.13,30.52 123.53,30.12 123.53,29.66 123.51,29.64 123.53,29.62 123.53,29.16 123.51,29.14 123.53,29.12 123.53,28.51 123.86,28.17 124.76,28.17 125.64,29.06 125.64,30.79 126.68,31.82 127.69,31.82 127.8,31.71 129.16,31.71 129.35,31.52 v2(129.36,31.52) ; v2(169.08,18.6) 169.03,18.55 WLAN1.52
PM_PCH_PWROK: length 37.2
  L6 w0.127: v2(100.66,46.24) 101.09,46.67 101.09,48.17 102.68,49.76 104.44,49.76 106.42,51.75 106.42,52.4 107.49,53.47 107.87,53.47 107.9,53.45 108.27,53.45 108.29,53.47 109.84,53.47 109.85,53.46 110.22,53.46 110.24,53.47 111.47,53.47 112.68,52.26 115.07,52.26 115.82,52.26 116.07,52.5 119.28,52.5 120.24,51.54 121.87,51.54 122.18,51.84 124.61,51.84 124.93,51.53 126.27,51.53 126.69,51.95 127.76,51.95 128.02,51.69 v2(128.1,51.69)
  BOTTOM w0.127: v2(100.66,46.24) 100.65,46.24 100.65,46.23 100.33,46.54 CPU1.BP31 ; RN1703.3 128.88,53.28 R1706.2 128.68,53.08 128.68,52.09 v1(128.91,51.86) 128.74,51.69 v2(128.1,51.69)
PM_RSMRST#: length 84.7
  TOP w0.127: 130.13,61.16 130.11,61.18 130.11,62.49 v1(130,62.61) 129.72,62.89 128.86,62.89 128.37,63.38 128.37,63.38 128.26,63.49 128.26,64.71 128.59,65.04 Q1701.6 ; 130.13,61.16 v2(130.15,61.15) ; 130.13,61.16 Q1702.5
  L5 w0.127: v2(132.75,54.48) 132.21,55.02 132.21,57.04 132.34,57.17 133.46,57.17 133.48,57.16 133.85,57.16 133.86,57.17 134.27,57.17 134.71,57.61 134.71,57.98 134.19,58.5 133.58,58.5 130.94,61.15 v2(130.15,61.15) 129.69,60.69 129.69,59.45 129.69,59.45 129.69,59.08 129.43,58.82 129.03,58.82 128.57,59.28 127.2,59.28 126.85,58.93 126.85,55.49 127.46,54.88 127.46,51.45 127.11,51.1 127.11,50.07 127.7,49.48 127.7,47.22 126.97,46.49 126.97,45.19 126.39,44.61 126.39,39.4 v2(125.46,38.47)
  L6 w0.127: v2(100.81,39.8) 100.81,41.25 103.29,43.73 110.8,43.73 114.23,40.3 114.24,40.3 114.49,40.05 114.85,40.05 115.1,40.3 116.28,40.3 116.99,39.58 122.79,39.58 123.56,38.81 125.11,38.81 v2(125.46,38.47)
  BOTTOM w0.076: 100.92,41.42 100.61,41.73 100.61,42.99 100.68,43.17 100.79,43.46 CPU1.BR36
  BOTTOM w0.127: 100.92,41.42 100.92,39.91 v2(100.81,39.8) ; v2(132.75,54.48) 132.75,54.53 132.57,54.35 130.67,54.35 R1704.1 130.4,54.08 RN1703.4 130.72,53.28 R1702.1 131.5,53.53 ED1706.1
PM_RSMRST#_M: length 3.1
  TOP w0.102: R1737.2 v1(126.33,60.9) 126.71,60.51 Q1702.3 Q1702.2
PM_SLP_A#: length 3.1
  BOTTOM w0.102: TP1706.1 102.38,40.24 102.38,40.54 101.97,40.95 101.97,42.78 CPU1.BU37
PM_SLP_S0#: length 116.5
  TOP w0.127: R9121.2 v2(184.96,24.38)
  L6 w0.127: v2(124.42,28.63) 124.42,27.01 126.88,24.55 128.77,24.55 129.42,25.21 137.68,25.21 138.89,23.99 138.89,23.79 140.9,21.77 148.3,21.77 148.51,21.56 153.37,21.56 154.64,22.84 155.22,22.84 155.6,22.46 161.16,22.46 161.26,22.36 161.6,22.36 161.7,22.46 163.41,22.46 163.49,22.38 168.83,22.38 169.26,21.95 173.25,21.95 175.12,23.82 183.75,23.82 184.3,24.38 v2(184.96,24.38)
  BOTTOM w0.127: CPU1.BJ37 97.29,42.65 97.31,42.64 97.65,42.3 97.66,42.3 97.78,42.17 97.78,42.17 98.14,41.81 98.37,41.53 98.37,41.4 98.99,40.79 98.99,37.84 98.02,36.88 98.02,35.04 101.21,31.86 112.01,31.86 113.06,30.81 123.08,30.81 123.12,30.77 123.24,30.77 123.78,30.23 123.78,28.89 124.04,28.63 v2(124.42,28.63) 124.45,28.66 124.88,28.66 125.39,29.17 125.39,30.89 126.6,32.1 129.6,32.1 130,31.7 v1(130.47,31.7) 130.69,31.7 131,32.01 R4040.1
PM_SLP_S3#: length 262.5
  TOP w0.127: v2(69.64,11.22) 70.47,12.05 70.47,13.7 70.12,14.04 58.96,14.04 58.9,14.1 55.99,14.1 52.7,17.39 45.46,17.39 45.46,17.39 45.09,17.39 45.09,17.39 43.42,17.39 41.1,19.71 v2(40.49,19.71) ; v2(184.33,23.77) 184.32,23.77 184.32,23.79 184.34,23.79 184.45,23.91 185.41,23.91 185.73,24.22 Q4001.G
  L5 w0.127: v2(134.24,23.67) 133.94,23.37 129.01,23.37 127.43,21.79 127.43,17.61 124.04,14.22 123.28,14.22 119.99,10.93 117.89,10.93 117.12,11.7 116.94,11.7 116.77,11.82 108.45,11.82 108.18,12.09 93.2,12.09 91.36,13.94 90.2,13.94 88.82,15.32 56.24,15.32 55.99,15.08 46.65,15.08 45.1,16.63 44.93,16.63 44.18,16.63 43.22,17.59 42.16,17.59 40.49,19.27 v2(40.49,19.71)
  L6 w0.127: v2(184.33,23.77) 184.32,23.77 184.32,23.79 184.09,23.55 177.26,23.55 173.18,19.48 173.18,19.27 172.51,18.59 170.81,18.59 170.32,19.08 161.29,19.08 159.25,21.12 154.52,21.12 153.86,20.46 148.05,20.46 147.84,20.67 139.8,20.67 136.36,24.1 134.67,24.1 v2(134.24,23.67) 133.98,23.41 132.09,23.41 130.88,22.2 125.27,22.2 123.38,24.1 120.53,24.1 119.26,25.36 119.26,25.72 119,25.98 118.41,25.98 113.18,31.21 105.02,31.21 101.94,34.29 101.94,38.01 102.9,38.97 v2(102.92,38.97)
  BOTTOM w0.076: CPU1.BU36 102,43.46 101.9,43.17 101.76,42.79 101.75,42.75 101.75,40.7 102.2,40.1
  BOTTOM w0.127: U4008.1 131.98,32.2 132.84,31.35 133.76,31.35 v1(133.81,31.3) 134.12,30.99 134.12,26.83 134.46,26.49 136,24.95 136.63,24.33 136.63,22.81 136.44,22.62 135.17,22.62 134.24,23.55 v2(134.24,23.67) ; v2(102.92,38.97) 102.2,39.69 102.2,40.1 ; R4010.1 69.3,11.56 v2(69.64,11.22)
PM_SLP_S4#: length 356.7
  TOP w0.127: v2(133.27,81.65) 133.31,81.69 R4024.1
  L3 w0.127: v2(147.71,8.44) 149.5,10.22 150.85,10.22 151.02,10.39 151.8,10.39 152.66,11.26 154.88,11.26 155.8,10.33 158.34,10.33 159.13,9.55 166.19,9.55 168.75,12.11 171.45,12.11 v2(175.28,15.94) ; v2(159.18,43.66) 158.06,43.66 142.75,58.97 142.75,63.11 140.33,65.54 136.51,65.54 135.32,66.73 135.32,74.35 v2(134.81,74.87)
  L5 w0.127: 31.47,34.21 31.47,34.4 31,34.87 30.6,34.87 30.48,34.75 29.19,34.75 28.89,34.45 27.32,34.45 v2(26.68,33.81) ; 31.47,34.21 32.79,32.88 35.84,32.88 35.89,32.83 36.26,32.83 36.31,32.88 41.4,32.88 45.48,36.97 49.69,36.97 52.68,39.95 52.68,42.69 58.1,48.12 62.81,48.12 64.82,50.14 69.65,50.14 70.55,51.04 73.13,51.04 74.32,49.85 99.17,49.85 99.35,50.02 99.71,50.02 99.97,49.76 99.97,48.54 100.44,48.08 101.62,48.08 v2(102.45,48.91) ; 31.47,34.21 v2(31.5,34.21)
  L6 w0.127: v2(31.5,34.21) 31.5,28.44 31.24,28.17 31.24,26.07 31.85,25.46 31.85,18.65 34.99,15.51 34.99,14.18 35.82,13.34 37.25,13.34 39.52,11.07 58.86,11.07 59.5,11.71 65.5,11.71 66.35,10.87 67.2,10.87 67.99,11.66 71.08,11.66 71.35,11.93 80.21,11.93 80.41,11.73 89.13,11.73 89.13,11.73 89.5,11.73 89.51,11.73 96.27,11.73 97.12,10.87 99.44,8.55 99.69,8.3 121.4,8.3 122.53,7.17 146.45,7.17 v2(147.71,8.44)
  L8 w0.127: v2(175.28,15.94) 175.28,17.46 169.56,23.19 169.29,23.19 167.29,25.19 167.29,26.14 166.08,27.34 165.13,27.34 163.04,29.43 162.49,29.43 161.9,30.03 161.9,30.04 161.64,30.3 161.63,30.3 160.56,31.37 160.56,32.87 160.48,32.87 158.09,35.26 158.09,36.62 160.72,39.25 160.72,41.74 159.18,43.29 v2(159.18,43.66) ; v2(134.81,74.87) 134.47,74.53 133.62,74.53 132.82,75.34 132.82,75.94 132.79,75.97 132.79,81.17 v2(133.27,81.65)
  BOTTOM w0.127: v2(133.27,81.65) 133.29,81.67 v1(133.29,82.26) ; CPU1.BU27 102.22,49.14 v2(102.45,48.91) ; v2(147.71,8.44) 147,8.44 145.51,6.94 Q9202.G ; v2(26.68,33.81) PR5153.1
PM_SLP_S5#: length 2.4
  TOP w0.102: v2(101.56,47.48) 101.56,47.48 101.98,47.06 101.98,46.33 TP1710.1
  BOTTOM w0.102: v2(101.56,47.48) 101.56,47.48 101.2,47.84 CPU1.BT29
POWER_SW_IN#: length 8.1
  TOP w0.102: v1(19.55,27.11) 18.67,27.11 R2451.2 18.11,27.1 v2(17.96,26.95)
  BOTTOM w0.102: U2401.127 17.97,25.87 18.26,26.16 18.26,26.64 v2(17.96,26.95) 17.96,27.17 17.71,27.42 16.02,27.42 C2427.1 15.56,27.05 14.81,27.81 R2432.2
PQ44B0_2: length 26.9
  TOP w0.203: PR44B6.2 140.71,2.91 v3(141.17,3.37) 141.29,3.24 141.29,2.81 PC44B2.1 ; PD44B1.K 160.18,2.37 159.61,2.37 159.58,2.34 151.06,2.34 149.92,3.48 149.47,3.48 v3(149.02,3.02) 148.79,2.8 147.99,2.8 v1(147.84,2.65) 147.68,2.8 PQ44B1.2
  L8 w0.203: v3(149.02,3.02) 148.93,2.94 141.56,2.94 141.17,3.33 v3(141.17,3.37)
PQ44B0_6: length 4.2
  TOP w0.203: PR44B5.1 145.69,4.13 145.69,3.18 145.31,2.8 PQ44B1.5 ; PQ44B1.5 PQ44B1.6 ; PQ44B1.5 144.12,2.8 v1(143.8,2.48)
