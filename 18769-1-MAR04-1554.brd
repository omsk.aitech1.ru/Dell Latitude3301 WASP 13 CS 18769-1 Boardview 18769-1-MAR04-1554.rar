# Allegro board 18769-1-MAR04-1554.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201H13
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
C402H22
  custom 0.114x0.114 smd: 1(0,0.457) 2(0,-0.457)
C603H35
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H36
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H40
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C805H54
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C805H58
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CSP15G154256H24
  round 0.356 smd: A1(0.5,1) A2(0,1) A3(-0.5,1) B1(0.5,0.5) B2(0,0.5) B3(-0.5,0.5) C1(0.5,0) C2(0,0) C3(-0.5,0) D1(0.5,-0.5) D2(0,-0.5) D3(-0.5,-0.5) E1(0.5,-1) E2(0,-1) E3(-0.5,-1)
CT7343H83
  rect 2.413x1.905 smd: 1(0,2.959) 2(0,-2.959)
D4724AKH44
  rect 2.007x1.295 smd: A(0,2.094) K(0,-2.094)
DF30FC-20DP-D4V-81
  rect 0.203x0.787 smd: 1(-1.8,-1.412) 2(-1.8,1.412) 3(-1.4,-1.412) 4(-1.4,1.412) 5(-1,-1.412) 6(-1,1.412) 7(-0.6,-1.412) 8(-0.6,1.412) 9(-0.2,-1.412) 10(-0.2,1.412) 11(0.2,-1.412) 12(0.2,1.412) 13(0.6,-1.412) 14(0.6,1.412) 15(1,-1.412) 16(1,1.412) 17(1.4,-1.412) 18(1.4,1.412) 19(1.8,-1.412) 20(1.8,1.412)
DF40C-40DP-D4V-51
  rect 0.203x0.66 smd: 1(-3.8,1.401) 2(-3.8,-1.401) 3(-3.4,1.401) 4(-3.4,-1.401) 5(-3,1.401) 6(-3,-1.401) 7(-2.6,1.401) 8(-2.6,-1.401) 9(-2.2,1.401) 10(-2.2,-1.401) 11(-1.8,1.401) 12(-1.8,-1.401) 13(-1.4,1.401) 14(-1.4,-1.401) 15(-1,1.401) 16(-1,-1.401) 17(-0.6,1.401) 18(-0.6,-1.401) 19(-0.2,1.401) 20(-0.2,-1.401) 21(0.2,1.401) 22(0.2,-1.401) 23(0.6,1.401) 24(0.6,-1.401) 25(1,1.401) 26(1,-1.401) 27(1.4,1.401) 28(1.4,-1.401) 29(1.8,1.401) 30(1.8,-1.401) 31(2.2,1.401) 32(2.2,-1.401) 33(2.6,1.401) 34(2.6,-1.401) 35(3,1.401) 36(3,-1.401) 37(3.4,1.401) 38(3.4,-1.401) 39(3.8,1.401) 40(3.8,-1.401)
  rect 0.356x0.66 smd: 41(-4.275,1.401) 42(-4.275,-1.401) 43(4.275,1.401) 44(4.275,-1.401)
DFN8-G125065H32
  rect 0.305x0.711 smd: 1(0.75,0.965) 2(0.25,0.965) 3(-0.25,0.965) 4(-0.75,0.965) 5(-0.75,-0.965) 6(-0.25,-0.965) 7(0.25,-0.965) 8(0.75,-0.965)
  rect 1.245x0.66 smd: 9(0,0)
DFN8F3-G2517H32
  rect 0.406x0.686 smd: 1(0.975,1.411) 2(0.325,1.411) 3(-0.325,1.411) 4(-0.975,1.411) 5(-0.975,-1.411)
  rect 0.025x0.025 smd: 6(-0.325,-1.411) 8(0.975,-1.411)
  custom 0.171x0.171 smd: 7(0.325,-1.411)
  rect 2.489x1.676 smd: 9(0,0)
DFN8G2-G1710-U1H40
  rect 0.305x0.559 smd: 1(0.75,1.043) 2(0.25,1.043) 3(-0.25,1.043) 4(-0.75,1.043) 5(-0.75,-1.043) 6(-0.25,-1.043) 7(0.25,-1.043) 8(0.75,-1.043)
  rect 1.702x0.94 smd: 9(0,0)
DFN10G2510-1H20
  rect 0.305x0.635 smd: 1(1,0.437) 2(0.5,0.437) 3(0,0.437) 4(-0.5,0.437) 5(-1,0.437) 6(-1,-0.437) 7(-0.5,-0.437) 8(0,-0.437) 9(0.5,-0.437) 10(1,-0.437)
FH52-8S-D5SH
  rect 0.305x0.838 smd: 1(-1.75,3.175) 2(-1.25,3.175) 3(-0.75,3.175) 4(-0.25,3.175) 5(0.25,3.175) 6(0.75,3.175) 7(1.25,3.175) 8(1.75,3.175)
  rect 0.813x2.007 smd: 9(3.45,0) 10(-3.45,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
HOLE233R142
  round 5.918 hole 3.607: 1(0,0)
HOLE276R150
  round 7.01 hole 3.81: 1(0,0)
HOLET237B213R142
  round 6.02 hole 3.607: 1(0,0)
L603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
L2520-D620H48
  rect 2.261x1.118 smd: 1(0,0.955) 2(0,-0.955)
L4947-1115H119
  rect 2.007x2.007 smd: 1(0,1.922) 2(0,-1.922)
L7066-1830-UH119
  rect 3.505x2.667 smd: 1(0,2.653) 2(0,-2.653)
L7366-1830H119
  rect 3.505x2.692 smd: 1(0,2.815) 2(0,-2.815)
L20125H42
  rect 1.346x0.94 smd: 1(0,0.838) 2(0,-0.838)
L109100-2430-UH119
  rect 3.505x3.302 smd: 1(0,4.27) 2(0,-4.27)
LD85D65-4P-1H20
  rect 0.533x0.33 smd: 1(0.382,0.29) 2(0.382,-0.29) 3(-0.382,-0.29) 4(-0.382,0.29)
LED3020-3P-19H44
  rect 1.499x0.991 smd: 1(0,1.5) 3(0,-1.5)
  rect 0.889x0.889 smd: 2(0.65,0)
LGA12G2H40
  rect 0.381x0.381 smd: 1(0.809,0.809) 4(-0.809,0.809) 7(-0.809,-0.809) 10(0.809,-0.809)
  rect 0.305x0.432 smd: 2(0.25,0.784) 3(-0.25,0.784) 8(-0.25,-0.784) 9(0.25,-0.784)
  rect 0.432x0.305 smd: 5(-0.784,0.25) 6(-0.784,-0.25) 11(0.784,-0.25) 12(0.784,0.25)
LQFP128H48
  rect 0.203x1.27 smd: 1(6.2,7.62) 2(5.8,7.62) 3(5.4,7.62) 4(5,7.62) 5(4.6,7.62) 6(4.2,7.62) 7(3.8,7.62) 8(3.4,7.62) 9(3,7.62) 10(2.6,7.62) 11(2.2,7.62) 12(1.8,7.62) 13(1.4,7.62) 14(1,7.62) 15(0.6,7.62) 16(0.2,7.62) 17(-0.2,7.62) 18(-0.6,7.62) 19(-1,7.62) 20(-1.4,7.62) 21(-1.8,7.62) 22(-2.2,7.62) 23(-2.6,7.62) 24(-3,7.62) 25(-3.4,7.62) 26(-3.8,7.62) 27(-4.2,7.62) 28(-4.6,7.62) 29(-5,7.62) 30(-5.4,7.62) 31(-5.8,7.62) 32(-6.2,7.62) 65(-6.2,-7.62) 66(-5.8,-7.62) 67(-5.4,-7.62) 68(-5,-7.62) 69(-4.6,-7.62) 70(-4.2,-7.62) 71(-3.8,-7.62) 72(-3.4,-7.62) 73(-3,-7.62) 74(-2.6,-7.62) 75(-2.2,-7.62) 76(-1.8,-7.62) 77(-1.4,-7.62) 78(-1,-7.62) 79(-0.6,-7.62) 80(-0.2,-7.62) 81(0.2,-7.62) 82(0.6,-7.62) 83(1,-7.62) 84(1.4,-7.62) 85(1.8,-7.62) 86(2.2,-7.62) 87(2.6,-7.62) 88(3,-7.62) 89(3.4,-7.62) 90(3.8,-7.62) 91(4.2,-7.62) 92(4.6,-7.62) 93(5,-7.62) 94(5.4,-7.62) 95(5.8,-7.62) 96(6.2,-7.62)
  rect 1.27x0.203 smd: 33(-7.62,6.2) 34(-7.62,5.8) 35(-7.62,5.4) 36(-7.62,5) 37(-7.62,4.6) 38(-7.62,4.2) 39(-7.62,3.8) 40(-7.62,3.4) 41(-7.62,3) 42(-7.62,2.6) 43(-7.62,2.2) 44(-7.62,1.8) 45(-7.62,1.4) 46(-7.62,1) 47(-7.62,0.6) 48(-7.62,0.2) 49(-7.62,-0.2) 50(-7.62,-0.6) 51(-7.62,-1) 52(-7.62,-1.4) 53(-7.62,-1.8) 54(-7.62,-2.2) 55(-7.62,-2.6) 56(-7.62,-3) 57(-7.62,-3.4) 58(-7.62,-3.8) 59(-7.62,-4.2) 60(-7.62,-4.6) 61(-7.62,-5) 62(-7.62,-5.4) 63(-7.62,-5.8) 64(-7.62,-6.2) 97(7.62,-6.2) 98(7.62,-5.8) 99(7.62,-5.4) 100(7.62,-5) 101(7.62,-4.6) 102(7.62,-4.2) 103(7.62,-3.8) 104(7.62,-3.4) 105(7.62,-3) 106(7.62,-2.6) 107(7.62,-2.2) 108(7.62,-1.8) 109(7.62,-1.4) 110(7.62,-1) 111(7.62,-0.6) 112(7.62,-0.2) 113(7.62,0.2) 114(7.62,0.6) 115(7.62,1) 116(7.62,1.4) 117(7.62,1.8) 118(7.62,2.2) 119(7.62,2.6) 120(7.62,3) 121(7.62,3.4) 122(7.62,3.8) 123(7.62,4.2) 124(7.62,4.6) 125(7.62,5) 126(7.62,5.4) 127(7.62,5.8) 128(7.62,6.2)
MSOP8-1H44
  rect 0.356x1.397 smd: 1(-0.975,-1.991) 2(-0.325,-1.991) 3(0.325,-1.991) 4(0.975,-1.991) 5(0.975,1.991) 6(0.325,1.991) 7(-0.325,1.991) 8(-0.975,1.991)
MSS3-Q-T-R
  round 0.254 hole 0.965 unplated: (-1.5,0) (1.5,0)
  rect 0.61x1.499 smd: 1(-2.25,1.75) 2(0.751,1.75) 3(2.25,1.75)
  rect 0.991x0.813 smd: 4(-3.65,1.056) 5(-3.65,-1.056) 6(3.65,1.056) 7(3.65,-1.056)
NFSM0-S6701-TP20
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.225) 3(-8.75,5.225) 5(-8.25,5.225) 7(-7.75,5.225) 9(-7.25,5.225) 11(-6.75,5.225) 13(-6.25,5.225) 15(-5.75,5.225) 17(-5.25,5.225) 19(-4.75,5.225) 21(-4.25,5.225) 23(-3.75,5.225) 25(-3.25,5.225) 27(-2.75,5.225) 29(-2.25,5.225) 31(-1.75,5.225) 33(-1.25,5.225) 35(-0.75,5.225) 37(-0.25,5.225) 39(0.25,5.225) 41(0.75,5.225) 43(1.25,5.225) 45(1.75,5.225) 47(2.25,5.225) 49(2.75,5.225) 51(3.25,5.225) 53(3.75,5.225) 55(4.25,5.225) 57(4.75,5.225) 67(7.25,5.225) 69(7.75,5.225) 71(8.25,5.225) 73(8.75,5.225) 75(9.25,5.225)
  rect 0.305x0.838 smd: 2(-9,-2.375) 4(-8.5,-2.375) 6(-8,-2.375) 8(-7.5,-2.375) 10(-7,-2.375) 12(-6.5,-2.375) 14(-6,-2.375) 16(-5.5,-2.375) 18(-5,-2.375) 20(-4.5,-2.375) 22(-4,-2.375) 24(-3.5,-2.375) 26(-3,-2.375) 28(-2.5,-2.375) 30(-2,-2.375) 32(-1.5,-2.375) 34(-1,-2.375) 36(-0.5,-2.375) 38(0,-2.375) 40(0.5,-2.375) 42(1,-2.375) 44(1.5,-2.375) 46(2,-2.375) 48(2.5,-2.375) 50(3,-2.375) 52(3.5,-2.375) 54(4,-2.375) 56(4.5,-2.375) 58(5,-2.375) 68(7.5,-2.375) 70(8,-2.375) 72(8.5,-2.375) 74(9,-2.375)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NTC-402H22-U
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
OSC-3225-4P-3H36
  rect 1.27x0.914 smd: 1(-1.108,-0.825) 2(1.108,-0.825) 3(1.108,0.825) 4(-1.108,0.825)
POLYSW-2114H30
  rect 1.6x0.889 smd: 1(0,0.865) 2(0,-0.865)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-8P-3232H36
  rect 0.406x0.66 smd: 1(-0.975,-2.142) 2(-0.325,-2.142) 3(0.325,-2.142) 4(0.975,-2.142)
  rect 3.353x2.438 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-3232H40
  rect 0.406x0.66 smd: 1(-0.975,-2.142) 2(-0.325,-2.142) 3(0.325,-2.142) 4(0.975,-2.142)
  rect 3.353x2.438 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-G5324H44-COLAY
  rect 0.762x0.889 smd: 1(-1.905,-2.946) 2(-0.635,-2.946) 3(0.635,-2.946) 4(1.905,-2.946) 5(1.905,2.946) 6(0.635,2.946) 7(-0.635,2.946) 8(-1.905,2.946)
  rect 5.207x2.896 smd: 9(0,0.65)
  rect 5.207x0.787 smd: 10(0,-1.7)
QFN20-G1D75H32
  rect 0.203x0.66 smd: 1(0.8,1.487) 2(0.4,1.487) 3(0,1.487) 4(-0.4,1.487) 5(-0.8,1.487) 11(-0.8,-1.487) 12(-0.4,-1.487) 13(0,-1.487) 14(0.4,-1.487) 15(0.8,-1.487)
  rect 0.66x0.203 smd: 6(-1.487,0.8) 7(-1.487,0.4) 8(-1.487,0) 9(-1.487,-0.4) 10(-1.487,-0.8) 16(1.487,-0.8) 17(1.487,-0.4) 18(1.487,0) 19(1.487,0.4) 20(1.487,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20Z3-G1D1H36
  custom 0.064x0.064 smd: 1(0.9,1.297) 5(-0.9,1.297) 6(-1.297,0.9) 10(-1.297,-0.9) 11(-0.9,-1.297) 15(0.9,-1.297) 16(1.297,-0.9) 20(1.297,0.9)
  rect 0.254x0.914 smd: 2(0.45,1.297) 3(0,1.297) 4(-0.45,1.297) 12(-0.45,-1.297) 13(0,-1.297) 14(0.45,-1.297)
  rect 0.914x0.254 smd: 7(-1.297,0.45) 8(-1.297,0) 9(-1.297,-0.45) 17(1.297,-0.45) 18(1.297,0) 19(1.297,0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN20Z3-G1H36
  custom 0.064x0.064 smd: 1(0.9,1.297) 5(-0.9,1.297) 6(-1.297,0.9) 10(-1.297,-0.9) 11(-0.9,-1.297) 15(0.9,-1.297) 16(1.297,-0.9) 20(1.297,0.9)
  rect 0.254x0.914 smd: 2(0.45,1.297) 3(0,1.297) 4(-0.45,1.297) 12(-0.45,-1.297) 13(0,-1.297) 14(0.45,-1.297)
  rect 0.914x0.254 smd: 7(-1.297,0.45) 8(-1.297,0) 9(-1.297,-0.45) 17(1.297,-0.45) 18(1.297,0) 19(1.297,0.45)
  rect 0.991x0.991 smd: 21(0,0)
QFN22G4-G2PH42
  rect 0.305x0.66 smd: 1(1.25,1.924) 2(0.75,1.924) 3(0.25,1.924) 4(-0.25,1.924) 5(-0.75,1.924) 6(-1.25,1.924) 16(0.75,-1.924) 17(1.25,-1.924)
  custom 0.326x0.326 smd: 7(-1.924,1.25)
  rect 0.025x0.025 smd: 8(-1.924,0.75) 9(-1.924,0.25) 10(-1.924,-0.75) 13(-0.75,-1.924) 14(-0.25,-1.924) 15(0.25,-1.924)
  custom 0.232x0.232 smd: 11(-1.924,-1.25)
  custom 0.165x0.165 smd: 12(-1.25,-1.924)
  rect 0.66x0.305 smd: 18(1.924,-1.25) 19(1.924,-0.75) 20(1.924,-0.25) 21(1.924,0.25) 22(1.924,1.25)
QFN31G5-G4P-9H34
  rect 0.305x0.66 smd: 1(1.75,2.424) 2(1.25,2.424) 3(0.75,2.424) 4(0.25,2.424) 5(-0.25,2.424) 6(-0.75,2.424) 7(-1.25,2.424) 8(-1.75,2.424)
  rect 0.025x0.025 smd: 9(-2.424,1.75) 10(-2.424,1.25) 11(-2.424,0.75) 12(-2.424,-0.25) 13(-2.424,-0.75) 14(-2.424,-1.25) 15(-2.424,-1.75) 17(-1.25,-2.424) 18(-0.75,-2.424) 19(-0.25,-2.424) 20(0.25,-2.424) 21(0.75,-2.424) 22(1.25,-2.424) 23(1.75,-2.424) 25(2.424,-1.25) 26(2.424,-0.75)
  custom 0.165x0.165 smd: 16(-1.75,-2.424) 24(2.424,-1.75)
  rect 0.61x0.305 smd: 27(2.424,-0.25)
  rect 0.66x0.305 smd: 28(2.424,0.25) 29(2.424,0.75) 30(2.424,1.25) 31(2.424,1.75)
  rect 1.422x1.143 smd: 32(1.038,1.183)
  custom 0.326x0.326 smd: 33(-1.175,1.183)
  custom 0.542x0.542 smd: 34(-0.669,-0.742)
  rect 0.559x0.406 smd: 35(1.66,-0.25)
QFN32G5-G3D6H32
  rect 0.305x0.66 smd: 1(1.75,2.487) 8(-1.75,2.487) 17(-1.75,-2.487) 24(1.75,-2.487)
  rect 0.305x0.737 smd: 2(1.25,2.449) 3(0.75,2.449) 4(0.25,2.449) 5(-0.25,2.449) 6(-0.75,2.449) 7(-1.25,2.449) 18(-1.25,-2.449) 19(-0.75,-2.449) 20(-0.25,-2.449) 21(0.25,-2.449) 22(0.75,-2.449) 23(1.25,-2.449)
  rect 0.66x0.305 smd: 9(-2.487,1.75) 16(-2.487,-1.75) 25(2.487,-1.75) 32(2.487,1.75)
  rect 0.737x0.305 smd: 10(-2.449,1.25) 11(-2.449,0.75) 12(-2.449,0.25) 13(-2.449,-0.25) 14(-2.449,-0.75) 15(-2.449,-1.25) 26(2.449,-1.25) 27(2.449,-0.75) 28(2.449,-0.25) 29(2.449,0.25) 30(2.449,0.75) 31(2.449,1.25)
  rect 3.607x3.607 smd: 33(0,0)
QFN32J4-G2D85H34
  rect 0.203x0.61 smd: 1(1.4,1.958) 2(1,1.958) 3(0.6,1.958) 4(0.2,1.958) 5(-0.2,1.958) 6(-0.6,1.958) 7(-1,1.958) 8(-1.4,1.958) 17(-1.4,-1.958) 18(-1,-1.958) 19(-0.6,-1.958) 20(-0.2,-1.958) 21(0.2,-1.958) 22(0.6,-1.958) 23(1,-1.958) 24(1.4,-1.958)
  rect 0.61x0.203 smd: 9(-1.958,1.4) 10(-1.958,1) 11(-1.958,0.6) 12(-1.958,0.2) 13(-1.958,-0.2) 14(-1.958,-0.6) 15(-1.958,-1) 16(-1.958,-1.4) 25(1.958,-1.4) 26(1.958,-1) 27(1.958,-0.6) 28(1.958,-0.2) 29(1.958,0.2) 30(1.958,0.6) 31(1.958,1) 32(1.958,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN32J4-G2D85H36
  rect 0.203x0.61 smd: 1(1.4,1.958) 2(1,1.958) 3(0.6,1.958) 4(0.2,1.958) 5(-0.2,1.958) 6(-0.6,1.958) 7(-1,1.958) 8(-1.4,1.958) 17(-1.4,-1.958) 18(-1,-1.958) 19(-0.6,-1.958) 20(-0.2,-1.958) 21(0.2,-1.958) 22(0.6,-1.958) 23(1,-1.958) 24(1.4,-1.958)
  rect 0.61x0.203 smd: 9(-1.958,1.4) 10(-1.958,1) 11(-1.958,0.6) 12(-1.958,0.2) 13(-1.958,-0.2) 14(-1.958,-0.6) 15(-1.958,-1) 16(-1.958,-1.4) 25(1.958,-1.4) 26(1.958,-1) 27(1.958,-0.6) 28(1.958,-0.2) 29(1.958,0.2) 30(1.958,0.6) 31(1.958,1) 32(1.958,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN32J4-G3P-1UH32
  rect 0.203x0.559 smd: 1(1.4,1.975) 2(1,1.975) 3(0.6,1.975) 4(0.2,1.975) 5(-0.2,1.975) 6(-0.6,1.975) 7(-1,1.975) 8(-1.4,1.975) 21(0.2,-1.975) 22(0.6,-1.975) 23(1,-1.975) 24(1.4,-1.975)
  rect 0.559x0.203 smd: 9(-1.975,1.4) 10(-1.975,1) 25(1.975,-1.4) 26(1.975,-1) 27(1.975,-0.6) 28(1.975,-0.2) 29(1.975,0.2) 30(1.975,0.6) 31(1.975,1) 32(1.975,1.4)
  rect 0.025x0.025 smd: 11(-1.975,0.6) 12(-1.975,0.2) 13(-1.975,-0.2) 14(-1.975,-0.6) 15(-1.975,-1) 17(-1.4,-1.975) 18(-1,-1.975) 19(-0.6,-1.975) 20(-0.2,-1.975)
  custom 0.14x0.14 smd: 16(-1.975,-1.4)
  rect 1.143x1.194 smd: 33(0.908,0.872)
  rect 1.092x1.499 smd: 34(0.925,-0.732)
  custom 0.418x0.418 smd: 35(-0.655,0)
QFN40J5-G3D6-DIFF-H34
  rect 0.203x0.66 smd: 1(1.8,2.388) 10(-1.8,2.388) 21(-1.8,-2.388) 30(1.8,-2.388)
  rect 0.203x0.737 smd: 2(1.4,2.388) 3(1,2.388) 4(0.6,2.388) 5(0.2,2.388) 6(-0.2,2.388) 7(-0.6,2.388) 8(-1,2.388) 9(-1.4,2.388) 22(-1.4,-2.388) 23(-1,-2.388) 24(-0.6,-2.388) 25(-0.2,-2.388) 26(0.2,-2.388) 27(0.6,-2.388) 28(1,-2.388) 29(1.4,-2.388)
  rect 0.66x0.203 smd: 11(-2.388,1.8) 20(-2.388,-1.8) 31(2.388,-1.8) 40(2.388,1.8)
  rect 0.737x0.203 smd: 12(-2.388,1.4) 13(-2.388,1) 14(-2.388,0.6) 15(-2.388,0.2) 16(-2.388,-0.2) 17(-2.388,-0.6) 18(-2.388,-1) 19(-2.388,-1.4) 32(2.388,-1.4) 33(2.388,-1) 34(2.388,-0.6) 35(2.388,-0.2) 36(2.388,0.2) 37(2.388,0.6) 38(2.388,1) 39(2.388,1.4)
  rect 3.607x3.607 smd: 41(0,0)
QFN40J5-G3D75H36
  rect 0.203x0.66 smd: 1(1.8,2.489) 2(1.4,2.489) 3(1,2.489) 4(0.6,2.489) 5(0.2,2.489) 6(-0.2,2.489) 7(-0.6,2.489) 8(-1,2.489) 9(-1.4,2.489) 10(-1.8,2.489) 21(-1.8,-2.489) 22(-1.4,-2.489) 23(-1,-2.489) 24(-0.6,-2.489) 25(-0.2,-2.489) 26(0.2,-2.489) 27(0.6,-2.489) 28(1,-2.489) 29(1.4,-2.489) 30(1.8,-2.489)
  rect 0.66x0.203 smd: 11(-2.489,1.8) 12(-2.489,1.4) 13(-2.489,1) 14(-2.489,0.6) 15(-2.489,0.2) 16(-2.489,-0.2) 17(-2.489,-0.6) 18(-2.489,-1) 19(-2.489,-1.4) 20(-2.489,-1.8) 31(2.489,-1.8) 32(2.489,-1.4) 33(2.489,-1) 34(2.489,-0.6) 35(2.489,-0.2) 36(2.489,0.2) 37(2.489,0.6) 38(2.489,1) 39(2.489,1.4) 40(2.489,1.8)
  rect 3.759x3.759 smd: 41(0,0)
QFN40J4060-G2848H32
  rect 0.203x0.635 smd: 1(1.4,2.936) 2(1,2.936) 3(0.6,2.936) 4(0.2,2.936) 5(-0.2,2.936) 6(-0.6,2.936) 7(-1,2.936) 8(-1.4,2.936) 21(-1.4,-2.936) 22(-1,-2.936) 23(-0.6,-2.936) 24(-0.2,-2.936) 25(0.2,-2.936) 26(0.6,-2.936) 27(1,-2.936) 28(1.4,-2.936)
  rect 0.635x0.203 smd: 9(-1.936,2.2) 10(-1.936,1.8) 11(-1.936,1.4) 12(-1.936,1) 13(-1.936,0.6) 14(-1.936,0.2) 15(-1.936,-0.2) 16(-1.936,-0.6) 17(-1.936,-1) 18(-1.936,-1.4) 19(-1.936,-1.8) 20(-1.936,-2.2) 29(1.936,-2.2) 30(1.936,-1.8) 31(1.936,-1.4) 32(1.936,-1) 33(1.936,-0.6) 34(1.936,-0.2) 35(1.936,0.2) 36(1.936,0.6) 37(1.936,1) 38(1.936,1.4) 39(1.936,1.8) 40(1.936,2.2)
  rect 2.794x4.801 smd: 41(0,0)
R0201H12
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
R402-TO0D2H20
  custom 0.152x0.152 smd: 1(0,0.457) 2(0,-0.457)
R402H14
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R402H15
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R402H16
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R603H22
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R603H24
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R805H24
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
R1206H26
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
R1206H28
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
R1206H38
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
RL3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-5H44
  rect 0.356x0.762 smd: 1(0.65,0.935) 2(0,0.935) 3(-0.65,0.935) 4(-0.65,-0.935) 5(0.65,-0.935)
SKT-HDMI23-178125-2
  oval 0.762x0.914 hole 0.508: 1(-4.5,6.08) 2(-4,7.58) 3(-3.5,6.08) 4(-3,7.58) 5(-2.5,6.08) 6(-2,7.58) 7(-1.5,6.08) 8(-1,7.58) 9(-0.5,6.08) 10(0,7.58) 11(0.5,6.08) 12(1,7.58) 13(1.5,6.08) 14(2,7.58) 15(2.5,6.08) 16(3,7.58) 17(3.5,6.08) 18(4,7.58) 19(4.5,6.08)
  oval 1.626x3.073 hole 0.914x2.464: 20(-7.25,6.98) 21(7.25,6.98)
  rect 1.549x2.388 smd: 22(-8.625,0) 23(8.625,0)
SKT-USB34-124103-U1
  round 0.254 hole 0.762 unplated: (-3.45,5.8) (3.45,5.8)
  oval 1.321x2.134 hole 0.61x1.6: 13(-6.075,0) 22(6.075,0)
  oval 1.321x2.311 hole 0.61x1.6: 14(-6.075,3.865) 21(6.075,3.865)
  oval 1.041x1.829 hole 0.508x1.118: 15(-4.475,6.2) 20(4.475,6.2)
  custom 0.076x0.076 smd: 16(-3.2,6.49) 19(3.2,6.49) A1(-2.75,5.74) A12(2.75,5.74)
  rect 0.508x0.305 smd: 17(-1,6.49) 18(1,6.49)
  rect 0.305x0.61 smd: A2(-2.25,5.74) A3(-1.75,5.74) A4(-1.25,5.74) A5(-0.75,5.74) A6(-0.25,5.74) A7(0.25,5.74) A8(0.75,5.74) A9(1.25,5.74) A10(1.75,5.74) A11(2.25,5.74)
  oval 1.626x0.991 hole 1.016x0.508: B1(3.2,4.665) B12(-3.2,4.665)
  round 0.66 hole 0.406: B2(2.5,3.765) B3(1.7,3.765) B4(1.3,4.665) B5(0.85,3.765) B6(0.4,4.665) B7(-0.4,4.665) B8(-0.85,3.765) B9(-1.3,4.665) B10(-1.7,3.765) B11(-2.5,3.765)
SLP2510P8-1H22
  rect 0.305x0.635 smd: 1(-1,-0.437) 5(1,-0.437) 6(1,0.437) 10(-1,0.437)
  rect 0.203x0.635 smd: 2(-0.5,-0.437) 4(0.5,-0.437) 7(0.5,0.437) 9(-0.5,0.437)
  rect 0.406x0.635 smd: 3(0,-0.437) 8(0,0.437)
SMD49-12H34
  rect 1.753x1.27 smd: 1(0,1.231) 2(0,-1.231)
SMD-ARES4
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SMD-ARES4H18
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SMD-ARES4H20
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SMD-OSC38H32
  rect 0.965x0.737 smd: 1(-0.706,-0.495) 2(0.706,-0.495) 3(0.706,0.495) 4(-0.706,0.495)
SOD123AK-2H43
  rect 1.143x1.245 smd: A(0,1.631) K(0,-1.631)
SOD323-2513AKH36
  rect 0.559x1.041 smd: A(0,0.987) K(0,-0.987)
SOD323AKH38
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD323AKH40
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD323AKH44
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD523AKH26
  rect 0.559x0.813 smd: A(0,0.66) K(0,-0.66)
SOD882-10D6-1H20
  rect 0.61x0.457 smd: 1(0,0.457) 2(0,-0.457)
SOIC8-1H86
  rect 0.635x1.524 smd: 1(-1.905,-3.442) 2(-0.635,-3.442) 3(0.635,-3.442) 4(1.905,-3.442) 5(1.905,3.442) 6(0.635,3.442) 7(-0.635,3.442) 8(-1.905,3.442)
SOIC8-G3530H63
  rect 0.635x1.524 smd: 1(-1.905,-2.492) 2(-0.635,-2.492) 3(0.635,-2.492) 4(1.905,-2.492) 5(1.905,2.492) 6(0.635,2.492) 7(-0.635,2.492) 8(-1.905,2.492)
  rect 3.505x2.997 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.524 smd: 1(-1.905,-2.477) 2(-0.635,-2.477) 3(0.635,-2.477) 4(1.905,-2.477) 5(1.905,2.477) 6(0.635,2.477) 7(-0.635,2.477) 8(-1.905,2.477)
SON14J3020-G2610H34
  rect 0.025x0.025 smd: 1(1.2,0.978) 6(-0.8,0.978) 9(-0.8,-0.978) 14(1.2,-0.978)
  custom 0.14x0.14 smd: 2(0.8,0.978) 7(-1.2,0.978) 8(-1.2,-0.978) 13(0.8,-0.978)
  rect 0.203x0.559 smd: 3(0.4,0.978) 4(0,0.978) 5(-0.4,0.978) 10(-0.4,-0.978) 11(0,-0.978) 12(0.4,-0.978)
  rect 2.591x0.889 smd: 15(0,0)
SOT23-2D4-312H44
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D4-312H46
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D4-312H60
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D8-312H56
  custom 0.171x0.171 smd: 1(-0.95,-1.21) 2(0.95,-1.21) 3(0,1.21)
SOT23CBE2D4H44
  custom 0.165x0.165 smd: B(-0.95,-1.073) C(0,1.073) E(0.95,-1.073)
SOT23DGS2D4H44
  custom 0.171x0.171 smd: D(0,1.069) G(-0.95,-1.069) S(0.95,-1.069)
SOT23DGS2D4H48
  custom 0.171x0.171 smd: D(0,1.069) G(-0.95,-1.069) S(0.95,-1.069)
SOT323CBE2D2H40
  custom 0.152x0.152 smd: B(-0.65,-0.864) C(0,0.864) E(0.65,-0.864)
SOT-6H58
  rect 0.61x0.813 smd: 1(-0.95,-1.219) 2(0,-1.219) 3(0.95,-1.219) 4(0.95,1.219) 5(0,1.219) 6(-0.95,1.219)
SOT-23-5H52
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H56
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H58
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-9H44
  custom 0.165x0.165 smd: 1(-0.953,-1.056) 2(0.953,-1.056) 3(0,1.056)
SOT-363H44
  rect 0.356x0.965 smd: 1(-0.65,-0.826) 2(0,-0.826) 3(0.65,-0.826) 4(0.65,0.826) 5(0,0.826) 6(-0.65,0.826)
STFT237B158R128H48
  round 4.013 hole 3.251: 1(0,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
unnamed#2
  round 0.254 hole 4.013 unplated: (0,0)

## Nets
1V_CPU_CORE: CPU1.AA9 CPU1.AB2 CPU1.AB8 CPU1.AB9 CPU1.AB10 CPU1.AC8 CPU1.AD9 CPU1.AE8 CPU1.AE9 CPU1.AE10 CPU1.AF2 CPU1.AF8 CPU1.AF10 CPU1.AG8 CPU1.AG9 CPU1.AH9 CPU1.AJ8 CPU1.AJ10 CPU1.AK2 CPU1.AK9 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AM8 CPU1.AN9 CPU1.AN10 CPU1.AN24 CPU1.AN26 CPU1.AN27 CPU1.AP2 CPU1.AP9 CPU1.AP24 CPU1.AP26 CPU1.AR5 CPU1.AR6 CPU1.AR7 CPU1.AR8 CPU1.AR10 CPU1.AR25 CPU1.AR27 CPU1.AT9 CPU1.AT24 CPU1.AT26 CPU1.AU5 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU24 CPU1.AU25 CPU1.AU26 CPU1.AU27 CPU1.AV2 CPU1.AV5 CPU1.AV7 CPU1.AV10 CPU1.AV27 CPU1.AW5 CPU1.AW6 CPU1.AW7 CPU1.AW8 CPU1.AW9 CPU1.AW10 CPU1.AW24 CPU1.AW25 CPU1.AW26 CPU1.AW27 CPU1.AY24 CPU1.AY26 CPU1.BA5 CPU1.BA7 CPU1.BA8 CPU1.BA25 CPU1.BA27 CPU1.BB2 CPU1.BB26 CPU1.BC5 CPU1.BC6 CPU1.BC7 CPU1.BC9 CPU1.BC10 CPU1.BC26 CPU1.BC27 CPU1.BD5 CPU1.BD8 CPU1.BD10 CPU1.BD25 CPU1.BD27 CPU1.BE9 CPU1.BE24 CPU1.BE25 CPU1.BE26 CPU1.BE27 CPU1.BF2 CPU1.BF9 CPU1.BF24 CPU1.BF26 CPU1.BG27 CPU1.V2 CPU1.Y8 CPU1.Y10 EC8902.1 EC8903.1 EC8904.1 EC8937.1 EC8938.1 FC8923.1 FC8924.1 FC8925.1 FC8926.1 FC8960.1 FC8961.1 FC8962.1 FC8963.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1034.1 PC1036.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PG4709.1 PG4715.1 PL4701.2 PL4702.2 PR44A6.1 PR4631.2 PT4701.1 PT4703.1 R719.1
1V_VCCGT: C1102.1 C1103.1 C1104.1 C1105.1 C1106.1 C1107.1 CPU1.A5 CPU1.A6 CPU1.A8 CPU1.A11 CPU1.A12 CPU1.A14 CPU1.A15 CPU1.A17 CPU1.A18 CPU1.A20 CPU1.B3 CPU1.B4 CPU1.B6 CPU1.B8 CPU1.B11 CPU1.B14 CPU1.B17 CPU1.B20 CPU1.C2 CPU1.C3 CPU1.C6 CPU1.C7 CPU1.C8 CPU1.C11 CPU1.C12 CPU1.C14 CPU1.C15 CPU1.C17 CPU1.C18 CPU1.C20 CPU1.D4 CPU1.D7 CPU1.D11 CPU1.D12 CPU1.D14 CPU1.D15 CPU1.D17 CPU1.D18 CPU1.D20 CPU1.E4 CPU1.F5 CPU1.F6 CPU1.F7 CPU1.F8 CPU1.F11 CPU1.F14 CPU1.F17 CPU1.F20 CPU1.G11 CPU1.G12 CPU1.G14 CPU1.G15 CPU1.G17 CPU1.G18 CPU1.G20 CPU1.H5 CPU1.H6 CPU1.H7 CPU1.H8 CPU1.H11 CPU1.H12 CPU1.H14 CPU1.H15 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.J7 CPU1.J8 CPU1.J11 CPU1.J14 CPU1.J17 CPU1.J20 CPU1.K2 CPU1.K11 CPU1.L7 CPU1.L8 CPU1.L10 CPU1.M9 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.P2 CPU1.P8 CPU1.R9 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.U8 CPU1.U10 CPU1.V9 CPU1.W8 CPU1.W9 EC8905.1 EC8906.1 FC8927.1 FC8928.1 FC8964.1 FC8965.1 PC1001.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PG4808.2 PL4801.2 PR4686.1 PT4801.1 R807.1
1V_VCCIO: C1108.1 C1109.1 C1110.1 C1111.1 C1133.1 C1134.1 C1135.1 CPU1.AK24 CPU1.AK26 CPU1.AL24 CPU1.AL25 CPU1.AL26 CPU1.AL27 CPU1.AM25 CPU1.AM27 CPU1.BH24 CPU1.BH25 CPU1.BH26 CPU1.BH27 CPU1.BJ24 CPU1.BJ26 CPU1.BP16 CPU1.BP18 R401.1 R4045.2
1V_VCCIO_R: C4010.1 R4043.1 R4045.1 U4003.6 U4003.7 U4003.8
1V_VCCSA: CPU1.BG8 CPU1.BG10 CPU1.BH9 CPU1.BJ8 CPU1.BJ9 CPU1.BJ10 CPU1.BK8 CPU1.BK25 CPU1.BK27 CPU1.BL8 CPU1.BL9 CPU1.BL10 CPU1.BL24 CPU1.BL26 CPU1.BM24 CPU1.BN25 EC8901.1 EC8907.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PG5001.1 PL5001.2 R810.1
1V_VCCST_CPU: C801.2 C805.1 C806.1 C807.1 CPU1.BP2 CPU1.BP11 CPU1.BR11 CPU1.BT11 PG4601.1 R308.1 R723.1 R726.1 R727.1 R4036.2
1V_VCCST_CPU_R: C4012.1 R4036.1 U4006.6 U4006.7 U4006.8
1V_VCCSTG: C802.2 CPU1.BG1 CPU1.BG2 CPU1.BG3 R301.1 R310.1 R4043.2
1V_VGA_CORE: C7744.1 C7745.1 C7746.1 C8001.1 C8002.1 C8008.1 C8009.1 C8010.1 C8011.1 C8012.1 C8013.1 C8014.1 C8015.1 C8016.1 C8017.1 C8018.1 C8019.1 C8020.1 C8021.1 C8022.1 C8023.1 C8024.1 C8025.1 C8027.1 C8030.1 C8031.1 C8032.1 C8033.1 C8038.1 C8039.1 C8040.1 C8041.1 C8042.1 C8043.1 C8045.1 C8046.1 FC8901.1 FC8902.1 FC8903.1 FC8904.1 FC8905.1 FC8939.1 FC8940.1 FC8941.1 FC8942.1 GPU1.G1 GPU1.G2 GPU1.G3 GPU1.G4 GPU1.G5 GPU1.G6 GPU1.G7 GPU1.H3 GPU1.H4 GPU1.H6 GPU1.J1 GPU1.J2 GPU1.J3 GPU1.J4 GPU1.J5 GPU1.J6 GPU1.J7 GPU1.K1 GPU1.K2 GPU1.K3 GPU1.K4 GPU1.K5 GPU1.K6 GPU1.K7 GPU1.K10 GPU1.K12 GPU1.K14 GPU1.K16 GPU1.K18 GPU1.L3 GPU1.L4 GPU1.L11 GPU1.L13 GPU1.L15 GPU1.L17 GPU1.M1 GPU1.M2 GPU1.M3 GPU1.M4 GPU1.M5 GPU1.M7 GPU1.M10 GPU1.M12 GPU1.M14 GPU1.M16 GPU1.M18 GPU1.N1 GPU1.N2 GPU1.N3 GPU1.N4 GPU1.N5 GPU1.N7 GPU1.N11 GPU1.N13 GPU1.N15 GPU1.N17 GPU1.P3 GPU1.P4 GPU1.P6 GPU1.P10 GPU1.P12 GPU1.P14 GPU1.P16 GPU1.P18 GPU1.R1 GPU1.R2 GPU1.R3 GPU1.R4 GPU1.R5 GPU1.R6 GPU1.R7 GPU1.R11 GPU1.R13 GPU1.R15 GPU1.R17 GPU1.T1 GPU1.T2 GPU1.T3 GPU1.T4 GPU1.T5 GPU1.T6 GPU1.T7 GPU1.T10 GPU1.T12 GPU1.T14 GPU1.T16 GPU1.T18 GPU1.U3 GPU1.U4 GPU1.U6 GPU1.U11 GPU1.U13 GPU1.U15 GPU1.U17 GPU1.V1 GPU1.V2 GPU1.V3 GPU1.V4 GPU1.V5 GPU1.V6 GPU1.V10 GPU1.V12 GPU1.V14 GPU1.V16 GPU1.V18 GPU1.W1 GPU1.W2 GPU1.W3 GPU1.W4 PC8558.1 PC8559.1 PC8570.1 PC8571.1 PL8551.2 PL8552.2 PR8577.2 PT8553.1 PT8555.1 R8624.1
1V_VGA_EN_B: R8617.2 U8604.2
1V_VGA_EN_OR: Q8509.2 R8523.2 R8524.2
1V_VGA_EN_R: C8603.1 PU8603.7 Q8615.2 R8523.1 R8615.2
1V_VGA_EN_Y: R8615.1 U8604.4
1V_VGA_S0: C7610.1 C7611.1 C7612.1 C7613.1 GPU1.AA22 GPU1.AB23 GPU1.AC24 GPU1.AD25 GPU1.AE26 GPU1.AE27 PG8607.2 PG8608.2 R8618.1
1V_VGA_S0_DISCHG: Q8615.3 R8618.2
1V_VGA_S0_PG: D8601.2 PR8623.2 R8524.1 R8531.1
1V_VREF_CPU: C2406.1 R2402.2 U2401.95
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4002.1 U4001.10
3V5V_S0_ON: C4003.1 R4010.2 U4001.3 U4001.5
3V_5V_DSW_OK: D2503.3 PR5210.1 PR5310.1 R2514.2 U2502.4
3V_5V_EN: C4009.1 D4001.A PR4556.1 PU4551.12 R4006.1 R4009.1 R4502.2
3V_5V_POK#: Q1701.2 Q1701.3 R1726.2
3V_5V_PWRGD: D2503.1 ED1704.1 PR4505.2 PU4501.9 PU4501.10 Q1701.5 R1727.2 R4503.2
5V_AUX_S5: PG4565.2 PR4552.1
5V_FAN_VCC: AFTP2603.1 C2604.1 C2605.1 FAN1.1 R2612.2
5V_HDMI: C5710.1 F5701.2 HDMI1.18
5V_KB_BL: AFTP6529.1 C6501.1 F6501.2 KBBL1.1
5V_S0: C4004.1 C5701.1 D5701.3 EC8949.1 EC8950.1 EC8951.1 EC8952.1 EC8953.1 EC8954.1 F5701.1 F6501.1 PR8556.1 Q5703.G R2612.1 R2701.1 R2703.2 R2707.1 R6510.1 U4001.8 U4001.9
5V_S5: AFTP6608.1 C4031.1 C4032.1 C4043.1 C7205.1 C7206.1 EC8918.1 EC8919.1 EC8920.1 EC8927.1 EC8928.1 EC8929.1 FC8933.1 FC8968.1 IO1.1 IO1.2 IO1.3 PC4556.1 PC4557.1 PC4558.1 PC4559.1 PC4560.1 PC4561.1 PC4565.1 PC4766.1 PC4777.1 PC4866.1 PC5001.1 PC5102.1 PC5151.1 PC5202.1 PG4562.2 PL4551.2 PR4610.1 PR4635.2 PR4703.1 PR4713.1 PR4804.2 PR5101.1 PR8559.1 PU4701.29 PU4702.29 PU4801.29 PU5002.6 PU5151.6 PU5201.21 Q6401.E Q6402.E Q6505.E R4303.1 U4001.4 U4001.6 U4001.7 U4002.3 U4003.3 U4006.3 U7201.A11 U7201.B11 U7201.C11 U7201.D11 U7201.H10
19V_AD+: C4303.1 C4304.1 C4305.1 C4306.1 PD4401.1 PD4408.1 PR4437.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4415.5 PU4415.6 PU4415.7 PU4415.8 R4316.1
19V_AD_JK: C4301.1 C4302.1 EL4301.2 EL4302.2 PU4301.1 PU4301.2 PU4301.3 Q4305.E R4307.1 R4376.1
19V_DCBATOUT: EC8908.1 EC8909.1 EC8910.1 EC8911.1 EC8912.1 EC8913.1 EC8914.1 EC8915.1 EC8916.1 EC8917.1 F5503.1 FC8906.1 FC8907.1 FC8908.1 FC8909.1 FC8910.1 FC8911.1 FC8912.1 FC8913.1 FC8914.1 FC8915.1 FC8916.1 FC8943.1 FC8944.1 FC8945.1 FC8946.1 FC8947.1 FC8948.1 FC8949.1 FC8950.1 FC8951.1 FC8952.1 FC8953.1 PC4401.1 PC4439.1 PC4441.1 PC4442.1 PC4443.1 PC4444.1 PC4461.1 PC4462.1 PC4465.1 PC4466.1 PC4501.1 PC4502.1 PC4503.1 PC4552.1 PC4554.1 PC4555.1 PC8551.1 PC8552.1 PC8553.1 PC8568.1 PD4401.2 PG4405.2 PG5201.1 PG5202.1 PG5203.1 PG8614.1 PG8615.1 PG8616.1 PG8617.1 PL4703.1 PL4704.1 PL4802.1 PL4803.1 PR44B2.1 PR4407.1 PR4485.1 PR4509.1 PR4557.1 PR4612.1 PR8561.1 PU4401.3 PU4403.2 PU4403.3 PU4403.4 PU4403.10 PU4501.2 PU4501.3 PU4501.4 PU4501.5 PU4551.2 PU4551.3 PU4551.4 PU4551.5 PU8552.2 PU8552.3 PU8552.4 PU8552.10 PU8553.2 PU8553.3 PU8553.4 PU8553.10 PU8554.2 PU8554.3 PU8554.4 PU8554.10 PU8555.2 PU8555.3 PU8555.4 PU8555.10 Q5512.E R5001.1 R5101.1 R6610.1 R6615.1 R6617.1 R6618.2 R6623.2 R6624.2
19V_DCBATOUT_LCD: C5512.1 C5513.1 C5514.1 C5556.1 D5504.A F5503.2 LCD1.1 LCD1.2 LCD1.3 R6619.2
19V_DCBATOUT_LCD_SEN: CN1.2 R6618.1
19V_DCBATOUT_R_SEN: CN1.18 R6624.1
19V_DCBATOUT_SEN: CN1.20 R6625.1
20V_VCCPD_VBUS: C7302.1 C7303.1 C7304.1 C7305.1 C7306.1 C7307.1 D7301.K ER7301.2 ER7302.2 R7423.1 R7425.1 R7426.1 U7419.B2 U7419.C2 U7419.D2 U7419.E1 U7419.E2 USB1.A4 USB1.A9 USB1.B4 USB1.B9
20V_VCCPD_VBUS_L: C7301.1 ER7301.1 ER7302.1 R7216.1 R7217.1 U7201.H11 U7201.J10 U7201.J11 U7201.K11
+3V_1D8V_AVDD: C2710.1 R2719.2 U2701.33
+3V_1D8V_DVDD: C2720.1 C2721.1 C2723.1 C2740.1 C2741.1 R2710.1 R2715.2 R2717.1 U2701.1 U2701.8
+5V_AVDD: C2706.1 C2707.1 R2703.1 U2701.20
+5V_PVDD: C2713.1 C2714.1 C2717.1 C2718.1 R2701.2 R2707.2 U2701.34 U2701.39
DV12S: C3311.1 U3301.20
DV3318_ANA_CORE: C3307.1 C3308.1 U3301.9
DV3318_HOST: C3310.1 R3321.2 U3301.13
DV3318_S_PAD: C3304.1 C3305.1 U3301.5
DVSS: R2716.2 U2701.10
