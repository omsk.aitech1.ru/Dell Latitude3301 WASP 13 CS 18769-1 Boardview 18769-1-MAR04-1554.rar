# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_S0_SSD_SEN: length 75
  TOP w0.127: v2(121.01,18.88) 120.64,19.26 120.38,19.26 119.77,19.87 119.32,19.87 119.18,19.73 R6612.2 ; v2(122.72,78.44) 122.31,78.85 v1(122.15,78.85)
  L5 w0.127: v2(121.01,18.88) 120.54,19.35 120.54,19.42 120.34,19.63 120.34,20.63 121.45,21.73 121.45,22.48 122.61,23.65 122.61,30.58 123.19,31.16 123.19,35.21 124.71,36.73 124.71,38.86 125.76,39.92 125.76,44.84 126.35,45.43 126.35,46.94 127.09,47.68 127.09,49.23 126.08,50.24 126.08,52.09 126.24,52.25 126.24,53 125.67,53.57 125.67,55.62 124.66,56.63 124.66,57.63 124.65,57.64 124.65,58.67 125.11,59.13 125.11,61.57 126.9,63.36 126.9,65.28 126.06,66.12 126.06,70.5 127.73,72.17 127.74,72.17 128,72.43 128,72.44 128.05,72.5 128.05,75.59 126.91,76.73 124.18,76.73 123.06,77.85 123.06,78.1 v2(122.72,78.44)
  BOTTOM w0.127: v2(122.72,78.44) 123.01,78.16 123.01,77.61 122.65,77.25 CN1.5
3D3V_S5: length 467.1
  TOP w0.254: R7224.1 29.32,64.22 29.56,64.45 v4(29.68,64.45)
  TOP w0.305: v4(42.64,72.52) 42.03,71.91 R5535.1 ; v4(66.87,13.21) 66.26,12.6 EC8926.1 ; R4378.1 31.57,59.54 v3(30.55,60.55) ; v2(151.76,22.51) 151.76,22.77 151.1,23.43 PR4443.1 ; EC8925.1 91.33,7.99 v4(91.26,7.93) 91.29,7.91 FC8931.1 91.29,7.2 FC8967.1 ; PR4460.1 146.96,20.77 146.96,19.97 146.65,19.67 146.21,19.67 v2(146.09,19.55)
  TOP w0.508: PR8557.1 146.19,85.65 v2(146.11,85.57) ; R7243.1 19.04,63.94 17.95,65.04 17.95,65.28 ; v2(131.76,27.47) 131.35,27.47 128.89,25.01 128.89,22.45 129.51,21.82 129.9,21.82 130.15,21.57 135.83,21.57 135.97,21.71 139.9,21.71 141.08,20.53 142.1,20.53 143.22,19.41 143.33,19.41 143.44,19.29 PR4462.1 145.84,19.29 146.06,19.51 146.06,19.55 v2(146.09,19.55) ; v2(16.5,47.8) 16.33,47.63 R6742.1 15.52,47.82 12.6,47.82 R6745.1 ; R2408.1 25.74,10.01 25.08,9.36 25.08,8.72 25.08,8.71 25.08,8.24 25.08,8.24 25.08,8.13 24.12,7.17 v2(23.71,7.17) ; v2(125.44,34.22) 125.21,34.45 R1721.1 ; R7247.1 17.31,64.27 17.28,64.27 v2(17.11,64.44) 17.95,65.28 ; 17.95,65.28 R6404.1 ; v2(124.64,88.31) 124.24,87.91 124.24,87.7 PR5208.1
  L3 w0.508: v2(151.76,22.51) 151.06,23.22 151.06,24.07 151.87,24.88 153.64,24.88 155.68,26.92 156.11,26.92 v3(158.75,29.56) ; v2(17.77,71.41) 17.77,71.01 17.77,71 17.77,67.58 17.11,66.92 v2(17.11,64.44) ; v2(18.14,52.11) 18.14,52.08 18.09,52.04 18.09,50.24 16.5,48.65 v2(16.5,47.8) ; v2(169.84,32.97) 169.84,32.04 171.87,30.01 171.87,28.02 172.92,26.97 172.96,26.96 173.15,26.88 173.32,26.77 177.38,26.77 v4(178.18,25.98) ; v2(51.74,44.06) 51.63,44.06 50.17,42.59 47.88,42.59 46.22,40.93 46.22,38.97 43.19,35.95 42.22,35.95 41.76,36.4 40.43,36.4 39.97,35.95 36.07,35.95 35.35,35.22 35.35,33.2 31.98,29.84 31.98,29.78 v2(31.96,29.78)
  L5 w0.508: v2(11.39,9.6) 9.81,11.18 6.57,11.18 5.49,12.25 v2(2.51,12.25) 2.27,12.25 1.71,12.81 1.71,18.73 v2(3.58,20.6) 3.58,20.31 5.33,18.57 14.04,18.57 v2(14.16,18.45) 14.52,18.8 16.24,18.8 17.11,17.93 21.21,17.93 v2(21.27,17.99) ; v4(22.95,45.17) 22.66,45.46 21.46,45.46 20.53,46.4 18.16,46.4 17.6,46.4 17.15,46.84 17.15,47.14 v2(16.5,47.8) ; v2(152.33,30.34) 153.76,30.34 155.25,28.85 158.03,28.85 v3(158.75,29.56) ; v2(125.44,34.22) 127.09,35.87 v2(130.01,35.87) 132.67,38.53 v2(132.67,48.29) 132.67,49.7 132.55,49.82 132.55,50.35 133.23,51.03 133.23,51.99 133.59,52.35 133.59,54.48 133.46,54.62 133.46,55.12 132.65,55.93 v2(132.65,56.72) ; v2(146.09,19.55) 147.43,19.55 147.52,19.46 149.1,19.46 151.76,22.12 v2(151.76,22.51)
  L6 w0.305: v2(132.67,48.29) 127.79,48.29 126.79,49.29 125.21,49.29 124.61,48.69 123.26,48.69 122.58,48.01 119.89,48.01 v3(118.98,48.92)
  L6 w0.508: v2(152.33,30.34) 153.03,30.34 157.37,34.68 168.12,34.68 v2(169.84,32.97) ; v2(17.11,64.44) 18.1,63.45 18.1,61.78 19.29,60.59 19.29,58.64 19.37,58.56 19.37,58.5 19.74,58.12 20.69,58.12 21.04,57.77 21.04,56.35 19.88,55.18 19.88,53.71 18.29,52.12 18.17,52.12 18.16,52.11 v2(18.14,52.11) ; v2(26.48,69.01) 26.48,69.81 27.32,70.65 27.32,70.65 27.57,70.9 27.57,71.52 27.93,71.88 27.93,72.67 27.19,73.42 27.03,73.42 26.42,74.02 26.42,74.04 26.31,74.15 25.03,74.15 22.42,71.54 19.29,71.54 18.9,71.15 18.11,71.15 17.85,71.41 v2(17.77,71.41) ; v2(21.27,17.99) 21.27,15.92 22.16,15.03 22.16,13.42 20.85,12.11 20.85,9.65 23.33,7.17 v2(23.71,7.17) ; v4(178.18,25.98) 178.18,27.01 181.75,30.59 181.87,30.59 181.9,30.56 182.43,30.56 182.46,30.59 186.17,30.59 187.73,29.02 v4(187.73,26.49) 188.47,26.49 188.69,26.27 195.29,26.27 196.66,24.9 196.66,17.98 196.6,17.92 196.6,17.4 196.66,17.34 196.66,12.9 196.6,12.84 196.6,12.32 196.66,12.26 196.66,9.62 196.2,9.16 196.2,9.05 196.12,8.96 196.12,3 v2(194.7,1.58)
  L8 w0.508: v2(30.98,19.16) 27.95,22.18 27.13,22.18 27.13,22.18 26.95,22.18 26.92,22.2 21.87,22.2 21.65,21.98 21.62,21.98 19.22,19.57 19.22,19.05 20.27,17.99 v2(21.27,17.99) ; 129.62,86.97 129.48,86.97 127.88,88.57 124.9,88.57 v2(124.64,88.31) ; 129.62,86.97 129.65,86.93 139.08,86.93 139.72,87.58 144.1,87.58 v2(146.11,85.57) ; 129.62,86.97 128.57,85.92 128.57,82.03 131.52,79.09 131.52,66.73 132.7,65.54 132.7,63.47 132.72,63.45 132.72,62.93 132.37,62.57 132.37,60.11 133.23,59.25 133.23,58.07 132.65,57.49 v2(132.65,56.72) ; v2(131.76,27.47) 131.35,27.89 131.35,28.18 130.01,29.51 v2(130.01,35.87)
  BOTTOM w0.152: v4(29.68,64.45) 29.56,64.45 29.25,64.14 U7201.B1 ; U7201.H1 29.53,61.14 29.73,60.94
  BOTTOM w0.254: v3(30.55,60.55) 30.16,60.94 29.73,60.94
  BOTTOM w0.305: R9212.1 149.41,5.93 v2(149.45,5.89) 149.39,5.83 149.39,4.68 147.9,3.19 Q9201.S ; PR4472.1 151.9,22.32 151.76,22.45 v2(151.76,22.51) ; R7427.1 20.71,70.37 R7424.1 20.65,70.37 20.18,70.84 20.18,71.57 21.09,72.49 21.09,73.63 20.74,73.98 19.79,73.98 17.77,71.96 v2(17.77,71.41) ; U4302.2 34.4,58.22 34.81,58.63 34.81,61.42 C7208.1 ; Q2416.2 Q2416.5 12.4,19.2 C2416.1 C2421.1 ; v2(3.58,20.6) 3.58,20.33 2.88,19.63 2.88,19.27 R3331.1 ; IO1.4 173.85,10.14 v2(174.13,10.42) ; R506.1 52.51,43.29 v2(51.74,44.06)
  BOTTOM w0.381: U4008.5 133.1,32.65 132.93,32.82 132.93,34.01 131.58,35.36 130.53,35.36 v2(130.01,35.87) ; v3(118.98,48.92) 118.53,49.37 R1910.1
  BOTTOM w0.508: U2502.5 169.86,33.99 169.86,32.97 v2(169.84,32.97) ; v2(2.51,12.25) 3.1,12.25 R3301.1 ; D4302.2 18.43,51.81 v2(18.14,52.11) ; v2(156.78,12.12) 156.39,12.51 PR4435.1 ; v2(26.48,69.01) 26.67,68.82 26.67,68.25 R7215.1 ; R3325.1 11.68,9.89 v2(11.39,9.6) ; C2421.1 12.48,18.15 12.93,18.59 14.01,18.59 v2(14.16,18.45) ; R4304.1 16.22,48.08 16.5,47.81 v2(16.5,47.8) ; R2604.1 129.51,36.38 v2(130.01,35.87)
  vias: v1(24.68,41.09) v2(26.76,32.66) v2(31,29.8) v2(31.06,29.16) v2(35.47,62.74) v2(163.45,13.78) v2(163.37,13.15) v2(164.03,13.12) v2(192.47,2.14) v2(192.47,1.48) v4(22.95,44.33) v4(30.5,64.78) v4(62.71,69.27) v4(63.22,74.13) v4(63.31,74.96) v4(67.74,13.21) v4(68.58,13.21) v4(69.47,13.21) v4(92.14,7.94) v4(93.13,7.92) v4(94,7.91) v4(94.89,7.92)
3D3V_S5_KBC: length 201.2
  TOP w0.305: DB3.1 31.39,10.51 ; C2413.1 31.7,21.74 v2(31.18,22.27)
  TOP w0.508: R2414.1 29.77,11.08 30.46,11.08 30.91,11.53 31.49,11.53 ; v2(26.57,28.81) 27.13,29.37 R2446.2 ; v2(26.57,28.81) 27.62,28.81 27.83,28.6 27.83,28.6 28.2,28.23 28.2,28.23 28.23,28.2 R2415.1 ; v2(26.57,28.81) 26.15,29.23 C2415.1 25.16,29.23 C2412.1 ; ED4304.2 81.6,10.48 83.21,12.09 83.21,12.68 v2(83.19,12.7) ; 31.39,10.51 31.49,10.62 31.49,11.53 ; v2(114.67,13.16) 114.75,13.08 ED4305.2 114.74,12.36 ED4306.2 ; 31.49,11.53 v2(31.49,12.45) 31.65,12.6 R2480.1 ; C2410.1 17.47,14.55 C2411.1 17.48,14.82 17.09,15.2 R2403.1 17.09,16.17 R2404.1 15.98,16.18 v2(15.71,15.91) ; v2(15.83,21.5) 15.79,21.46 C2422.1
  L3 w0.508: v2(19.47,26.22) 19.51,26.22 19.51,26.87 20.32,27.67 25.43,27.67 v2(26.57,28.81)
  L5 w0.508: v2(31.18,22.27) 30.91,22.27 26.57,26.6 v2(26.57,28.81) ; v2(52.12,18.03) 49.93,20.23 48.9,20.23 45.48,23.64 45.48,26.53 46.11,27.15 46.11,27.66 45.31,28.46 42.36,28.46 v2(41.8,29.02) ; v2(15.71,15.91) 15.97,15.91 17.14,14.74 17.14,14.29 19.37,12.07 23.59,12.07 24.02,11.64 ; 24.02,11.64 24.35,11.98 24.44,11.98 24.45,11.99 24.98,11.99 25.35,11.62 25.35,11.56 25.45,11.46 25.45,7.86 25.1,7.51 25.1,6.98 27.48,4.61 34.4,4.61 v2(35.32,3.69) ; 24.02,11.64 v2(24.02,11.39)
  L6 w0.508: v2(15.71,15.91) 15.97,15.91 16.8,16.74 16.8,20.68 15.98,21.5 v2(15.83,21.5) 17.61,23.28 17.61,24.32 18.14,24.85 18.57,24.85 19.38,25.66 19.38,26.13 v2(19.47,26.22)
  L8 w0.508: v2(41.8,29.02) 38.38,29.02 34.24,24.87 33.78,24.87 v2(31.18,22.27) ; v2(24.02,11.39) 24.02,11.56 24.53,12.07 31.12,12.07 v2(31.49,12.45)
  BOTTOM w0.203: U2401.19 25.77,28.78 25.84,28.85 25.84,28.85 26.53,28.85 v2(26.57,28.81) 26.65,28.81 26.97,28.5 U2401.22 ; U2401.82 24.17,11.55 v2(24.02,11.39) ; U2401.103 16.07,16.27 v2(15.71,15.91) ; U2401.115 16.32,21.07 15.89,21.5 v2(15.83,21.5) ; v2(19.47,26.22) 19.51,26.22 19.51,26.26 19.61,26.26 20.01,26.66 20.01,26.72 20.17,26.87 U2401.5 ; U2401.43 v2(31.18,22.27) ; U2401.65 v2(31.49,12.45)
  BOTTOM w0.305: v2(15.83,21.5) 15.8,21.47 R2443.1
  BOTTOM w0.508: v2(114.67,13.16) 114.66,13.17 114.42,13.17 111.43,16.17 87.03,16.17 v1(83.99,13.13) 83.56,12.7 v2(83.19,12.7) 79.72,16.17 53.99,16.17 v2(52.12,18.03)
3D3V_S5_PCH: length 178.2
  TOP w0.508: v2(109.46,38.25) 109.31,38.09 109.31,36.98 R303.1 ; v2(175.45,29.37) 175.71,29.11 R9148.1 ; v2(131.72,29.35) 132.4,30.03 139.48,30.03 v2(139.91,30.46) ; R9805.1 175.76,25.17 v2(175.22,25.71)
  L3 w0.508: v2(123.07,54.05) 121.68,55.43 119.81,55.43 118.88,56.36 v2(118.88,56.77)
  L5 w0.305: v2(115.5,39.6) 115.87,39.98 115.87,40.83 115.23,41.47 115.23,44.02 114.75,44.5 113.72,44.5 112.6,45.62 112.6,49.18 113.64,50.22 113.65,50.22 v2(115.25,51.82)
  L5 w0.508: v2(117.34,56.59) 116.18,55.44 116.18,52.92 115.25,51.99 v2(115.25,51.82) ; v2(123.89,46.51) 123.07,47.33 v2(123.07,54.05)
  L6 w0.508: v2(166.84,32.85) 166.01,32.85 165.92,32.94 165.64,33.13 165.3,33.19 165.08,33.19 164.86,33.15 164.83,33.14 156.73,33.14 153.29,29.7 148.59,29.7 148.08,30.21 142.1,30.21 141.84,30.46 v2(139.91,30.46) 138.25,32.13 135.58,32.13 134.1,33.61 134.1,34.64 125.64,43.1 125.64,44.56 123.89,46.31 v2(123.89,46.51) ; v2(130.08,58.36) 128.75,58.36 128.75,58.37 127.81,58.37 127.65,58.2 126.43,58.2 125.58,57.34 124.7,57.34 124.2,57.84 123.51,57.84 123.02,57.35 119.38,57.35 118.88,56.85 v2(118.88,56.77)
  L8 w0.508: v2(166.84,32.85) 168.9,32.85 171.88,29.87 171.88,29.45 172.73,28.6 173.09,28.6 173.46,28.22 173.46,27.47 v2(175.22,25.71) 175.22,26.84 175.58,27.2 175.58,29.23 v2(175.45,29.37) ; v2(130.19,66.4) 130.94,66.4 131.88,65.47 131.88,64.1 131.1,63.32 131.1,59.02 130.44,58.36 v2(130.08,58.36)
  BOTTOM w0.254: v2(118.88,56.77) 119.34,57.23 v1(120.09,57.23) 121.12,57.23 R1504.1 ; R1502.1 115.96,51.18 115.96,51.18 115.33,51.82 v2(115.25,51.82)
  BOTTOM w0.305: v2(130.19,66.4) 130,66.21 RN405.2 129.49,66.64 129.25,66.88 129.06,66.88 128.82,66.64 RN405.1 ; v2(115.5,39.6) 115.16,39.27 113.7,39.27 113.7,39.27 113.34,39.27 113.34,39.27 112.47,39.27 111.88,38.69 111.44,38.69 R1837.1 110.71,38.41 109.82,38.41 109.67,38.25 v2(109.46,38.25) 109.08,37.87 R1510.1 R1508.1 107.76,37.87 107.63,37.74 107.23,37.74 107.19,37.78 106.83,37.78 R1506.1
  BOTTOM w0.381: R1513.1 123.54,46.51 v2(123.89,46.51)
  BOTTOM w0.508: v2(131.72,29.35) 131.71,29.35 131.71,29.36 BIOS1.8 129.18,29.36 C2501.1 128.4,31.1 C2502.1 ; R2516.2 172.25,35.12 172.76,34.62 172.76,33.73 174.43,32.06 174.43,30.38 v2(175.45,29.37) ; R2519.1 138.93,31.44 v2(139.91,30.46) ; v2(115.5,39.6) 115.63,39.74 115.7,39.74 115.73,39.76 116.23,39.76 116.26,39.74 116.35,39.74 116.85,39.24 117.99,39.24 118.95,38.28 R2042.1 ; R1551.1 118.66,56.99 v2(118.88,56.77) ; R1522.1 123.75,53.37 v2(123.07,54.05) 122.5,54.05 R1554.1
3D3V_SSD:
  vias: v1(117.19,20.11) v2(116.2,19.96) v2(116.25,19.22) v2(116.26,18.51) v2(116.59,33.16) v2(117.22,33.07)
3D3V_SSD_R: length 74.1
  TOP w0.127: v2(123.54,78.44) 123.54,78.61 123.36,78.79 v1(123.36,78.98) ; v2(121.01,19.7) 120.8,19.49 120.47,19.49 119.86,20.1 119.33,20.1 119.18,20.24 R6613.2
  L5 w0.127: v2(121.01,19.7) 120.92,19.61 120.68,19.61 120.57,19.72 120.57,20.49 120.58,20.5 120.58,20.54 121.68,21.64 121.68,22.39 122.84,23.56 122.84,30.49 123.42,31.07 123.42,35.12 124.94,36.64 124.94,38.76 125.99,39.82 125.99,44.75 126.58,45.34 126.58,46.85 127.32,47.59 127.32,49.32 126.31,50.34 126.31,52 126.47,52.16 126.47,53.09 125.9,53.66 125.9,55.72 124.89,56.72 124.89,57.72 124.88,57.74 124.88,58.58 125.33,59.04 125.33,61.47 127.13,63.27 127.13,65.38 126.29,66.22 126.29,70.41 127.82,71.94 127.83,71.94 128.23,72.34 128.23,72.35 128.28,72.4 128.28,75.68 127.01,76.95 124.28,76.95 123.31,77.92 123.31,78.21 v2(123.54,78.44)
  BOTTOM w0.127: v2(123.54,78.44) 123.26,78.16 123.26,77.5 123.05,77.29 CN1.7
3D3V_TBT: length 3.1
  TOP w0.203: v1(27.43,60.76) 27.43,60.99 27.7,61.26 v3(28.08,61.26)
  TOP w0.254: v3(28.08,61.26) 28.15,61.26 28.69,60.71 28.69,60.22 C7210.1
  BOTTOM w0.254: U7201.H2 28.19,61.14 v3(28.08,61.26)
3D3V_TP_VDD: length 5.9
  TOP w0.381: C6505.1 119.29,6.8 R6502.2 119.43,7.63 AFTP6531.1 120.79,6.25 R6511.1
  BOTTOM w0.305: TPAD1.8 v2(123.1,5.95)
3D3V_TPAN_VDD: length 16.7
  TOP w0.508: R5508.2 61.96,82.41 C5517.1 61.26,82.83 60.55,82.12 C5516.1 60.32,82.08 C5518.1 58.81,82.28 57.41,82.28 v1(57.11,82.58) 56.54,82.02 52.21,82.02 51.52,81.34 v2(51.52,81.01)
  BOTTOM w0.203: 50.8,80.1 50.79,80.09 ; 50.79,80.09 50.79,79.54 50.8,79.54 LCD1.31 ; 50.79,80.09 50.4,79.7 LCD1.30
  BOTTOM w0.356: v2(51.52,81.01) 51.52,80.82 50.8,80.1
3D3V_TPM: length 13.7
  TOP w0.508: R9151.1 179.17,31.14 v2(178.54,31.14)
  BOTTOM w0.508: v2(177.39,27.85) 177.39,29.36 178.54,30.51 v2(178.54,31.14) 179.28,31.88 186.65,31.88 v2(187.11,31.42)
  vias: v1(178.17,27.44)
3D3V_VCCDSW: length 150
  TOP w0.254: v2(151.7,52.71) 149.3,52.71 144.86,57.15 v1(142.09,57.15) 141.63,57.15 v2(141.3,57.48) ; RN1704.2 112.23,35.07 111.84,34.69 v2(111.81,34.69) 111.56,34.94 RN1704.1 111.26,35.47 110.47,34.68 R1722.1 110.41,34.33 109.39,33.31 103.51,33.31 102.63,34.19 R1524.1 ; v2(100.87,51.33) 100.87,51.25 101.54,50.58 C2224.1 101.54,49.2 R1707.1
  L3 w0.254: v2(151.7,52.71) 152.26,52.16 153.36,52.16 153.74,51.78 154.69,51.78 156.2,50.27 158.97,50.27 160.6,48.64 160.92,48.32 160.92,47.37 161.2,47.09 161.2,46.78 162.75,45.23 162.75,40.81 162.83,40.73 162.88,40.68 162.88,40.46 165.18,38.16 165.18,34.68 v2(166.15,33.71) ; v2(111.81,34.69) 111.81,34.69 110.64,35.86 110.64,35.96 108.34,38.26 108.34,40.26 107.34,41.26 107.34,42.09 105.47,43.96 101.39,43.96 100.13,45.22 100.13,47.58 101.41,48.85 101.41,50.72 100.87,51.25 v2(100.87,51.33)
  L5 w0.254: v2(141.3,57.48) 141.3,57.41 140.68,56.79 138.51,56.79 137.34,57.95 136.08,57.95 134.53,59.5 133.35,59.5 129.89,62.96 127.77,62.96 126.09,61.28 126.09,58.72 125.32,57.96 125.32,57.95 ; 125.32,57.95 125.32,57.92 125.33,57.91 125.33,56.91 126.34,55.9 126.34,55.6 126.53,55.41 126.53,55.35 126.98,54.9 126.98,51.61 v2(126.88,51.51) ; 125.32,57.95 v3(125.32,57.95)
  L6 w0.254: v2(100.87,51.33) 100.87,51.25 101.31,50.82 101.73,50.82 102.24,51.33 103.42,51.33 104.32,52.22 104.32,52.39 105.25,53.32 105.66,53.32 105.95,53.62 105.95,54.64 107.07,55.76 107.07,56.13 107.42,56.47 109.88,56.47 110.12,56.23 111.95,56.23 113.09,57.37 113.85,57.37 114.3,56.91 116.94,56.91 117.12,57.09 118.41,57.09 119.24,57.93 122.88,57.93 123.38,58.43 124.85,58.43 125.32,57.96 125.32,57.95 v3(125.32,57.95)
  BOTTOM w0.254: v3(125.32,57.95) 125.31,57.97 125.01,57.97 R1819.1 ; R1520.1 126.55,50.35 126.55,51.2 126.85,51.51 v2(126.88,51.51) ; v2(166.15,33.71) 166.15,33.86 166.55,34.26 U2502.1 169,34.26 169.66,34.92 170.03,34.92 170.83,35.72 170.83,36.02 171.25,36.45 R2516.1 ; CPU1.BT23 100.9,51.41 100.9,51.35 v2(100.87,51.33) 100.87,51.19 CPU1.BR24
3D3V_VCCPRIM: length 55.6
  TOP w0.508: v2(122.15,61.09) 121.94,60.87 121.94,57.3 120.67,56.03 120.62,56.03 120.12,55.54 115.91,55.54 R1103.2
  L3 w0.508: v2(104.83,52.18) 104.8,52.2 v2(104.8,55.55)
  L5 w0.305: v2(115.98,39.15) 116.49,39.66 116.49,41.49 115.98,42 115.98,45.88 116.89,46.79 116.89,47.79 116.88,47.81 116.88,48.16 116.21,48.83 114.08,48.83 113.26,48.01 v2(113.24,48.01)
  L6 w0.305: v2(122.15,61.09) 121.78,60.71 121.78,60.42 120.4,59.05 118.84,59.05 118.76,58.97 118.75,58.97 118.16,58.38 115.76,58.38 115.12,57.74 114.68,57.74 114.23,58.19 110.71,58.19 ; 107.28,58.6 106.97,58.28 106.97,57.35 105.66,56.04 105.23,56.04 104.8,55.61 v2(104.8,55.55)
  BOTTOM w0.203: CPU1.CP29 112.15,48.01 113.23,48.01 113.23,48.01 v2(113.24,48.01) ; CPU1.BV23 CPU1.BW23 103.19,51.81 v2(103.52,52.14)
  BOTTOM w0.254: CPU1.BT20 100.9,53.09 v2(100.9,52.98) ; v2(100.27,52.14) 100.27,52.14 99.94,51.8 CPU1.BP23 ; CPU1.CB16 104.8,55.61 v2(104.8,55.55)
  BOTTOM w0.305: v2(115.98,39.15) 115.7,38.88 113.87,38.88 113.86,38.87 113.18,38.87 113.18,38.88 112.65,38.88 112,38.23 111.67,38.23 R1731.1
  BOTTOM w0.508: R1701.1 122,60.93 v2(122.15,61.09)
  vias: v1(106.96,50.49) v2(105.49,52.16)
3D3V_VCCPRTC: length 15.3
  TOP w0.254: v2(100.92,52.14) 101.16,51.9 102.02,51.9 C2221.1 ; C2222.1 109.64,55.33 v2(110.03,54.94) 110.3,54.94 110.55,55.19 v1(110.55,55.2) 110.56,55.21 110.59,55.21 111.36,55.98 R2204.2
  L5 w0.254: v2(110.03,54.94) 109.55,54.46 106.75,54.46 105.95,53.67 105.95,53.62 105.66,53.32 105.25,53.32 104.03,52.1 104.03,51.93 103.73,51.63 103.05,51.63 102.92,51.77 102.55,52.14 v2(100.92,52.14)
  BOTTOM w0.203: v2(100.92,52.14) 100.59,51.81 CPU1.BR23
3D3V_WLAN:
  vias: v1(168.46,13.19) v2(168.75,31.08) v2(169.4,30.88) v4(167.03,12.42) v4(167.94,12.42)
27MHZ_IN: length 24
  BOTTOM w0.102: X7901.1 175.33,39.15 175.8,39.62 175.8,40.65 C7907.1 175.12,41.33 175.12,41.82 R7903.1 174.4,42.6 173.42,42.6 172.52,43.51 172.52,44.97 168.46,49.02 167.72,49.02 166.01,50.73 166.01,50.83 163.65,53.2 163.65,53.3 162.42,54.53 162.23,54.53 161.66,55.1 GPU1.C11
27MHZ_OUT: length 19
  BOTTOM w0.102: R7903.2 R7904.1 173.3,41.93 173.3,42.3 172.21,43.38 172.21,44.84 168.34,48.72 167.59,48.72 165.71,50.6 165.71,50.71 163.34,53.07 163.34,53.17 162.33,54.18 162.3,54.18 162.26,54.22 161.83,54.22 GPU1.B10
65982D_BUSPWR: length 4.4
  TOP w0.254: R7204.2 24.27,60.43 v1(24.27,60.55) 24.27,61.27 24.4,61.4 24.4,61.47 24.98,62.05 v3(25.07,62.05) 25.21,62.18 R7236.1
  BOTTOM w0.254: v3(25.07,62.05) 24.98,62.14 U7201.F10
65982D_DBG_CTL1: length 4.3
  TOP w0.127: v1(27.55,62.15) 27.55,62.69 v3(27.91,63.06) 27.97,63.06 28.39,63.47 28.39,64.35 27.8,64.94 RN7202.2
  BOTTOM w0.127: v3(27.91,63.06) 27.58,62.72 U7201.E4
65982D_DBG_CTL2: length 2.5
  TOP w0.127: RN7202.1 27.5,64.12 v3(27.97,63.65) 27.71,63.65 v1(27.47,63.4)
  BOTTOM w0.127: U7201.D5 27.58,63.65 v3(27.97,63.65)
65982D_DEBUG1: length 6.6
  BOTTOM w0.127: R7220.2 31.7,54.53 31.34,54.9 31.34,55.66 30.59,56.4 30.59,56.62 30.11,57.1 v1(30.11,57.42) 30.11,57.53 29,58.65 29,58.72 28.97,58.75 28.97,59.06 28.58,59.45 U7201.L2
65982D_DEBUG2: length 6.2
  BOTTOM w0.089: 29.18,59.15 28.8,59.54 28.8,59.92 U7201.K2
  BOTTOM w0.127: 29.18,59.15 29.18,58.95 29.2,58.94 29.2,58.86 30.52,57.53 30.52,57.05 v1(31.29,56.28) 31.92,55.66 R7221.2
65982D_DIG_AUD_N: length 6
  BOTTOM w0.127: R7241.2 30.34,55.91 30.34,56.52 29.74,57.12 29.74,57.49 28.75,58.47 28.75,58.97 28.32,59.41 28.32,59.9 U7201.K3
65982D_DIG_AUD_P: length 5.1
  BOTTOM w0.127: U7201.L3 28.08,59.34 28.54,58.88 28.54,58.33 29.46,57.4 29.46,57.04 30.08,56.42 R7242.2
65982D_GND: length 2.7
  TOP w0.254: v3(25.7,60.64) 25.74,60.6 25.74,59.72 C7212.1 26.24,59.18 v1(26.24,58.81)
  BOTTOM w0.254: v3(25.7,60.64) 25.7,60.71 26.08,61.09 U7201.H7
65982D_GPIO1: length 5.2
  TOP w0.127: v3(30.25,63.89) 30.25,62.95 29.87,62.57 29.6,62.57 R7245.2 28.76,61.74 v1(28.76,61.25)
  BOTTOM w0.089: v3(30.25,63.89) 30.2,63.95 29.36,63.95 29.33,63.92 28.85,63.92 U7201.C2
65982D_GPIO2: length 8.9
  TOP w0.127: R7247.2 18.17,63.14 v1(18.44,62.88) 18.71,62.61 v2(19.36,62.61)
  BOTTOM w0.127: R7231.1 19.18,62.79 v2(19.36,62.61) 19.36,62.64 19.52,62.8 19.53,62.8 19.79,63.06 19.79,63.07 20.04,63.32 20.3,63.32 20.38,63.4 22.86,63.4 23.36,62.9 24.33,62.9 U7201.D10
65982D_GPIO3: length 3.3
  BOTTOM w0.127: U7201.G11 22.52,61.64 22.22,61.94 22.22,62.1 v1(22.09,62.24) 21.46,61.61 R7208.2
65982D_GPIO8: length 7.9
  TOP w0.127: v3(26.3,60.63) 26.77,60.15 27.11,60.15 27.75,59.52 29.05,59.52 29.65,60.12 R7222.2 30.01,60.99 30.79,60.99 v1(31.11,60.66) 31.27,60.51 R7223.1
  BOTTOM w0.127: v3(26.3,60.63) 26.58,60.91 U7201.H6
65982D_HPD_CON: length 2.6
  TOP w0.127: v3(25.05,63.44) 24.97,63.36 v1(24.49,63.36) 23.8,62.67 R7227.2
  BOTTOM w0.127: v3(25.05,63.44) 24.85,63.64 U7201.C10
65982D_HRESET: length 2.2
  TOP w0.127: v3(26.42,63.63) 26.16,63.37 v1(26.16,63.15) 26.64,62.66 R7202.1
  BOTTOM w0.127: U7201.D6 26.58,63.48 v3(26.42,63.63)
65982D_I2C_ADDR: length 3.5
  BOTTOM w0.127: v1(31.52,63.25) 31.52,62.4 R7201.2 30.88,62.34 30.76,62.46 30.43,62.46 30.39,62.41 30.34,62.41 30.08,62.14 U7201.F1
65982D_LDO_1V8A: length 3.7
  BOTTOM w0.127: 29.71,59.75 29.31,60.14 U7201.K1
  BOTTOM w0.254: C7203.2 31,57.64 31,57.98 30.66,58.32 v1(30.66,58.79) 30.66,58.8 29.71,59.75
65982D_LDO_1V8D: length 4.8
  TOP w0.254: C7202.2 v1(29.98,66.55) 30.09,66.55 30.45,66.19 v3(30.45,65.7)
  BOTTOM w0.152: 28.92,65.31 28.92,65.25 28.58,64.91 U7201.A2
  BOTTOM w0.254: 28.92,65.31 29.41,65.8 30.35,65.8 v3(30.45,65.7)
65982D_LDO_BMC: length 4.9
  TOP w0.254: v1(32.85,64.47) 31.78,64.47 C7201.2 31.76,64.4 30.86,63.5 30.86,62.99 v2(30.75,62.87)
  BOTTOM w0.152: 29.78,62.64 U7201.E1
  BOTTOM w0.254: 29.78,62.64 30.18,62.64 30.35,62.81 30.69,62.81 v2(30.75,62.87)
65982D_LSRX: length 4.5
  BOTTOM w0.127: TP7202.1 29.17,56.8 29.17,57.33 28.27,58.24 28.27,58.84 27.83,59.28 27.83,59.89 U7201.K4
65982D_LSTX: length 5
  BOTTOM w0.127: R7237.2 28.92,55.73 28.92,57.06 v1(28.27,57.71) 28.05,57.93 28.05,58.75 27.58,59.23 U7201.L4
65982D_MRESET: length 5.6
  BOTTOM w0.127: U7201.E11 23.31,62.64 22.82,63.14 20.57,63.14 v1(20.21,62.77) 19.37,61.93 R7214.2
65982D_RESET_N: length 6.7
  BOTTOM w0.127: v1(20.23,60.62) 19.83,61.03 R7229.1 19.34,61.2 20.31,62.17 20.87,62.17 20.95,62.25 21,62.25 21.36,62.61 22.74,62.61 23.18,62.17 24.05,62.17 U7201.F11
65982D_ROSC: length 4
  BOTTOM w0.089: v1(31.23,61.35) 30.93,61.05 30.43,61.05 30.27,61.2 30.16,61.2 30,61.35 29.26,61.35 29.24,61.37 28.85,61.37 U7201.G2
  BOTTOM w0.127: 32.09,61.55 31.43,61.55 v1(31.23,61.35)
65982D_SBU1_R: length 3.6
  BOTTOM w0.127: TP7203.1 25.69,57.79 25.69,58.28 25.79,58.37 25.79,59.44 25.82,59.47 25.82,59.9 U7201.K8
65982D_SBU2_R: length 4.2
  BOTTOM w0.127: U7201.L8 25.58,58.46 25.48,58.37 25.48,58.25 24.41,57.18 TP7204.1
65982D_UART_RX: length 7.3
  TOP w0.127: v2(30.7,59.46) 30.48,59.46 v1(30.13,59.81)
  L6 w0.127: v2(30.7,59.46) 31.02,59.78 31.02,61.63 v3(30.59,62.06)
  BOTTOM w0.127: v3(30.59,62.06) 30.43,61.9 28.82,61.9 U7201.F2 28.54,62.18 28.54,62.61 U7201.E2 ; v2(30.7,59.46) 30.77,59.38 RN7203.6
+3D3V_VDD_+SDC_IN: length 13.7
  TOP w0.254: v3(157.91,30.27) 157.19,29.55 PR44C5.1 157,29.51 PC44C2.1 157.69,27.64 PR44C2.1
  BOTTOM w0.203: PR44B4.1 151.13,30.65 151.13,30.01 v1(151.31,29.83)
  BOTTOM w0.254: PR44B4.1 151.42,30.93 154.76,30.93 155.77,29.92 155.92,29.92 156.33,29.51 PU44C1.5 156.81,28.77 157.91,29.87 v3(157.91,30.27)
+DC_IN_C:
  vias: v4(33.49,79.69) v4(33.59,80.52) v4(33.62,78.86) v4(36.31,80.53) v4(36.28,79.66) v4(36.28,78.72) v4(37.15,80.17)
+RTC_VCC: length 7.4
  TOP w0.508: R2504.1 16.85,10.27 R2510.1 16.2,9.77 v2(15.89,9.45) 15.81,9.38 15.81,8.53 16.06,8.28 AFTP2508.1 15.58,6.99 v2(15.58,6.98)
  BOTTOM w0.508: v2(15.89,9.45) 15.43,9.91 D2501.2 ; Q2505.G 14.62,6.98 v2(15.58,6.98)
+V_VREF_PATH1: length 0.7
  TOP w0.508: R1225.1 63.26,34.85 63.26,34.86 C1250.2
+V_VREF_PATH2: length 0.6
  TOP w0.508: C1339.2 R1322.1
+V_VREF_PATH3: length 0.8
  TOP w0.508: C1251.2 62.47,34.67 R1229.1
AC_DIS: length 192.7
  TOP w0.254: PR4440.1 132.44,3.4 132.14,3.7 131.32,3.7 129.49,1.87 111.42,1.87 v1(110.9,2.39) 110.23,3.05 v2(110.23,3.12) ; Q4304.B 20.16,75.4 v2(20.57,74.99)
  L3 w0.254: v2(29.93,8.31) 32.22,8.31 32.31,8.22 64.03,8.22 65.78,9.97 80.83,9.97 81.12,10.25 102.71,10.25 109.03,3.93 109.52,3.93 110.23,3.21 v2(110.23,3.12)
  L6 w0.254: v2(24.08,70.57) 23.41,69.91 23.41,66.95 23.99,66.37 23.99,65.95 22.96,64.92 22.96,62.68 23.15,62.49 23.15,59.96 22.9,59.7 22.9,56.37 23.51,55.76 23.51,48.31 25.36,46.45 25.36,45.28 25.9,44.74 25.9,42.58 25.1,41.78 25.1,35.48 26.07,34.51 26.07,32.37 27.08,31.36 27.08,28.6 27.07,28.59 27.07,25.53 28.28,24.31 28.28,14.59 28.6,14.27 28.6,9.9 29.93,8.56 v2(29.93,8.31)
  BOTTOM w0.203: 28.3,11.08 28.77,11.55 29.16,11.55 29.37,11.75 U2401.69
  BOTTOM w0.254: v2(29.93,8.31) 29.93,8.36 29.37,8.93 28.3,8.93 28.15,9.07 28.15,10.93 28.3,11.08 ; v2(20.57,74.99) 21.25,75.67 22.62,75.67 23.94,74.36 23.94,70.71 v2(24.08,70.57) 24.53,70.12 24.53,69.72 24.04,69.23 R4310.1
AC_DIS_R: length 2.8
  TOP w0.102: PQ4452.5 134.36,2.37 PR4441.2 133.24,2.36 PR4440.2 132.43,2.35 v1(131.56,2.35)
AC_IN#: length 113.1
  TOP w0.254: v2(157.22,14) 156.61,14 156.38,13.77 155.77,13.77 155.28,13.29 153.62,13.29 152.99,12.65 152.99,11.62 152.07,10.7 151.67,10.7 149.54,8.58 149.54,7.78 147.77,6 144.89,6 PR4491.1
  L3 w0.254: v2(172.4,14.28) 172.21,14.28 171.74,14.74 160.04,14.74 159.12,13.83 157.4,13.83 v2(157.22,14)
  L8 w0.254: v2(137.15,56.55) 138.23,55.47 138.23,55.07 139.81,53.49 142.22,53.49 142.31,53.4 142.92,53.4 143,53.49 151.7,53.49 152.55,52.64 155.64,52.64 158.21,50.08 158.74,50.08 162.07,46.75 168.66,46.75 171.05,44.36 171.05,35.08 171.58,34.56 171.58,34.05 v2(171.67,33.96)
  BOTTOM w0.254: v2(172.4,14.28) 172.88,14.28 175.65,17.04 175.65,18.19 176.05,18.6 176.05,25.7 173.49,28.26 173.49,29.45 173.04,29.91 173.04,31.12 171.62,32.54 171.62,33.92 v2(171.67,33.96) ; v2(137.15,56.55) 136.71,56.55 136.12,57.14 v1(135.73,57.14) 133.92,57.14 133.87,57.09 133.13,57.09 132.99,57.23 132.36,57.23 131.93,56.8 130.64,56.8 D1701.K
AC_IN#_G: length 9.7
  TOP w0.254: v2(32.24,56.14) 32.24,56.32 32.47,56.55 32.47,57.9 R4377.1 32.03,58.47 v1(30.8,58.47) 30.62,58.47 30.18,58.03 R4376.2
  BOTTOM w0.254: U4302.5 35.71,57.27 34.3,55.87 33.68,55.87 33.68,55.87 32.5,55.87 32.24,56.13 v2(32.24,56.14)
AC_PRESENT: length 73.2
  TOP w0.102: v2(128.24,57.73) 128.24,58.19 128.45,58.4 128.45,61.51 128.75,61.81 Q1702.6 ; RN1704.4 111.56,37.58 109.84,39.29 109.29,39.29 107.74,37.74 107.09,37.74 106.73,38.1 106.73,38.59 104.66,40.66 104.23,40.66 103.87,41.01 103.44,41.01 v2(102.69,41.76)
  L5 w0.102: v2(125.97,37.83) 129.81,41.66 129.81,43.51 130.84,44.54 130.84,46.65 130.66,46.83 130.66,49.72 130.84,49.91 130.84,55.59 128.71,57.73 v2(128.24,57.73)
  L6 w0.102: v2(102.69,41.76) 104.41,43.49 110.46,43.49 111.42,42.52 111.42,41.86 111.8,41.48 112.7,41.48 114.33,39.86 114.33,39.86 114.39,39.81 114.95,39.81 115.2,40.05 116.18,40.05 116.89,39.34 122.69,39.34 123.46,38.57 124.74,38.57 125.49,37.83 v2(125.97,37.83)
  BOTTOM w0.076: CPU1.BU35 102.18,44.1 102.2,44.05 102.27,43.84 102.35,43.63 102.35,42.74
  BOTTOM w0.102: v2(128.24,57.73) 128.24,56.94 v1(128.21,56.91) 128.25,56.87 D1701.A ; v2(102.69,41.76) 102.17,42.28 102.17,42.56 102.35,42.74
ACAV_IN: length 13
  TOP w0.102: PR4441.1 133.79,3.78 135.31,3.78 135.51,3.98 137.9,3.98 138.12,4.21 v1(138.77,4.21) 138.98,4.21 139.22,3.96 139.22,3.24 PR44B6.1 140.04,3.4 140.43,3.4 140.71,3.68 140.71,3.86 141.43,4.58 PQ4415.2 143.05,4.58 PG4408.1 143.09,3.96 PR4490.2
ACOK#: length 23.7
  TOP w0.127: PQ4415.6 PQ4415.5 140.5,4.58 140.93,5.01 140.93,5.39 141.31,5.77 142.35,5.77 142.9,6.32 147.63,6.32 149.23,7.91 149.23,8.76 151.49,11.02 151.94,11.02 152.67,11.76 152.67,12.78 153.49,13.6 155.15,13.6 155.75,14.2 v1(156.2,14.2) 156.51,14.51 v2(156.81,14.51)
  BOTTOM w0.127: v2(156.81,14.51) 156.44,14.89 PR4442.2
AD_IA: length 138.7
  TOP w0.102: v2(36.6,17.07) 37.53,16.13 37.53,14.37 37.44,14.28 37.44,12.52 v2(37.56,12.4) ; R2421.2 20.89,19.66 v2(21.21,19.66) 21.3,19.75 v1(21.3,20.72) 21.25,20.77 R2423.1 ; PR4492.2 140.34,6.44 139.2,5.31 PC4432.1 138.59,5.77 138.59,5.8 138.55,5.85 137.26,5.85 136.28,4.86 132.05,4.86 129.36,2.17 114.49,2.17 v2(112.07,4.59)
  L3 w0.102: v2(112.07,4.59) 111.74,4.93 111.74,5.24 109.82,7.15 109.2,7.15 104.14,12.21 92.58,12.21 91.25,13.54 88.96,13.54 88.68,13.82 70.42,13.82 70.12,14.13 54.23,14.13 53.43,13.33 41.07,13.33 40.75,13.01 38.17,13.01 v2(37.56,12.4)
  L8 w0.102: v2(36.6,17.07) 36.52,17 32.96,17 31.56,15.6 30.07,15.6 28.26,17.41 23.47,17.41 22.66,18.22 22.26,18.22 21.21,19.27 v2(21.21,19.66)
  BOTTOM w0.102: PR2455.1 35.72,17.07 v2(36.6,17.07)
AD_OFF_L: length 12.6
  TOP w0.254: Q4304.C 21.92,77.72 v1(22.12,77.93) 23.11,78.92 24.37,78.92 26.19,80.75 26.19,81.63 26.76,82.2 29.32,82.2 Q4305.B
AD_OFF_R: length 7.5
  TOP w0.254: PU4301.4 31.53,77.15 30.87,77.82 30.87,77.96 30.21,78.62 R4307.2 30.06,79.51 C4301.2 29.78,80.04 29.05,80.76 R4308.1 28.42,81.26 Q4305.C 27.69,81.64 v1(27.68,81.65)
ALERT#: length 2.5
  BOTTOM w0.102: U2601.6 127.72,35.66 R2603.2 127.49,34.09 v1(126.83,34.09)
ALWON: length 6.5
  TOP w0.127: v2(18.41,25.6) 18.41,25.5 17.94,25.03 v1(17.72,25.03) 17.67,25.07 17.67,25.8 R4009.2
  BOTTOM w0.127: v2(18.41,25.6) 19.48,24.52 19.48,24.05 18.9,23.47 U2401.121
AMBER_LED_BAT: length 5.8
  BOTTOM w0.254: EC6402.1 7.79,72.8 v1(7.79,72.09) 7.35,71.65 6.28,71.65 6.2,71.74 5.07,71.74 Q6402.C 4.05,71.87 R6401.1
AUD_AGND: length 9.7
  TOP w0.203: v2(185.01,17.98) 184.69,17.65 U2701.31 ; v2(184.37,11.97) 184.32,11.97 184.11,12.17 U2701.19
  TOP w0.305: C2706.2 185.27,11.4 184.7,11.97 v2(184.37,11.97)
  TOP w0.508: v2(189.17,20.33) 188.52,20.97 C2711.1 188.16,21.01 C2710.2
  BOTTOM w0.203: IO1.30 186.85,9.32 187.16,9.63 188.96,9.63 v2(189.29,9.96)
  BOTTOM w0.305: v2(181.23,9.89) 181.23,9.8 180.85,9.42 IO1.18
  vias: v1(191.25,18.3) v2(191.46,17.63)
AUD_HP1_JACK_L: length 13.5
  TOP w0.203: U2701.25 185.76,14.96 186.19,14.53 v1(186.57,14.53) v2(187.12,14.53)
  TOP w0.254: C2907.2 185.5,8.23 v2(184.98,7.7) ; RN2902.4 187.52,14.08 187.31,14.3 187.31,14.35 v2(187.12,14.53)
  L8 w0.254: v2(187.12,14.53) 186.93,14.53 186.25,13.85 186.25,9.4 184.98,8.13 v2(184.98,7.7)
  BOTTOM w0.254: v2(184.98,7.7) 184.35,8.33 IO1.25
AUD_HP1_JACK_R: length 16
  TOP w0.203: U2701.26 185.78,15.36 185.86,15.28 185.95,15.28 186.09,15.13 186.33,15.13 v2(186.33,15.13)
  TOP w0.254: v2(186.33,15.13) 186.57,15.13 186.64,15.06 187.24,15.06 187.26,15.04 187.33,15.04 187.65,14.73 RN2902.3 ; C2908.2 184.31,8.49 v2(183.48,7.65)
  L8 w0.254: v2(186.33,15.13) 186.3,15.13 185.38,14.2 185.38,10.14 183.48,8.23 v2(183.48,7.65)
  BOTTOM w0.203: v1(183.14,10.46) 183.35,10.24 IO1.23
  BOTTOM w0.254: v2(183.48,7.65) 183.48,7.9 183.35,8.03 IO1.23
AUD_HPJD_N: length 5.4
  TOP w0.203: v2(180.77,11.98) 180.91,11.98 181.31,12.38 U2701.12
  TOP w0.254: R2711.2 179.72,11.3 179.48,11.55 v2(179.48,11.6) 179.47,11.6 178.91,11.04 R2710.2
  L3 w0.254: v2(180.77,11.98) 179.93,11.98 179.54,11.6 v2(179.48,11.6)
  BOTTOM w0.254: v1(180.4,10.83) 180.77,11.2 v2(180.77,11.98)
AUD_PC_BEEP: length 2.3
  TOP w0.203: C2735.2 180.5,11.42 v1(180.13,11.79) 180.13,11.9 180.13,11.91 180.13,12.2 180.61,12.67 U2701.11
AUD_PC_BEEP_C: length 5.8
  TOP w0.254: C2735.1 180.47,10.07 180.47,8.49 180.32,8.34 179.32,8.34 179.3,8.36 178.87,8.36 178.61,8.62 R2735.1 176.86,8.77 C2739.1
  vias: v1(175.56,6.55)
AUD_RING: length 3.6
  TOP w0.203: v4(181.34,10.75) 181.34,10.9 181.24,11 181.24,11.82 181.71,12.29 U2701.13
  TOP w0.305: v2(189.78,10.6) 190.02,10.85 RN2901.3
  BOTTOM w0.356: v2(189.78,10.6) v1(189.22,10.6)
  vias: v1(181.91,10.41)
AUD_SENSE: length 10
  TOP w0.254: C2909.1 179.72,9.15 R2711.1 179.37,10.01 v2(179.07,10.32)
  L3 w0.254: v2(179.07,10.32) 181.23,8.16 183.71,8.16 v2(184.21,7.65)
  BOTTOM w0.254: v2(184.21,7.65) 184.21,7.8 183.85,8.17 IO1.24 ; v1(178.86,10.84) 178.89,10.81 178.89,10.76 179.07,10.58 v2(179.07,10.32)
AUD_SLEEVE: length 2.6
  TOP w0.203: U2701.14 182.11,11.81 181.88,11.57 181.88,11.58 v4(181.87,11.58)
  TOP w0.305: RN2901.4 v2(190.69,10.6)
  BOTTOM w0.356: v2(190.69,10.6) v1(191.35,10.6)
  vias: v1(185.41,10.52)
AUD_SPK_L+: length 31.6
  TOP w0.203: U2701.35 182.91,18.35 183.59,19.02 v4(183.59,19.63)
  L6 w1.016: v4(183.59,19.63) 183.32,19.63 182.72,20.23 178.31,20.23 173.29,15.22 173.29,13.82 168.85,9.38 168.56,9.38 167.95,8.77 166.47,8.77 165.65,7.95 161.82,7.95 160.82,6.95
  vias: v1(159.93,5.84) v4(160.9,5.44)
AUD_SPK_L+_C:
  vias: v4(160.85,10.29)
AUD_SPK_L-: length 34.6
  TOP w0.203: U2701.36 182.51,18.42 182.87,18.78 182.87,18.99 182.92,19.03
  L6 w1.016: v4(183.29,21.25) 183.1,21.44 180.53,21.44 180.2,21.77 177.01,21.77 174.26,19.03 174.26,18.82 172.95,17.51 172.93,17.51 172.93,17.23 170.04,14.35 170.04,12.93 168.34,11.23 167.86,11.23 166.54,9.91 165.99,9.91 165.18,9.1 161.35,9.1 158.69,6.43 v4(158.69,5.63)
  vias: v1(182.8,20.29)
AUD_SPK_L-_C:
  vias: v1(159.04,10.21) v4(159.8,10.34)
AUD_SPK_R+: length 24.9
  TOP w0.203: U2701.38 181.66,17.7 181.66,18.53 181.61,18.58 181.52,18.58 v4(181.1,18.99)
  L6 w1.016: v4(181.1,18.99) 180.58,18.99 178.57,16.99 178.57,16.49 178.43,16.35 178.43,16.32 177.91,15.8 177.89,15.8 172.66,10.58 172.2,10.58 170.59,8.97 170.5,8.97 169.76,8.23 169.32,8.23 169.04,8.23 168.42,7.62 166.94,7.62 166.05,6.74 163.29,6.74
  vias: v1(161.97,5.95) v4(162.42,5.42)
AUD_SPK_R+_C:
  vias: v4(162.95,10.09)
AUD_SPK_R-: length 27
  TOP w0.203: v4(182.25,19.09) 182.2,19.04 182.11,19.04 182.11,19.03 182.11,18.15 182.11,18.15 U2701.37
  L6 w1.016: v4(163.48,5.48) 166.44,5.48 167.39,6.43 169.78,6.43 171.21,7.86 171.41,7.86 172.47,8.91 173.88,8.91 175.02,10.05 175.02,10.1 175.17,10.24 175.17,10.88 180.28,15.99 180.28,16.52 182.25,18.5 v4(182.25,19.09)
  vias: v1(163.66,6.12)
AUD_SPK_R-_C:
  vias: v1(165.87,10.14) v4(164.88,10.29)
AUD_VREF: length 2.9
  TOP w0.203: U2701.22 185.54,13.76 186.13,13.18
  TOP w0.254: C2702.2 187,12.69 186.66,13.03 186.51,13.18 186.13,13.18
AUX_EN_WOWL: length 1.9
  TOP w0.102: v2(101.57,46.85) 101.13,46.41 101.13,45.86 TP1715.1
  BOTTOM w0.102: CPU1.BT30 101.23,47.19 v2(101.57,46.85)
BAT1_LED#: length 10.4
  TOP w0.127: v2(20.11,15.45) 20.11,15.47 20.13,15.49 RN2405.6
  BOTTOM w0.127: v2(20.11,15.45) 20.11,16.48 19.13,17.47 U2401.106 15.37,17.47 14.84,18 14.84,18.4 14.04,19.19 v1(13.83,19.19) 13.53,19.5 13.5,19.5 Q2416.4
BAT2_LED#: length 35.3
  TOP w0.127: RN2405.5 19.54,15.26 v2(19.49,15.21) 19.48,15.2 v1(19.48,14.47)
  L6 w0.127: v2(17.17,28.73) 17.2,28.73 18.6,27.32 18.99,27.32 19.98,26.33 19.98,24.46 20.56,23.88 21.12,23.88 21.68,23.32 21.68,19.22 19.49,17.02 v2(19.49,15.21)
  BOTTOM w0.127: U2401.1 18.57,28.08 17.92,28.73 v2(17.17,28.73) 17.13,28.73 16.36,27.96 16.31,27.96 16.14,27.79 15.18,27.79 14.71,28.25 10.89,28.25 10.57,27.93 10.57,21.82 10.81,21.58 11.73,21.58 Q2416.1
BAT_AMBER: length 3.4
  TOP w0.254: LED1.1 5.43,72.77 v2(5.44,72.76)
  BOTTOM w0.254: R6401.2 3.8,72.55 v1(4.79,72.55) 5.23,72.55 v2(5.44,72.76)
BAT_WHITE: length 3.9
  TOP w0.254: v2(5.62,71.09) 5.43,71.27 LED1.2
  BOTTOM w0.254: v2(5.62,71.09) 5.62,70.93 4.89,70.2 v1(4.83,70.2) 4.75,70.2 4.31,70.64 4.21,70.64 3.73,71.12 R6402.2
BATT_WHITE_LED#: length 63.8
  TOP w0.127: v2(12.98,69.83) 13.03,69.88 13.03,70.28 Q6403.D 13.15,70.94 v1(13.76,70.94)
  L3 w0.127: v2(8.66,27.11) 9.47,27.11 13.52,31.15 13.52,32.47 13.51,32.47 13.51,34.41 14.16,35.06 14.16,39.44 12.98,40.62 12.05,40.62 10.33,42.34 10.33,49.29 11.89,50.85 12.42,50.85 13.01,51.43 13.01,52.27 12.59,52.69 12.59,65.21 13.01,65.63 13.01,66.99 11.57,68.43 11.57,69.72 11.83,69.98 12.83,69.98 v2(12.98,69.83)
  BOTTOM w0.127: v2(8.66,27.11) 8.66,26.3 10.02,24.94 10.02,21.6 10.81,20.81 10.81,20.26 11.13,19.94 11.74,19.94 Q2416.6 ; Q6404.4 13.03,69.92 12.98,69.87 v2(12.98,69.83) 12.74,69.58 R6422.2
BATT_WHITE_LED_R#: length 10.2
  TOP w0.127: v1(15.05,70.13) 15.05,69.79 v2(15.24,69.6)
  L8 w0.127: v2(15.24,69.6) 15.24,70.15 12.46,72.93 11.5,72.93 v2(11.43,72.99)
  BOTTOM w0.127: Q6401.B 11.43,72.66 v2(11.43,72.99) ; R6422.1 14.76,69.12 v2(15.24,69.6) 15.25,69.6 15.25,70.27 15,70.51 Q6404.3
BEEP: length 159.1
  TOP w0.254: v2(39.88,14.35) 40.41,14.89 42.31,14.89 42.48,14.72 44.38,14.72 44.62,14.96 46.27,14.96 47.58,13.65 58.72,13.65 61.7,10.67 71.06,10.67 72.87,12.48 76.03,12.48 81.09,7.42 82,7.42 v2(87.51,1.91) ; R2734.1 175.68,5.26 169.1,5.26 168.34,6.02 167.51,6.02 166.48,4.99 166.48,4.63 164.73,2.88 163.37,2.88 162.6,2.11 v2(162.3,2.11)
  L3 w0.254: v2(162.3,2.11) 162.22,2.11 161.72,1.61 161.19,1.61 161.11,1.69 159.26,1.69 158.86,1.29 156.16,1.29 155.87,1 150,1 149.71,1.29 147.14,1.29 146.72,1.7 136.37,1.7 135.96,1.29 133.34,1.29 133.14,1.08 129.43,1.08 129.23,1.29 111.09,1.29 110.94,1.29 110.82,1.29 110.01,1.31 108.34,1.31 108.33,1.31 88.1,1.31 v2(87.51,1.91)
  BOTTOM w0.203: 33.74,21.47 U2401.45
  BOTTOM w0.254: v2(39.88,14.35) 39.88,16.86 37.17,19.57 37.17,20.46 36.45,21.17 v1(35.43,21.17) 34.19,21.17 33.9,21.47 33.74,21.47
BKLT_CTRL: length 11.8
  TOP w0.127: D5502.3 62.98,86.6 62.98,85.07 R5502.1 63.27,84.78 63.27,84 v1(63.23,83.96) 62.71,83.96 v2(62.47,84.19) 62.31,84.36 62.29,84.36 61.94,84.71 RN5505.4 ; RN5502.5 v2(58.69,87.3)
  L8 w0.127: v2(62.47,84.19) 62.45,84.19 61.86,84.78 61.86,86.26 60.82,87.3 v2(58.69,87.3)
BKLT_IN_EC: length 5.8
  BOTTOM w0.102: R2440.1 33.72,11.54 v1(33.78,11.48) 33.56,11.26 30.27,11.26 30.17,11.36 U2401.67
BL_PWR_MONITOR: length 3.1
  TOP w0.102: Q5508.B 42.49,76.11 42.49,75.85 43.06,75.28 v1(43.06,74.89) 42.68,74.5 42.66,74.5 42.51,74.35 42.2,74.35
BL_PWR_MONITOR_BJT_B: length 3.7
  BOTTOM w0.102: v1(49.28,71.33) 49.03,71.58 Q5512.B 48.12,71.59 48.12,72.7 48.6,73.18 R5533.2
BL_PWR_MONITOR_BJT_C: length 5.9
  TOP w0.102: R5534.1 42.86,73.49 43.27,73.89 43.66,73.89 v1(44.14,73.41) 44.18,73.37 45.06,73.37 v2(45.35,73.67)
  BOTTOM w0.102: Q5512.C 46.69,73.23 45.78,73.23 v2(45.35,73.67)
BL_PWR_MONITOR_R: length 22.1
  TOP w0.102: v2(50.08,74.4) v1(50.08,73.84)
  L5 w0.102: v2(50.08,74.4) 49.13,75.35 42.93,75.35 40.17,72.59 40.17,68.92 39.34,68.08 v3(38,68.08)
  BOTTOM w0.102: v2(50.08,74.4) 49.59,74.4 49.47,74.27 R5533.1 C5557.1 49.47,72.65 49.52,72.6 R5532.1 ; v3(38,68.08) 38,67.78 37.66,67.44 D5504.K
BLON_OUT_C: length 25
  TOP w0.102: RN5501.2 58.93,86.2 ; 58.93,86.2 v2(58.43,86.7) ; 58.93,86.2 58.99,86.26 58.99,86.65 59.06,86.72 59.75,86.72 59.91,86.88 RN5502.6
  L5 w0.102: v2(41.99,80.31) 41.99,81.25 43.03,82.29 55.94,82.29 56.94,83.29 56.94,84.9 57.21,85.17 57.21,85.48 v2(58.43,86.7)
  BOTTOM w0.102: LCD1.8 41.6,79.63 41.99,80.01 v2(41.99,80.31)
BLUETOOTH_EN: length 89.6
  TOP w0.102: v2(166.85,32.2) 166.85,30.88 164.57,28.6 164.57,24.73 165.09,24.21 165.09,23.8 166.98,21.91 AFTP6112.1 166.98,19.29 R6110.1
  L6 w0.102: v2(122.58,60.56) 122.88,60.87 129.62,60.87 131.34,59.15 131.34,58.99 133.23,57.1 133.26,57.1 133.43,56.93 134.96,56.93 135.27,56.63 136.15,56.63 136.32,56.46 136.34,56.46 136.58,56.22 136.58,56.2 136.87,55.91 137,55.91 137.31,55.6 v2(137.31,55.14)
  L8 w0.102: v2(166.85,32.2) 166.41,32.64 166.41,33.03 166.73,33.35 166.73,37.77 163.9,40.61 163.9,42.93 159.53,47.3 159.25,47.3 159.02,47.54 159.02,48.03 158.76,48.29 158.76,48.3 154.98,52.08 151.32,52.08 150.48,52.92 148.18,52.92 147.32,52.07 141.88,52.07 141.07,52.87 139.58,52.87 v2(137.31,55.14)
  BOTTOM w0.076: CPU1.CP14 112.06,57.38 112.25,57.57 arc(112.32,57.62) 112.4,57.64 114.53,57.64 114.68,57.49 115.05,57.49 115.45,57.88 115.8,57.88
  BOTTOM w0.102: 115.8,57.88 116.37,57.88 116.47,57.98 120.06,57.98 120.26,58.19 120.26,58.25 v1(120.9,58.88) v2(122.58,60.56)
BLUETOOTH_EN_R: length 5.8
  TOP w0.102: R6115.2 165.9,17.27 v1(166.28,17.66) 167.01,18.39 R6110.2 167.6,17.81 168.72,17.81 v2(168.79,17.73)
  BOTTOM w0.102: v2(168.79,17.73) 168.64,17.73 168.33,18.05 WLAN1.54
BOARD_ID: length 5.5
  BOTTOM w0.102: R2443.2 14.11,21.26 14.11,20.05 14.3,19.86 R2444.1 14.55,19.86 C2408.1 15.33,19.25 15.59,19 v1(15.83,19) 16.3,19.47 U2401.111
BOARD_ID1: length 26.2
  TOP w0.102: v1(128.84,58.83) 128.84,58.87 v2(129.24,59.27)
  L6 w0.102: v2(107.5,58.06) 108.14,57.43 109.33,57.43 109.33,57.43 112.76,57.43 112.98,57.65 114.02,57.65 114.45,57.22 116.82,57.22 117,57.4 118.12,57.4 119.03,58.31 122.82,58.31 123.25,58.74 126.53,58.74 127.06,59.27 127.69,59.27 127.69,59.27 v2(129.24,59.27)
  BOTTOM w0.102: CPU1.CG12 107.91,58.47 v2(107.5,58.06) ; R2009.1 v2(129.24,59.27) 128.91,59.27 R2010.2
BOARD_ID2: length 9.9
  BOTTOM w0.076: CPU1.CM14 110.87,57.65 112.04,57.65 112.13,57.74 arc(112.19,57.75) 112.24,57.78 112.26,57.8 114.6,57.8 114.73,57.67 114.85,57.67
  BOTTOM w0.102: R2008.1 v1(118.87,58.44) 116.55,58.44 116.19,58.09 115.4,58.09 114.98,57.67 114.85,57.67
BPM_CPU_N2: length 7.7
  BOTTOM w0.102: CPU1.U3 77.29,64.44 77.56,64.7 77.56,65.68 77.36,65.88 77.36,65.97 75.65,67.69 75.17,67.69 75.06,67.8 74.67,67.8 74.63,67.84 74.62,67.84 74.31,68.15 74.31,68.16 74.05,68.42 74.05,68.8 73.31,69.55 TP302.1
BPM_CPU_N3: length 8.3
  BOTTOM w0.102: TP303.1 72.55,67.66 73.75,67.66 74.49,66.92 75.55,66.92 76.67,65.81 76.67,65.09 77,64.77 77,64.09 77.29,63.8 CPU1.U4
BPM_N0: length 5.1
  BOTTOM w0.102: CPU1.U1 77.13,65.69 77.13,65.93 75.66,67.41 74.61,67.41 73.67,68.35 TP307.1
BPM_N1: length 8.2
  BOTTOM w0.102: TP308.1 72.03,69.56 72.33,69.26 72.33,68.3 72.76,67.86 73.85,67.86 74.59,67.13 75.66,67.13 76.87,65.91 76.87,65.25 77.25,64.87 CPU1.U2
BT+: length 27.6
  TOP w0.508: PR4483.2 138.64,6.7 137.23,6.7 136.08,5.55 131.95,5.55 129.13,2.73 114.73,2.73 113.52,3.94 113.52,4.09 113.37,4.09
  vias: v1(102.6,12.78) v2(112.77,4.59)
BT_PCMFRM_RSTN: length 3.9
  TOP w0.102: R1913.1 167.83,29.03 v1(168.32,28.54) 168.32,28.68 v2(168.77,29.13) 168.87,29.13 169.01,28.99 R6120.2
  BOTTOM w0.102: v2(168.77,29.13) 168.69,29.05 WLAN1.10
BT_PCMOUT_CLKREQ0: length 4.2
  TOP w0.102: R6119.2 168.2,27.64 v2(168.67,28.1) 168.74,28.18 R1912.1 169.5,27.38 v1(169.41,27.29)
  BOTTOM w0.102: WLAN1.14 168.61,28.05 v2(168.67,28.1)
BT_USB20_CON_N: length 19.5
  TOP w0.102: R6104.1 164.37,17.95 164.63,17.68 164.78,17.68 165.12,18.02 165.12,18.16 v2(164.75,18.53) AFTP6111.1
  BOTTOM w0.102: WLAN1.5 160.02,30.33 160.94,30.33 161.16,30.55 161.95,30.55 164.62,27.88 164.62,24.61 164.9,24.32 164.9,23.13 165.52,22.51 165.52,21.25 165.17,20.9 165.17,18.95 v2(164.75,18.53)
BT_USB20_CON_P: length 19.4
  TOP w0.102: AFTP6114.1 165.6,19.36 165.6,18.59 v2(165.54,18.53) 165.35,18.34 165.36,18.34 165.36,18.33 165.35,18.32 165.35,17.92 164.87,17.45 164.63,17.45 164.37,17.18 R6105.1
  BOTTOM w0.102: v2(165.54,18.53) 165.38,18.69 165.38,18.83 165.4,18.86 165.4,20.8 165.75,21.15 165.75,22.6 165.13,23.22 165.13,24.41 164.84,24.7 164.84,27.97 162.04,30.78 159.94,30.78 WLAN1.3
BT_USB20_N: length 112.3
  TOP w0.102: v2(162.33,17.95) R6104.2
  L3 w0.089: v2(105.22,70.54) 105.22,70.6 105.39,70.76 105.65,70.76 105.73,70.67 105.73,70.09 105.81,70.02 106.33,70.02 107.61,68.73 114.22,68.73 119.43,63.53 123.93,63.53 124.46,63 124.46,62.31 125.3,61.47 125.98,61.47 128.23,59.23 128.23,58.87 129.11,57.98 129.11,57.5 130.5,56.12 130.5,48.77 131.07,48.2 131.07,44.96 132.72,43.3 132.72,40.79 131.9,39.97 131.9,33.85 131.32,33.27 131.32,30.78 130.75,30.21 130.75,25.47 128.92,23.65 128.92,22.51 129.4,22.03 141.31,22.03 142.48,20.86 143.56,20.86 145.37,19.05 153.39,19.05 154.77,17.66 158.55,17.66 158.58,17.63 161.99,17.63 162.3,17.95 v2(162.33,17.95)
  BOTTOM w0.083: CPU1.CC3 105.45,64.23 105.3,64.37 105.25,64.57 105.25,64.66 105.19,64.77 105.19,64.95 105.22,65.06 105.22,65.34 105.19,65.42 105.19,65.6 105.28,65.91 105.35,65.98 105.35,66.02 105.37,66.04 105.37,66.1 105.4,66.12 105.4,66.14 105.45,66.19 105.45,66.2
  BOTTOM w0.102: v2(105.22,70.54) 105.22,70.44 105.39,70.27 105.71,70.27 105.94,70.04 105.94,69.6 105.58,69.24 105.58,66.75 105.49,66.66 105.49,66.66 105.45,66.62 105.45,66.2
BT_USB20_P: length 112
  TOP w0.102: R6105.2 162.36,17.18 v2(162.33,17.16)
  L3 w0.089: v2(105.18,69.83) 106.25,69.83 107.53,68.54 114.14,68.54 119.35,63.34 123.85,63.34 124.27,62.92 124.27,62.23 125.22,61.28 125.9,61.28 128.04,59.15 128.04,58.79 128.92,57.91 128.92,57.42 130.3,56.04 130.3,48.69 130.88,48.12 130.88,44.88 132.53,43.23 132.53,40.87 131.71,40.05 131.71,33.93 131.13,33.35 131.13,30.86 130.56,30.28 130.56,25.55 128.73,23.72 128.73,22.43 129.32,21.84 141.23,21.84 142.4,20.67 143.48,20.67 145.29,18.86 153.31,18.86 154.69,17.47 158.47,17.47 158.5,17.44 162.05,17.44 v2(162.33,17.16)
  BOTTOM w0.083: CPU1.CC4 105.36,63.53 105.2,63.59 105.08,64.04 105.08,64.62 105.02,64.73 105.02,65.02 105.04,65.04 105.05,65.13 105.05,65.27 105.03,65.37 105.02,65.39 105.02,65.63 105.09,65.86 105.13,66 105.18,66.05 105.18,66.09 105.2,66.11 105.2,66.18 105.22,66.2
  BOTTOM w0.102: 105.22,66.2 105.22,66.71 105.26,66.75 105.26,66.76 105.35,66.85 105.35,69.34 105.71,69.7 105.71,69.95 105.62,70.04 105.4,70.04 v2(105.18,69.83)
C_SD_CLK: length 1.7
  BOTTOM w0.127: U3301.19 7.67,16.46 7.18,16.95 R3309.1
C_SD_CMD: length 1.9
  BOTTOM w0.127: U3301.21 8.47,16.83 8.77,17.14 R3308.1
C_SD_D0: length 2.9
  BOTTOM w0.127: R3310.1 5.44,17.18 5.71,17.18 6.58,16.31 7.14,16.31 7.27,16.18 U3301.18
C_SD_D1: length 3.2
  BOTTOM w0.127: R3311.1 4.47,17.21 4.77,16.92 5.6,16.92 6.76,15.76 U3301.17
C_SD_D2: length 2.6
  BOTTOM w0.127: U3301.23 9.27,16.56 v1(9.53,16.83) 10.39,17.68 R3306.1
C_SD_D3: length 2.3
  BOTTOM w0.127: R3307.1 9.61,17.46 8.87,16.71 U3301.22
C_SD_WP: length 1.4
  BOTTOM w0.127: U3301.25 10.23,15.39 R3333.1
CA_VREF: length 33.3
  TOP w0.254: v3(107.39,22.05) 107.4,22.05 107.4,22.08 107.71,22.39 107.71,22.47 RAM4.H4 ; RAM2.H4 69.61,22.47 69.61,22.37 69.34,22.11 69.34,22.07 v3(69.31,22.07) ; v3(88.22,22.06) 88.23,22.06 88.23,22.06 88.26,22.09 88.26,22.2 88.53,22.47 RAM3.H4 ; v3(50.78,26.61) 50.78,26.51 RAM1.H4
  TOP w0.508: v2(60.8,33.86) 60.82,33.87 60.82,35.33 R1228.1 ; C1214.1 60.11,25.28 v2(60.16,25.33) ; C1214.1 C1329.1 ; C1214.1 R1227.2 ; C1314.1 79.62,20.68 R1226.1 ; R1226.1 79.43,20.71 78.92,20.2 C1229.1 ; R1226.1 79.59,20.55 79.72,20.42 79.72,20.37 79.94,20.15 79.99,20.15 80,20.14 v2(80,20.05)
  L3 w0.508: v2(60.8,33.86) 62.19,32.47 62.19,29.16 60.56,27.53 60.56,26.66 60.16,26.26 60.16,25.42 60.2,25.37 v2(60.16,25.33)
  L8 w0.508: 65.37,21.26 63.59,21.26 61.05,23.8 61.05,24.44 v2(60.16,25.33) 59.78,24.95 52.77,24.95
CAD_SNK: length 2.2
  TOP w0.102: R7118.2 16.75,38.86 v1(17.39,38.86) 17.79,38.86 18.04,38.61 U7101.29
CAP_LED: length 7.4
  TOP w0.254: R6513.2 61.79,2.94 61.79,3.15 62.05,3.41 AFTP6538.1 61.95,4.2 v2(61.22,4.2)
  BOTTOM w0.254: KB1.4 59.5,6.66 61,5.16 61,4.43 v2(61.22,4.2)
CAP_LED#: length 38.1
  TOP w0.127: R2489.2 16.32,11.58 16.83,11.06 16.83,11.09 v2(16.83,11.09) ; Q2414.S 42.95,11.74 v2(42.74,11.53)
  L3 w0.127: v2(42.74,11.53) 42.39,11.18 40.29,11.18 40.09,11.38 38.38,11.38 38.23,11.22 30.23,11.22 29.97,11.48 28.93,11.48 27.8,10.34 24.07,10.34 22.61,8.88 17.66,8.88 15.73,10.81 15.73,11.18 15.99,11.44 16.48,11.44 v2(16.83,11.09)
  BOTTOM w0.127: v2(16.83,11.09) 16.83,11.09 16.83,11.06 17.08,10.82 18.56,10.82 v1(18.57,10.83) 19.07,10.83 19.77,11.53 U2401.93
CAP_LED#_R: length 6.2
  TOP w0.127: v2(47.21,11.69) 45.09,13.81 Q2414.D
  BOTTOM w0.127: Q6505.B 48.72,10.19 v1(48.01,10.89) v2(47.21,11.69)
CAP_LED_Q: length 16.4
  TOP w0.254: v2(61.94,1.37) 61.94,1.45 61.89,1.5 R6513.1
  L5 w0.254: v2(61.94,1.37) 61.94,2.61 55.94,8.6 v2(55.94,9.38)
  BOTTOM w0.254: v2(55.94,9.38) 55.61,9.38 54.96,10.03 54.38,10.03 v1(53.57,10.85) 53.28,11.14 Q6505.C
CARD_CD_N: length 12.7
  TOP w0.127: v2(14.19,17.8) 14.6,17.8 14.88,17.52 14.88,16.48 15.24,16.12 15.24,13.27 14.83,12.86 CARD1.12
  BOTTOM w0.127: v2(14.19,17.8) 14.02,17.97 v1(13.34,17.97) 12.93,17.97 12.67,17.7 10.95,17.7 10.94,17.72 9.67,16.44 U3301.24
CARD_CLK: length 13.6
  TOP w0.127: v2(2.51,14.97) 2.47,14.97 2.29,14.79 CARD1.5
  L3 w0.127: v2(7.79,19.87) 6.96,19.87 4.66,17.57 4.66,15.9 3.97,15.2 2.75,15.2 v2(2.51,14.97)
  BOTTOM w0.127: v2(7.79,19.87) 7.33,19.87 6.31,18.85 C3301.1 6.32,18.05 R3309.2 ; v2(2.51,14.97) 2.21,14.66 v1(2.04,14.66)
CARD_CMD: length 14.6
  TOP w0.127: v2(2.53,13) 2.12,12.59 CARD1.3
  L3 w0.127: v2(8.77,20.09) 8.77,19.82 6.41,17.46 5.62,17.46 5.1,16.94 5.1,16.94 5,16.83 5,14.43 3.57,13 v2(2.53,13)
  BOTTOM w0.127: R3308.2 8.81,18.4 8.81,20.05 v2(8.77,20.09) ; v1(1.99,13.37) 2.16,13.37 v2(2.53,13)
CARD_SDATA0: length 10.5
  TOP w0.127: CARD1.7 v2(2.58,16.99)
  L3 w0.127: v2(6.1,19.66) 5.96,19.66 4.18,17.88 4.18,16.02 3.93,15.77 3.58,15.77 2.58,16.78 v2(2.58,16.99)
  BOTTOM w0.127: v2(2.58,16.99) 2.18,17.38 v1(2.18,17.4) ; v2(6.1,19.66) 5.25,18.81 R3310.2
CARD_SDATA1: length 8
  TOP w0.127: v2(5.45,19.84) 4.93,19.84 v1(4.76,20.01) ; v2(3.2,17.62) 2.73,18.09 CARD1.8
  L3 w0.127: v2(5.45,19.84) 5.41,19.8 5.38,19.8 v2(3.2,17.62)
  BOTTOM w0.127: R3311.2 4.47,18.87 v2(5.45,19.84)
CARD_SDATA2: length 16.3
  TOP w0.127: v2(2.52,10.95) 2.54,10.95 1.97,10.39 CARD1.1
  L3 w0.127: v2(9.87,19.86) 9.91,19.86 9.91,19.55 7.26,16.91 5.82,16.91 5.69,16.78 5.69,14.22 2.96,11.49 2.96,11.41 2.7,11.15 2.62,11.15 2.52,11.04 v2(2.52,10.95)
  BOTTOM w0.127: R3306.2 9.91,19.26 9.91,19.86 v2(9.87,19.86) ; v1(1.97,10.74) 2.31,10.74 v2(2.52,10.95)
CARD_SDATA3: length 16.6
  TOP w0.127: CARD1.2 1.41,11.59 v2(2.52,11.59)
  L3 w0.127: v2(2.52,11.59) 5.36,14.43 5.36,16.84 5.72,17.2 6.83,17.2 9.36,19.72 v2(9.36,20.65)
  BOTTOM w0.127: v1(2.03,11.96) 2.15,11.96 v2(2.52,11.59) ; v2(9.36,20.65) 9.36,19.16 9.61,18.91 R3307.2
CBN: length 5
  TOP w0.203: U2701.28 186.02,16.16 v1(186.1,16.24) 186.33,16.46 189.41,16.46 C2708.2
CBP: length 5.9
  TOP w0.203: 188.4,18.65 186.22,18.65 185.5,17.92 185.5,17.78 185.2,17.48 U2701.30
  TOP w0.254: 188.4,18.65 188.53,18.52 189.62,18.52 C2708.1
CCD_USB20_CON_N: length 10.1
  BOTTOM w0.102: LCD1.35 52.4,78.56 52.28,78.44 52.28,78.43 52.18,78.33 52.18,76.86 ; v1(52.39,76.86) 52.18,76.86 ; 52.18,76.86 52.18,76.17 52.29,76.07 53.01,76.07 53.26,75.81 53.49,75.81 54.17,75.14 54.17,74.86 54.17,73.85 54.33,73.69 ED5501.6 55,73.69 55.25,73.43 55.41,73.43 55.81,73.82 56.37,73.82 56.47,73.92 56.47,74.19 56.62,74.34 EL5501.2
CCD_USB20_CON_P: length 10.3
  BOTTOM w0.102: LCD1.34 51.96,78.78 51.96,76.39 51.94,76.38 51.94,75.76 52.12,75.59 ED5501.3 53.4,75.59 53.94,75.05 53.94,74.95 53.94,74.95 53.94,73.75 54.49,73.2 55.51,73.2 55.9,73.59 56.15,73.59 ; 56.15,73.59 56.4,73.59 56.41,73.59 56.95,73.59 EL5501.3 ; 56.15,73.59 v1(56.15,73.39)
CCD_USB20_N: length 68.3
  L8 w0.089: v2(108.63,71.3) 108.65,71.3 108.86,71.51 108.86,72.12 108.21,72.76 97.19,72.76 95.53,74.42 94.94,74.42 93.02,72.5 90.77,72.5 90.47,72.8 84.07,72.8 83.87,73 83.87,73.59 83.78,73.68 83.48,73.68 83.4,73.59 83.4,73 83.2,72.8 82.75,72.8 82.54,73 82.54,73.59 82.46,73.68 82.16,73.68 82.08,73.59 82.08,73 81.87,72.8 80.55,72.8 79.92,73.44 66.17,73.44 65.5,74.11 64.95,74.11 64.8,74.27 64.8,74.72 v2(64.91,74.83)
  BOTTOM w0.083: 105.66,66.08 105.65,66.07 105.65,66 105.64,65.99 105.64,65.96 105.55,65.87 105.55,65.78 105.51,65.74 CPU1.CC1
  BOTTOM w0.102: EL5501.1 58,74.34 58.09,74.24 58.09,73.93 58.21,73.82 61.28,73.82 61.92,73.19 63.62,73.19 64.72,74.29 65.08,74.29 65.19,74.4 65.19,74.55 v2(64.91,74.83) ; v2(108.63,71.3) 108.83,71.1 108.83,70.41 108.57,70.15 107.21,70.15 106.65,69.59 106.61,69.59 105.88,68.87 105.88,66.71 105.8,66.63 105.8,66.22 105.66,66.08
