# Allegro board 18769-1-MAR04-1554.brd (continued)
## Nets (continued)
FFS_INT2: CPU1.CH12 R2044.2 R7006.2
FP1_USB20_CON_N: ED9201.1 ED9201.10 FP1.3 R9209.2
FP1_USB20_CON_P: ED9201.2 ED9201.9 FP1.4 R9210.2
FP1_USB20_N: CPU1.CG5 R9209.1
FP1_USB20_P: CPU1.CG6 R9210.1
FP_3D3V: Q9201.D R9213.1
FP_EN#: Q9201.G Q9202.D R9212.2
FPR_SCAN#: FP1.7 R9201.2 U2401.42
FWP/GPIO2: R3314.1 U3301.29
GC6_FB_EN: D8601.1 Q7907.3 R2004.1 R7937.2 R7953.2
GC6_FB_EN_GPU: GPU1.B2 Q7907.2 R7927.1 R7937.1
GC6_FB_EN_GPU_L: Q7907.5 Q7907.6 R7952.2
GC6_FB_EN_MCP: CPU1.CE28 R2004.2
GC6_PWR_EN: R8626.2 U8605.2
GC6_THM_DIS#: CPU1.CR26 R2447.2
GC6_THM_DIS#_EC: R2426.1 R2447.1 R2471.2 U2401.23
GFX_CLK_CPU_N: CPU1.AW2 GPU1.AD8
GFX_CLK_CPU_P: CPU1.AY3 GPU1.AE8
GFX_PCIE_RX_CON_N0: C7602.2 GPU1.AB9
GFX_PCIE_RX_CON_N1: C7604.2 GPU1.AC10
GFX_PCIE_RX_CON_N2: C7606.2 GPU1.AC11
GFX_PCIE_RX_CON_N3: C7608.2 GPU1.AB12
GFX_PCIE_RX_CON_P0: C7601.2 GPU1.AC9
GFX_PCIE_RX_CON_P1: C7603.2 GPU1.AB10
GFX_PCIE_RX_CON_P2: C7605.2 GPU1.AD11
GFX_PCIE_RX_CON_P3: C7607.2 GPU1.AC12
GFX_PCIE_RX_N0: C7602.1 CPU1.BW9
GFX_PCIE_RX_N1: C7604.1 CPU1.BU6
GFX_PCIE_RX_N2: C7606.1 CPU1.BT7
GFX_PCIE_RX_N3: C7608.1 CPU1.BU9
GFX_PCIE_RX_P0: C7601.1 CPU1.BW8
GFX_PCIE_RX_P1: C7603.1 CPU1.BU5
GFX_PCIE_RX_P2: C7605.1 CPU1.BT6
GFX_PCIE_RX_P3: C7607.1 CPU1.BU8
GFX_PCIE_TX_C_N0: C1606.2 CPU1.BW4
GFX_PCIE_TX_C_N1: C1608.2 CPU1.BU4
GFX_PCIE_TX_C_N2: C1610.2 CPU1.BU2
GFX_PCIE_TX_C_N3: C1612.2 CPU1.BT4
GFX_PCIE_TX_C_P0: C1605.2 CPU1.BW3
GFX_PCIE_TX_C_P1: C1607.2 CPU1.BU3
GFX_PCIE_TX_C_P2: C1609.2 CPU1.BU1
GFX_PCIE_TX_C_P3: C1611.2 CPU1.BT3
GFX_PCIE_TX_N0: C1606.1 GPU1.AG7
GFX_PCIE_TX_N1: C1608.1 GPU1.AE7
GFX_PCIE_TX_N2: C1610.1 GPU1.AF9
GFX_PCIE_TX_N3: C1612.1 GPU1.AG10
GFX_PCIE_TX_P0: C1605.1 GPU1.AG6
GFX_PCIE_TX_P1: C1607.1 GPU1.AF7
GFX_PCIE_TX_P2: C1609.1 GPU1.AE9
GFX_PCIE_TX_P3: C1611.1 GPU1.AG9
GPD11/LANPHYPC: CPU1.BU34 R1721.2
GPD_7: CPU1.BV35 R1524.2 R1525.1
GPIO3: R3322.1 U3301.28
GPIO4: R3323.1 U3301.27
GPIO5_GC6_NVVDD_OR: Q8509.5 R8525.2
GPIO5_GC6_PWR_1V: R8614.1 U8605.4
GPIO5_GC6_PWR_1V_A: R8614.2 U8604.1
GPIO5_GC6_PWR_B: Q8601.D R8626.1 R8635.2
GPIO5_GC6_PWR_EN: GPU1.F9 Q8601.S Q8612.5 R7933.2 R8525.1
GPIO9_ALERT: GPU1.F8 RN7910.4(B)
GPIO10_FBVREF: GPU1.C5 Q8101.G R7910.2
GPP_B22_GSPI1_MOSI: CPU1.CA30 R1553.1
GPP_E3/CPU_GP0: CPU1.CE9 TP304.1
GPP_H1_SFRM: CPU1.CJ32 R1913.2
GPP_H2_CLKREQ0: CPU1.CH29 R1912.2
GPP_H17_STRAP: CPU1.CP26 R1527.1
GPP_H21: CPU1.CF25 R1522.2 R1523.1
GPP_H23: CPU1.CM26 R1513.2 R1514.1
GPPC_H18_BOOTMPC: CPU1.CN27 R2119.1
GPPC_H18_VCCIO_LPM: R2119.2 R4040.2 R4041.2 U4008.2
GPU_CLKREQ#: GPU1.AC6 Q7601.S R7603.2
GPU_EVENT#: Q7906.D R2003.1 R7948.2
GPU_EVENT_GPU#: GPU1.D6 Q7906.S R7949.2
GPU_EVENT_MCP#: CPU1.CC27 R2003.2
GPU_PWR_LEVEL: R2460.2 R2477.2 U2401.10
GPU_ROM_SCLK: GPU1.C12 R7920.2 R7921.1
GPU_ROM_SI: GPU1.B12 R7924.1 R7935.2
GPU_ROM_SO: GPU1.A12 R7918.2 R7932.1
GPU_THM_SMBCLK: R2406.1 R6602.1 U2401.12
GPU_THM_SMBDAT: R2405.1 R6601.1 U2401.11
GSEN2_INT1: R7003.1 R7005.1 U7002.12
GSEN2_INT1_C: R2025.2 R7003.2
GSEN2_INT1_ISH: CPU1.BW35 R2025.1
GSEN2_INT2: R7004.1 R7006.1 U7002.11
GSEN2_INT2_C: R2026.2 R7004.2
GSEN2_INT2_ISH: CPU1.BW34 R2026.1
GSENSOR_CS: R7016.1 U7002.2
GSENSOR_SDO: R7002.1 R7008.2 U7002.3
H_CPUPWRGD: CPU1.AR2 ED301.2
H_PECI: C2405.1 R2437.1 U2401.94
HALL_VCC: C6715.1 HALL1.1 R6744.2 R6745.2
HDA_BITCLK_CODEC: EC1901.1 EC2710.1 R1920.1 R2723.1
HDA_BITCLK_CODEC_R: R2723.2 U2701.5
HDA_BITCLK_CPU: CPU1.BN37 R1920.2
HDA_CODEC_SDIN0: R2724.2 U2701.7
HDA_RST_N_CPU: CPU1.BL35 TP1903.1
HDA_SDIN0_CPU: CPU1.BN35 R2724.1
HDA_SDOUT_CODEC: EC2709.1 R1921.1 U2701.4
HDA_SDOUT_CPU: CPU1.BN36 R1512.2 R1909.2 R1921.2
HDA_SPKR_R: D2703.1 R2741.2
HDA_SYNC_CODEC: R1908.1 U2701.9
HDA_SYNC_CPU: CPU1.BN34 R1908.2
HDMI_DDI_TX_CMC_N0: C5708.2 R5707.1 RN5702.3(A)
HDMI_DDI_TX_CMC_N1: C5706.2 R5703.1 RN5702.1(A)
HDMI_DDI_TX_CMC_N2: C5704.2 R5705.1 RN5703.1(A)
HDMI_DDI_TX_CMC_N3: C5702.2 R5701.1 RN5703.3(A)
HDMI_DDI_TX_CMC_P0: C5709.2 R5708.1 RN5702.4(A)
HDMI_DDI_TX_CMC_P1: C5707.2 R5704.1 RN5702.2(A)
HDMI_DDI_TX_CMC_P2: C5705.2 R5706.1 RN5703.2(A)
HDMI_DDI_TX_CMC_P3: C5703.2 R5702.1 RN5703.4(A)
HDMI_DDI_TX_CON_N0: ED5702.2 ED5702.9 ER5716.1 HDMI1.3 R5707.2
HDMI_DDI_TX_CON_N1: ED5702.5 ED5702.6 ER5717.1 HDMI1.6 R5703.2
HDMI_DDI_TX_CON_N2: ED5701.5 ED5701.6 ER5715.1 HDMI1.9 R5705.2
HDMI_DDI_TX_CON_N3: ED5701.2 ED5701.9 ER5714.1 HDMI1.12 R5701.2
HDMI_DDI_TX_CON_P0: ED5702.1 ED5702.10 ER5716.2 HDMI1.1 R5708.2
HDMI_DDI_TX_CON_P1: ED5702.4 ED5702.7 ER5717.2 HDMI1.4 R5704.2
HDMI_DDI_TX_CON_P2: ED5701.4 ED5701.7 ER5715.2 HDMI1.7 R5706.2
HDMI_DDI_TX_CON_P3: ED5701.1 ED5701.10 ER5714.2 HDMI1.10 R5702.2
HDMI_DDI_TX_N0: C5708.1 CPU1.AL5
HDMI_DDI_TX_N1: C5706.1 CPU1.AJ5
HDMI_DDI_TX_N2: C5704.1 CPU1.AF6
HDMI_DDI_TX_N3: C5702.1 CPU1.AE5
HDMI_DDI_TX_P0: C5709.1 CPU1.AL6
HDMI_DDI_TX_P1: C5707.1 CPU1.AJ6
HDMI_DDI_TX_P2: C5705.1 CPU1.AF5
HDMI_DDI_TX_P3: C5703.1 CPU1.AE6
HDMI_HPD_B: Q5701.B R5711.2
HDMI_HPD_CPU: CPU1.CN6 Q5701.E R5712.1
HDMI_PLL_GND: Q5703.D R5718.1 RN5702.5(B) RN5702.6(B) RN5702.7(B) RN5702.8(B) RN5703.5(B) RN5703.6(B) RN5703.7(B) RN5703.8(B)
HOST_DEBUG_TX: DB3.5 R2480.2 R6801.1 U2401.81
HOST_DEBUG_TX_CON: DB1.11 R6801.2
HPD_HDMI_CON: ED5703.2 ED5703.9 HDMI1.19 R5710.1 R5711.1
HPDIN: R7121.2 U7101.32
HVA_GATE1: R7218.1 U7201.B9
HVA_GATE2: R7219.1 U7201.A9
HW_ACAV_IN: D6402.K PR4490.1 U2401.128
HW_ACAVIN_NB: PR4471.1 R4378.2 U2401.24 U4302.1
I2C_CLK_PD: R7114.2 RN7206.3(B) U7201.D2
I2C_CLK_PD_MUX: R7114.1 U7101.21
I2C_DATA_PD: R7116.2 RN7206.4(B) U7201.D1
I2C_DATA_PD_MUX: R7116.1 U7101.22
I2CB_SCL: GPU1.C9 RN7905.1(A)
I2CB_SDA: GPU1.C8 RN7905.2(A)
I2CC_SCL: GPU1.A9 RN7904.2(A)
I2CC_SDA: GPU1.B9 RN7904.1(A)
I2CEN: R7173.1 R7174.2 U7101.17
I_ADP: C2435.1 R2421.1 U2401.110
I_BATT: C2441.1 R2423.2 U2401.114
IC_DELAY: C4344.1 U4302.4
ICSP_CLK: DB3.2 R2403.2 U2401.101
ICSP_CLR: DB3.6 R2414.2 U2401.87
ICSP_DAT: DB3.3 R2404.2 U2401.102
INPUT3VSEL: CPU1.BT27 R1520.2 R1521.1
INT_ITE8010: AFTP4317.1 IO2.2
IR_CAM_DET#: CPU1.CM22 R2046.2
ISH_TABLE_MODE#: CPU1.CA37 R2027.1
IST_TRIG: CPU1.CP36 TP620.1
ITP_PMODE: CPU1.W4 TP618.1
JGND: AFTP4301.1 AFTP4302.1 DCIN1.1 DCIN1.2 DCIN1.3 EC4301.2 EC4302.2 EC4312.2 EL4303.1 EL4304.1
JIO3_PCIE_WAKE#: AFTP6115.1 R1806.2 R1819.2 WLAN1.55
KB_BL_CTRL#: AFTP6530.1 KBBL1.4 Q6501.D
KB_DET#: CPU1.CM12 KB1.30 R2045.2
KB_LED_BL_DET: CPU1.CK23 R6507.1 R6508.1
KB_LED_DET_C: C6504.1 KBBL1.2 R6507.2
KB_LED_PWM: Q6501.G R6509.1 U2401.44
KBC_BEEP_R: D2703.2 R2734.2
KBC_PWRBTN#: FP1.2 Q6406.E R2432.1
KBC_SMB_SCL_BAT: AFTP4311.1 BATT1.5 RN4302.4(B)
KBC_SMB_SDA_BAT: AFTP4310.1 BATT1.6 RN4302.3(B)
KSI0: AFTP6512.1 KB1.22 RN2403.5(B) U2401.98
KSI1: AFTP6501.1 KB1.24 RN2403.7(B) U2401.99
KSI2: AFTP6508.1 KB1.26 RN2403.8(B) U2401.6
KSI3: AFTP6509.1 KB1.23 RN2403.6(B) U2401.7
KSI4: AFTP6505.1 KB1.27 RN2404.6(B) U2401.104
KSI5: AFTP6506.1 KB1.25 RN2404.5(B) U2401.105
KSI6: AFTP6503.1 KB1.28 RN2404.7(B) U2401.107
KSI7: AFTP6502.1 KB1.29 RN2404.8(B) U2401.108
KSO0: AFTP6507.1 KB1.13 RN2411.8(B) U2401.2
KSO1: AFTP6511.1 KB1.15 RN2412.6(B) U2401.14
KSO2: AFTP6513.1 KB1.14 RN2412.5(B) U2401.15
KSO3: AFTP6518.1 KB1.16 RN2412.7(B) U2401.16
KSO4: AFTP6514.1 KB1.20 RN2409.7(B) U2401.37
KSO5: AFTP6510.1 KB1.21 RN2409.8(B) U2401.38
KSO6: AFTP6517.1 KB1.18 RN2409.5(B) U2401.39
KSO7: AFTP6515.1 KB1.19 RN2409.6(B) U2401.50
KSO8: AFTP6516.1 KB1.17 RN2412.8(B) U2401.46
KSO9: AFTP6504.1 KB1.7 R2452.2 R2453.1 U2401.68
KSO10: AFTP6523.1 KB1.5 RN2410.6(B) U2401.72
KSO11: AFTP6522.1 KB1.6 RN2410.5(B) U2401.74
KSO12: AFTP6519.1 KB1.12 RN2411.7(B) U2401.75
KSO13: AFTP6520.1 KB1.9 RN2410.8(B) U2401.76
KSO14: AFTP6521.1 KB1.8 RN2410.7(B) U2401.77
KSO15: AFTP6524.1 KB1.10 RN2411.6(B) U2401.86
KSO16: AFTP6539.1 KB1.11 RN2411.5(B) U2401.92
L_BKLT_CTRL: CPU1.CH11 D5502.1 R5502.2
L_BKLT_EN: CPU1.CK11 R2427.1 R2440.2 R2455.1
L_BKLT_EN_L: D2401.2 R2427.2
LAN_WAKE#: CPU1.BU32 R1707.2
LCD_BRIGHTNESS: LCD1.9 RN5505.1(A)
LCD_TST: D5502.2 RN5501.4(B) U2401.26
LCD_TST_C: LCD1.10 RN5501.1(A)
LCD_VCC_TEST_EN: D5501.2 U2401.113
LCDVDD_MONITOR: Q5510.B R5539.2
LCDVDD_MONITOR_BJT_B: Q5509.B R5538.2
LCDVDD_MONITOR_BJT_C: Q5509.C R5539.1
LCDVDD_MONITOR_BJT_E: Q5509.E R5540.2
LCDVDD_MONITOR_R: C5555.1 D5505.K R5537.1 R5538.1
LDO1_CAP: C2703.1 R2702.1 U2701.21
LDO2_CAP: C2711.2 U2701.32
LDO3_CAP: C2722.1 U2701.6
LID_CL_NB#: C6701.1 D6701.K D6702.K HALL1.2 R6701.1 R6742.2 R6743.2
LID_CL_SIO#: CPU1.CA34 D2402.K D6702.A ED6701.1 FP1.6 RN2405.7(B) U2401.66 U6402.1
LID_CL_SIO_TAB#: CPU1.BW37 R2042.2
LID_POWER_ON#: R2495.2 R2497.2 U2401.126
LID_POWER_ON#_R: C6702.1 Q6701.3 R2495.1
LINE1_L: C2907.1 U2701.18
LINE1_R: C2908.1 U2701.17
LINE1_VREFO: D2901.3 U2701.24
LINE1_VREFO_L: D2901.1 RN2902.1(A)
LINE1_VREFO_R: D2901.2 RN2902.2(A)
LPS_SW: C7401.2 R7402.1 R7403.1 R7404.2 U7418.4
LPS_SW_A: Q7406.3 R7402.2
LPS_SW_B: Q7401.D R7403.2
LPS_SW_C: Q7401.G R7405.1 R7406.2
LPS_SW_D: Q7406.6 R7405.2
LVDS_VDD_EN_R: D5501.3 RN5502.7(B) U5501.4
M2_PCIE_LED2#: IO2.28 R6626.2
M2_PCIE_LED#: D6401.2 R6405.2 R6626.1 SSD1.10
M2_SSD_PEDET: AFTP6303.1 CPU1.CP10 R6305.2 SSD1.69
M_A_A0: CPU1.AB35 RAM1.R2 RN1201.5(B)
M_A_A1: CPU1.W36 RAM1.P2 RN1201.6(B)
M_A_A2: CPU1.AA37 RAM1.N2 RN1201.8(B)
M_A_A3: CPU1.AB34 RAM1.N3 RN1201.7(B)
M_A_A4: CPU1.AA36 R1206.2 RAM1.M3
M_A_A5: CPU1.V34 R1205.2 RAM1.F3
M_A_A6: CPU1.AA34 RAM1.E3 RN1202.3(B)
M_A_A7: CPU1.W34 RAM1.E2 RN1202.4(B)
M_A_A8: CPU1.V35 RAM1.D2 RN1206.3(B)
M_A_A9: CPU1.W35 RAM1.C2 RN1206.4(B)
M_A_B0: CPU1.AC32 RAM2.R2 RN1207.3(B)
M_A_B1: CPU1.AB32 RAM2.P2 RN1207.4(B)
M_A_B2: CPU1.AC31 RAM2.N2 RN1203.4(B)
M_A_B3: CPU1.Y32 RAM2.N3 RN1203.3(B)
M_A_B4: CPU1.W32 R1208.2 RAM2.M3
M_A_B5: CPU1.AC34 R1207.2 RAM2.F3
M_A_B6: CPU1.AB31 RAM2.E3 RN1205.6(B)
M_A_B7: CPU1.Y31 RAM2.E2 RN1205.5(B)
M_A_B8: CPU1.AC36 RAM2.D2 RN1205.7(B)
M_A_B9: CPU1.AC37 RAM2.C2 RN1205.8(B)
M_A_CKE0: CPU1.U36 R1220.2 RAM1.K3
M_A_CKE1: CPU1.U37 R1221.2 RAM1.K4
M_A_CKE2: CPU1.U34 R1249.2 RAM2.K3
M_A_CKE3: CPU1.U35 R1252.2 RAM2.K4
M_A_CLK0: CPU1.V31 R1246.2 RAM1.J3
M_A_CLK1: CPU1.T31 R1215.2 RAM2.J3
M_A_CLK#0: CPU1.V32 R1214.2 RAM1.J2
M_A_CLK#1: CPU1.T32 R1216.2 RAM2.J2
M_A_CS#0: CPU1.AE32 R1217.2 RAM1.L3 RAM2.L3
M_A_CS#1: CPU1.AF32 R1218.2 RAM1.L4 RAM2.L4
M_A_DQ0: CPU1.A26 RAM1.M8
M_A_DQ1: CPU1.D26 RAM1.M9
M_A_DQ2: CPU1.D28 RAM1.P9
M_A_DQ3: CPU1.C28 RAM1.M10
M_A_DQ4: CPU1.B26 RAM1.N9
M_A_DQ5: CPU1.C26 RAM1.N11
M_A_DQ6: CPU1.B28 RAM1.N10
M_A_DQ7: CPU1.A28 RAM1.M11
M_A_DQ8: CPU1.B30 RAM1.T11
M_A_DQ9: CPU1.D30 RAM1.R10
M_A_DQ10: CPU1.B33 RAM1.R8
M_A_DQ11: CPU1.D32 RAM1.T8
M_A_DQ12: CPU1.A30 RAM1.R11
M_A_DQ13: CPU1.C30 RAM1.T10
M_A_DQ14: CPU1.B32 RAM1.T9
M_A_DQ15: CPU1.C32 RAM1.R9
M_A_DQ16: CPU1.J22 RAM1.C10
M_A_DQ17: CPU1.H25 RAM1.C8
M_A_DQ18: CPU1.G22 RAM1.C11
M_A_DQ19: CPU1.H22 RAM1.B11
M_A_DQ20: CPU1.F25 RAM1.B8
M_A_DQ21: CPU1.J25 RAM1.C9
M_A_DQ22: CPU1.G25 RAM1.B9
M_A_DQ23: CPU1.F22 RAM1.B10
M_A_DQ24: CPU1.D22 RAM1.F11
M_A_DQ25: CPU1.C22 RAM1.E10
M_A_DQ26: CPU1.C24 RAM1.F8
M_A_DQ27: CPU1.D24 RAM1.D9
M_A_DQ28: CPU1.A22 RAM1.F10
M_A_DQ29: CPU1.B22 RAM1.E11
M_A_DQ30: CPU1.A24 RAM1.E9
M_A_DQ31: CPU1.B24 RAM1.F9
M_A_DQ32: CPU1.H37 RAM2.F10
M_A_DQ33: CPU1.H34 RAM2.D9
M_A_DQ34: CPU1.K34 RAM2.F11
M_A_DQ35: CPU1.K35 RAM2.F8
M_A_DQ36: CPU1.H36 RAM2.E10
M_A_DQ37: CPU1.H35 RAM2.E9
M_A_DQ38: CPU1.K36 RAM2.E11
M_A_DQ39: CPU1.K37 RAM2.F9
M_A_DQ40: CPU1.N36 RAM2.R10
M_A_DQ41: CPU1.N34 RAM2.T10
M_A_DQ42: CPU1.R37 RAM2.R8
M_A_DQ43: CPU1.R34 RAM2.R9
M_A_DQ44: CPU1.N37 RAM2.T11
M_A_DQ45: CPU1.N35 RAM2.R11
M_A_DQ46: CPU1.R36 RAM2.T9
M_A_DQ47: CPU1.R35 RAM2.T8
M_A_DQ48: CPU1.G31 RAM2.B11
M_A_DQ49: CPU1.G32 RAM2.C11
M_A_DQ50: CPU1.H29 RAM2.B8
M_A_DQ51: CPU1.H28 RAM2.C8
M_A_DQ52: CPU1.G28 RAM2.B10
M_A_DQ53: CPU1.G29 RAM2.C10
M_A_DQ54: CPU1.H31 RAM2.C9
M_A_DQ55: CPU1.H32 RAM2.B9
M_A_DQ56: CPU1.L31 RAM2.M10
M_A_DQ57: CPU1.L32 RAM2.M8
M_A_DQ58: CPU1.N29 RAM2.P9
M_A_DQ59: CPU1.N28 RAM2.N11
M_A_DQ60: CPU1.L28 RAM2.N9
M_A_DQ61: CPU1.L29 RAM2.M9
M_A_DQ62: CPU1.N31 RAM2.N10
M_A_DQ63: CPU1.N32 RAM2.M11
M_A_DQS_DN0: CPU1.C27 RAM1.L11
M_A_DQS_DN1: CPU1.D31 RAM1.P11
M_A_DQS_DN2: CPU1.H24 RAM1.D11
M_A_DQS_DN3: CPU1.C23 RAM1.G11
M_A_DQS_DN4: CPU1.J35 RAM2.G11
M_A_DQS_DN5: CPU1.P34 RAM2.P11
M_A_DQS_DN6: CPU1.G30 RAM2.D11
M_A_DQS_DN7: CPU1.L30 RAM2.L11
M_A_DQS_DP0: CPU1.D27 RAM1.L10
M_A_DQS_DP1: CPU1.C31 RAM1.P10
M_A_DQS_DP2: CPU1.G24 RAM1.D10
M_A_DQS_DP3: CPU1.D23 RAM1.G10
M_A_DQS_DP4: CPU1.J34 RAM2.G10
M_A_DQS_DP5: CPU1.P35 RAM2.P10
M_A_DQS_DP6: CPU1.H30 RAM2.D10
M_A_DQS_DP7: CPU1.N30 RAM2.L10
M_A_ODT0: CPU1.AE31 R1219.2 RAM1.J8 RAM2.J8
M_B_A0: CPU1.AF35 RAM3.R2 RN1301.5(B)
M_B_A1: CPU1.AB29 RAM3.P2 RN1301.6(B)
M_B_A2: CPU1.AE37 RAM3.N2 RN1301.8(B)
M_B_A3: CPU1.AE36 RAM3.N3 RN1301.7(B)
M_B_A4: CPU1.AC29 R1306.2 RAM3.M3
M_B_A5: CPU1.W29 R1305.2 RAM3.F3
M_B_A6: CPU1.AB28 RAM3.E3 RN1302.4(B)
M_B_A7: CPU1.AC28 RAM3.E2 RN1302.3(B)
M_B_A8: CPU1.W28 RAM3.D2 RN1306.3(B)
M_B_A9: CPU1.Y28 RAM3.C2 RN1306.4(B)
M_B_B0: CPU1.AK35 RAM4.R2 RN1307.3(B)
M_B_B1: CPU1.AK34 RAM4.P2 RN1307.4(B)
M_B_B2: CPU1.AJ35 R1308.2 RAM4.N2
M_B_B3: CPU1.AJ34 RAM4.N3 RN1303.3(B)
M_B_B4: CPU1.AJ37 RAM4.M3 RN1303.4(B)
M_B_B5: CPU1.AF34 R1307.2 RAM4.F3
M_B_B6: CPU1.AJ36 RAM4.E3 RN1308.4(B)
M_B_B7: CPU1.AG34 RAM4.E2 RN1308.3(B)
M_B_B8: CPU1.AG35 RAM4.D2 RN1304.3(B)
M_B_B9: CPU1.AG36 RAM4.C2 RN1304.4(B)
M_B_CKE0: CPU1.T28 R1316.2 RAM3.K3
M_B_CKE1: CPU1.T29 R1317.2 RAM3.K4
M_B_CKE2: CPU1.V28 R1318.2 RAM4.K3
M_B_CKE3: CPU1.V29 R1319.2 RAM4.K4
M_B_CLK0: CPU1.AF29 R1341.2 RAM3.J3
M_B_CLK1: CPU1.AE29 R1311.2 RAM4.J3
M_B_CLK#0: CPU1.AF28 R1310.2 RAM3.J2
M_B_CLK#1: CPU1.AE28 R1312.2 RAM4.J2
M_B_CS#0: CPU1.AL37 R1313.2 RAM3.L3 RAM4.L3
M_B_CS#1: CPU1.AL35 R1314.2 RAM3.L4 RAM4.L4
M_B_DQ0: CPU1.AN35 RAM3.D9
M_B_DQ1: CPU1.AN34 RAM3.E10
M_B_DQ2: CPU1.AR35 RAM3.E11
M_B_DQ3: CPU1.AR34 RAM3.F9
M_B_DQ4: CPU1.AN37 RAM3.E9
M_B_DQ5: CPU1.AN36 RAM3.F8
M_B_DQ6: CPU1.AR36 RAM3.F10
M_B_DQ7: CPU1.AR37 RAM3.F11
M_B_DQ8: CPU1.AU35 RAM3.R11
M_B_DQ9: CPU1.AU34 RAM3.T11
M_B_DQ10: CPU1.AW35 RAM3.R8
M_B_DQ11: CPU1.AW34 RAM3.R10
M_B_DQ12: CPU1.AU37 RAM3.R9
M_B_DQ13: CPU1.AU36 RAM3.T9
M_B_DQ14: CPU1.AW36 RAM3.T10
M_B_DQ15: CPU1.AW37 RAM3.T8
M_B_DQ16: CPU1.AJ29 RAM3.C8
M_B_DQ17: CPU1.AJ30 RAM3.B8
M_B_DQ18: CPU1.AM32 RAM3.C11
M_B_DQ19: CPU1.AM31 RAM3.C10
M_B_DQ20: CPU1.AM30 RAM3.B11
M_B_DQ21: CPU1.AM29 RAM3.C9
M_B_DQ22: CPU1.AJ31 RAM3.B10
M_B_DQ23: CPU1.AJ32 RAM3.B9
M_B_DQ24: CPU1.AR31 RAM3.N10
M_B_DQ25: CPU1.AR32 RAM3.M10
M_B_DQ26: CPU1.AV30 RAM3.N9
M_B_DQ27: CPU1.AV29 RAM3.P9
M_B_DQ28: CPU1.AR30 RAM3.M9
M_B_DQ29: CPU1.AR29 RAM3.M8
M_B_DQ30: CPU1.AV32 RAM3.N11
M_B_DQ31: CPU1.AV31 RAM3.M11
M_B_DQ32: CPU1.BA35 RAM4.E9
M_B_DQ33: CPU1.BA34 RAM4.D9
M_B_DQ34: CPU1.BC35 RAM4.F9
M_B_DQ35: CPU1.BC34 RAM4.E11
M_B_DQ36: CPU1.BA37 RAM4.E10
M_B_DQ37: CPU1.BA36 RAM4.F8
M_B_DQ38: CPU1.BC36 RAM4.F10
M_B_DQ39: CPU1.BC37 RAM4.F11
M_B_DQ40: CPU1.BE35 RAM4.R8
M_B_DQ41: CPU1.BE34 RAM4.T9
M_B_DQ42: CPU1.BG35 RAM4.T11
M_B_DQ43: CPU1.BG34 RAM4.R10
M_B_DQ44: CPU1.BE37 RAM4.T8
M_B_DQ45: CPU1.BE36 RAM4.R9
M_B_DQ46: CPU1.BG36 RAM4.T10
M_B_DQ47: CPU1.BG37 RAM4.R11
M_B_DQ48: CPU1.BA32 RAM4.B11
M_B_DQ49: CPU1.BA31 RAM4.C11
M_B_DQ50: CPU1.BD31 RAM4.B8
M_B_DQ51: CPU1.BD32 RAM4.C9
M_B_DQ52: CPU1.BA30 RAM4.C10
M_B_DQ53: CPU1.BA29 RAM4.B10
M_B_DQ54: CPU1.BD29 RAM4.B9
M_B_DQ55: CPU1.BD30 RAM4.C8
M_B_DQ56: CPU1.BG31 RAM4.M10
M_B_DQ57: CPU1.BG32 RAM4.M9
M_B_DQ58: CPU1.BK32 RAM4.N11
M_B_DQ59: CPU1.BK31 RAM4.M11
M_B_DQ60: CPU1.BG29 RAM4.M8
M_B_DQ61: CPU1.BG30 RAM4.N9
M_B_DQ62: CPU1.BK30 RAM4.N10
M_B_DQ63: CPU1.BK29 RAM4.P9
M_B_DQS_DN0: CPU1.AP35 RAM3.G11
M_B_DQS_DN1: CPU1.AV34 RAM3.P11
M_B_DQS_DN2: CPU1.AL31 RAM3.D11
M_B_DQS_DN3: CPU1.AU31 RAM3.L11
M_B_DQS_DN4: CPU1.BB35 RAM4.G11
M_B_DQS_DN5: CPU1.BF34 RAM4.P11
M_B_DQS_DN6: CPU1.BC31 RAM4.D11
M_B_DQS_DN7: CPU1.BH31 RAM4.L11
M_B_DQS_DP0: CPU1.AP34 RAM3.G10
M_B_DQS_DP1: CPU1.AV35 RAM3.P10
M_B_DQS_DP2: CPU1.AL30 RAM3.D10
M_B_DQS_DP3: CPU1.AU30 RAM3.L10
M_B_DQS_DP4: CPU1.BB34 RAM4.G10
M_B_DQS_DP5: CPU1.BF35 RAM4.P10
M_B_DQS_DP6: CPU1.BC30 RAM4.D10
M_B_DQS_DP7: CPU1.BH30 RAM4.L10
M_B_ODT0: CPU1.AL36 R1315.2 RAM3.J8 RAM4.J8
M_VREF_CA_DIMMA: C1215.1 C1230.1 R1222.2 R1223.1 R1224.1 RAM1.J11 RAM2.J11
M_VREF_CA_DIMMB: C1315.1 C1330.1 R1320.2 R1321.1 R1323.1 RAM3.J11 RAM4.J11
MASK_BASE_LEDS#: Q6404.2 Q6404.5 R6419.2 U6402.4
MASK_SATA_LED#: Q6403.G R6406.2 U2401.56
MCARD_PCIE#_SATA: R1605.2 RN2405.8(B) U2401.41
ME_FWP: FSW1.3 R9806.1 U2401.80
ME_FWP_SW: FSW1.2 R1909.1 R9806.2
ME_SUS_PWR_ACK_R: CPU1.BV34 R1708.2 R1738.2
MEC_XTAL1_R: C2425.1 U2401.123 X2401.1
MEC_XTAL2: C2424.1 R2461.1 U2401.125 X2401.2
MEM_CHA_EN: CPU1.CJ31 R2030.1 R2031.2
MEM_CHB_EN: CPU1.CJ27 R2032.1 R2033.2
MEM_CONFIG0: CPU1.CF27 R2015.1 R2016.2
MEM_CONFIG1: CPU1.CF29 R2017.1 R2018.2
MEM_CONFIG2: CPU1.CH27 R2022.1 R2029.2
MEM_CONFIG3: CPU1.CH28 R2011.2 R2012.1
MEM_CONFIG4: CPU1.CJ30 R2013.2 R2014.1
MESW1_B: FSW1.1 R9804.1 R9805.2
MIC2_VREFO_R: RN2901.1(A) RN2901.2(A) U2701.23
MIC_CAP: C2715.1 U2701.15
MIC_GND: LCD1.38 R5512.1
MODEL_ID: C2407.1 R2441.1 R2442.2 U2401.109
MSATA_DEVSLP_R: AFTP6301.1 R6301.2 SSD1.38
MUX_HPD_CON: R7149.1 U7101.23
N12P_JTAG_TCK: GPU1.AE5 TP7906.1
N12P_JTAG_TDI: GPU1.AE6 TP7905.1
N12P_JTAG_TDO: GPU1.AF6 TP7901.1
N12P_JTAG_TMS: GPU1.AD6 TP7902.1
N12P_JTAG_TRST: GPU1.AG4 R7912.1
N12P_XTAL_OUTBUFF: GPU1.C10 R7902.1 R7917.2
N17S_F22: GPU1.F22 R7809.1
N17S_J22: GPU1.J22 R7808.1
NB_MODE#: R2002.2 U2401.34
NB_MUTE#: R2712.1 R2717.2 U2401.119
NCT7718_DXN: C2606.2 C2607.2 Q2603.E U2601.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C U2601.2
NRB_BIT: CPU1.CE29 R1502.2 R1503.1
OVERT_GPU#: GPU1.A6 RN7910.3(B)
OVP_UVP_REF_VDD: PR44A2.1 PR44B7.1 PR44C5.2 PR44C6.2
P2800_VGA_DXN: GPU1.E12 TP7903.1
P2800_VGA_DXP: GPU1.F12 TP7904.1
PANEL_BKEN: D2401.3 RN5501.3(B)
PANEL_BKEN_EC: D2401.1 U2401.117
PANEL_MONITOR: R5536.2 U2401.20
PANEL_PWRGD: C5558.1 Q5508.C Q5510.C R5535.2 R5536.1 R5558.1
PBAT_CHG_SMBCLK: EC4309.1 ED4306.3 PR4489.1 RN2402.3(B) RN4302.1(A) U2401.9
PBAT_CHG_SMBDAT: EC4310.1 ED4305.3 PR4488.1 RN2402.4(B) RN4302.2(A) U2401.8
PBAT_PRES1#: AFTP4309.1 BATT1.7 R4327.2
PBAT_PRES#: EC4306.1 ED4304.3 PR4498.1 R2415.2 R4327.1 U2401.29
PCH_BATLOW#: CPU1.BV36 R1722.2 R1723.1
PCH_DPWROK: CPU1.BP30 R1704.2
PCH_PLTRST#: CPU1.BJ35 R1713.2
PCH_POPIRCOMP: CPU1.BW25 R305.2
PCH_RSMRST#: R1702.2 R6425.1 TP2402.1 U2401.27
PCH_SATA_LED#: CPU1.CN7 D6401.1 R1606.2
PCH_TCK: CPU1.W6 TP314.1
PCIE_RCOMPN: CPU1.CE6 R1604.1
PCIE_RCOMPP: CPU1.CE5 R1604.2
PCIE_WAKE#_CPU: CPU1.BU30 RN1704.3(B)
PD4403_A: PD4403.A PQ4408.B
PD4403_K: PD4403.K PR4485.2
PD_IRQ1: R7224.2 U7201.C1
PD_OVP_TRIP_P1: R7243.2 R7250.2 U7201.E10
PD_VBUS_C_CTRL1: Q7405.2 Q7406.5 U7201.G10
PD_VBUS_C_CTRL1_A: Q7404.3 Q7405.1
PD_VBUS_C_CTRL1_R: Q7405.5 Q7405.6 R7410.1 R7426.2
PD_VBUS_C_EN: Q7407.3 R7422.1 R7427.2 U7419.A3
PD_VBUS_C_EN_A: Q7405.3 Q7407.5 Q7407.6 R7408.1 R7425.2
PDB_R: R2712.2 U2701.40
PECI_CPU: CPU1.AR1 R2437.2
PEX_TERMP: GPU1.AF25 R7601.1
PIRQA#: CPU1.CC32 R2053.2 R9123.2
PLTRST#_CPU: AFTP6108.1 C1701.1 ED1702.1 IO2.20 R1713.1 R1715.1 R6103.2 R6604.1 SSD1.50 U7601.2 U9101.17 WLAN1.52
PM_PCH_PWROK: CPU1.BP31 R1706.2 RN1703.3(B)
PM_RSMRST#: CPU1.BR36 ED1706.1 Q1701.6 Q1702.5 R1702.1 R1704.1 RN1703.4(B)
PM_RSMRST#_M: Q1702.2 Q1702.3 R1737.2
PM_SLP_A#: CPU1.BU37 TP1706.1
PM_SLP_S0#: CPU1.BJ37 R4040.1 R9121.2
PM_SLP_S3#: CPU1.BU36 Q4001.G R4010.1 U4008.1
PM_SLP_S4#: CPU1.BU27 PR5153.1 Q9202.G R4024.1
PM_SLP_S5#: CPU1.BT29 TP1710.1
POWER_SW_IN#: C2427.1 R2432.2 R2451.2 U2401.127
PQ44B0_2: PC44B2.1 PD44B1.K PQ44B1.2 PR44B6.2
PQ44B0_6: PQ44B1.5 PQ44B1.6 PR44B5.1
PQ3802_1: Q4302.B R4302.2 R4309.1
PQ4405_2: PQ4405.2 PR4463.2 PR4487.2
PQ4405_3: PQ4405.3 PR4497.2
PQ4405_5: PC4468.2 PQ4405.5 PR4438.1
PQ4405_6: PC4468.1 PQ4405.6 PR4443.2
PQ4408_C: PQ4408.C PR4439.1 PR4487.1
PQ4408_E: PQ4408.E PR4436.1 PR4437.2
PQ4417_D: PQ4417.D PR4462.2 PR4486.1
PQ4417_G: PQ4417.G PR4494.2
PQ4418_2: PQ4418.2 PR4459.2 PR4486.2
PQ4418_3: PQ4418.3 PR4496.2
PQ4418_5: PC4467.2 PQ4418.5 PR4461.1
PQ4418_6: PC4467.1 PQ4418.6 PR4460.2
PQ4451_D: PQ4451.D PR4465.2 PR4469.1
PQ4451_G: PQ4451.G PR4464.1 PR4466.2 PR4469.2
PQ4452_G: PQ4452.2 PR4470.1 PR4471.2
PRD_CC1: R7211.1 U7201.K9
PRD_CC2: R7212.1 U7201.K10
PRIM_PWRGD: PR5311.1 U2401.30
PROCHOT: Q2408.G U2401.83
PROCHOT#_CPU: PQ4416.6 PR4496.1 PR4497.1 PR4603.2 PR4607.1 Q2408.D R301.2 R302.1
PROCHOT#_CPU_R: CPU1.Y4 R302.2
PROJECT_ID0: CPU1.CH23 R2113.2 R2114.1
PROJECT_ID1: CPU1.CK19 R2111.2 R2112.1
PROJECT_ID2: CPU1.CG17 R2115.2 R2116.1
PROJECT_ID3: CPU1.CN20 R2117.2 R2118.1
PS_ID: D4302.3 R4304.2 R4305.2 U2401.36
PS_ID_R: AFTP4304.1 DCIN1.4 EC4303.1 R4317.1
PS_ID_R1: Q4301.S R4305.1 R4306.2
PS_ID_R2: D4303.1 D4303.2 Q4301.D R4306.1 R4309.2 R4317.2
PSID_DISABLE#_R_C: Q4301.G Q4302.C R4303.2
PTP_DIS#: AFTP6537.1 TPAD1.3 U2401.90
PU44C1_ADJ: PR44C2.2 PR44C3.1 PU44C1.4
PU44C1_EN: PR44C1.1 PR44C4.1 PR44C7.2
PU44C1_EN_R: PC44C1.1 PR44C4.2 PU44C1.3
PURE_HW_SHUTDOWN#: C2610.1 D4001.K Q2602.D
PWR_1D0V_PG: PR5208.2 PU5201.1
PWR_1D05V_BT: PC5204.2 PU5201.20
PWR_1D05V_EN: PC5214.1 PR5210.2 PU5201.2
PWR_1D05V_PFM: PR5203.1 PU5201.3
PWR_1D05V_PH: PC5204.1 PL5201.1 PU5201.10 PU5201.11 PU5201.16 PU5201.17 PU5201.18
PWR_1D05V_SS: PC5213.1 PU5201.22
PWR_1D05V_TON: PR5201.2 PU5201.6
PWR_1D05V_VFB: PC5212.2 PR5202.2 PR5204.1 PU5201.5
PWR_1D05V_VFB_A: PC5212.1 PG5210.2 PR5202.1
PWR_1D8V: PC5302.1 PC5303.1 PC5305.1 PL5301.2 PR5305.1 PR5307.1
PWR_1D8V_EN: PC5307.1 PR5310.2 PU5301.7
PWR_1D8V_FB: PC5305.2 PR5304.1 PR5305.2 PU5301.1
PWR_1D8V_PG: PR5306.2 PR5311.2 PU5301.2
PWR_1D8V_PH: PL5301.1 PU5301.6
PWR_1D8V_PHASE: PL8601.1 PU8601.6
PWR_1D8V_PVDD: PC8601.1 PC8622.1 PC8623.1 PG8601.2 PG8602.2 PU8601.3
PWR_1D8V_VGA: PC8624.1 PC8625.1 PC8626.1 PG8603.2 PG8604.2 PL8601.2 PR8612.1
PWR_1D8V_VGA_FB: PC8624.2 PR8612.2 PR8614.1 PU8601.1
PWR_1D8V_VIN: PC5301.1 PG5302.1 PG5303.1 PU5301.3
PWR_1D35V_BOOT: PR8633.1 PU8602.1
PWR_1D35V_BOOT_R: PC8619.1 PR8633.2
PWR_1D35V_BYP: PC8618.1 PR8634.2 PU8602.15
PWR_1D35V_EN: PC8616.1 PR8631.2 PU8602.11
PWR_1D35V_IMAX: PR8632.1 PU8602.13
PWR_1D35V_LDO_P5: PC8617.1 PU8602.16 PU8602.17
PWR_1D35V_PGOOD: PR8611.2 PR8630.2 PU8602.9 PU8602.10
PWR_1D35V_PHASE: PC8619.2 PL8603.1 PU8602.6 PU8602.19 PU8602.20
PWR_1D35V_VFB: PC8602.2 PR8626.1 PR8627.2 PU8602.14
PWR_1D35V_VFB1: PC8602.1 PG8613.2 PR8627.1
PWR_1V: PC8628.1 PC8631.1 PC8632.1 PG8607.1 PG8608.1 PL8602.2 PR8613.1
PWR_1V_FB: PC8632.2 PR8613.2 PR8620.1 PU8603.1
PWR_1V_PHASE: PL8602.1 PU8603.6
PWR_1V_PVDD: PC8627.1 PC8629.1 PC8630.1 PG8605.2 PG8606.2 PU8603.3
PWR_3D3V_BOOT: PR4501.2 PU4501.1
PWR_3D3V_BOOT_A: PC4506.2 PR4501.1
PWR_3D3V_EN: PR4514.1 PU4501.12 R4502.1
PWR_3D3V_EN2: PC4508.2 PR4508.1 PR4509.2 PU4501.11
PWR_3D3V_FB: PC4526.1 PU4501.13
PWR_3D3V_FB2: PC4526.2 PR4506.2
PWR_3D3V_LDO: PC4507.1 PG4532.2 PU4501.16 PU4501.17
PWR_3D3V_PH: PC4506.1 PL4501.1 PU4501.6 PU4501.19 PU4501.20
PWR_3D3V_VOUT: PG4530.1 PR4506.1 PU4501.14
PWR_5V_BOOT: PR4554.1 PU4551.1
PWR_5V_BOOT_A: PC4553.1 PR4554.2
PWR_5V_EN2: PC4564.2 PR4557.2 PR4558.1 PU4551.11
PWR_5V_FB: PC4563.1 PR4502.1 PU4551.13
PWR_5V_FB_A: PC4563.2 PR4555.2
PWR_5V_LDO: PC4551.1 PG4565.1 PU4551.15
PWR_5V_PG: PR4552.2 PU4551.9 PU4551.10 R4503.1
PWR_5V_PH: PC4553.2 PL4551.1 PU4551.6 PU4551.19 PU4551.20
PWR_5V_VCC: PC4562.1 PU4551.16 PU4551.17
PWR_5V_VOUT: PG4562.1 PR4555.1 PU4551.14
PWR_AC_IN#: PQ4415.3 PR4491.2
PWR_AD_A: C7401.1 PC44C3.1 PC4469.1 PG4401.1 PQ4451.S PR44C7.1 PR4401.1 PR4466.1 PR4468.1 PU44A1.5 PU44B1.5 PU44C1.1 PU4401.16 PU4415.1 PU4415.2 PU4415.3 Q7401.S R7404.1 R7406.1 R7407.1 U7418.1 U7418.2 U7418.3
PWR_AD_A_SW: PC4469.2 PR4465.1 PR4467.1 PR4468.2 PU4415.4
PWR_AD_A_SW_R1: PQ4452.6 PR4467.2
PWR_AD_B: C8901.1 C8902.1 C8903.1 EC4401.1 EC4402.1 EC4403.1 EC4404.1 EC4405.1 EC4406.1 EC4407.1 EC4408.1 PC4402.1 PC4404.1 PC4405.1 PC4406.1 PG4402.1 PR4401.2 PU4402.2 PU4402.3 PU4402.4 PU4402.10
PWR_CHG_ACIN: PC4420.1 PR44A5.2 PR4404.2 PR4406.1 PU4401.19
PWR_CHG_ACIN_A: PQ44A1.3 PQ44A1.6 PR44A5.1
PWR_CHG_ACOK: PG4408.2 PR4426.1 PR4429.2 PR4459.1 PR4463.1 PU4401.24
PWR_CHG_AIN: PD4408.3 PR4404.1
PWR_CHG_AMON: PR4492.1 PU4401.29
PWR_CHG_ASGATE: PU4401.13 TP4401.1
PWR_CHG_BAT_IN#: PR4409.1 PR4498.2
PWR_CHG_BATGONE: PC4430.1 PR4409.2 PU4401.25
PWR_CHG_BGATE: PC4429.1 PU4401.32 PU4412.4
PWR_CHG_BTST1: PR4402.1 PU4401.12
PWR_CHG_BTST1_A: PC4436.1 PR4402.2
PWR_CHG_BTST2: PR4408.1 PU4401.4
PWR_CHG_BTST2_A: PC4423.1 PR4408.2
PWR_CHG_CLK: PR4489.2 PU4401.22
PWR_CHG_COMP: PC4433.1 PR4411.1 PU4401.28
PWR_CHG_COMP_R: PC4431.1 PR4411.2
PWR_CHG_CSIN: PC4415.2 PC4417.1 PR4482.2 PU4401.14
PWR_CHG_CSIN_R: PG4402.2 PR4482.1
PWR_CHG_CSIP: PC4415.1 PC4416.1 PR4422.2 PU4401.15
PWR_CHG_CSIP_R: PG4401.2 PR4422.1
PWR_CHG_CSON: PC4425.2 PC4451.2 PR4425.1 PU4401.1
PWR_CHG_CSON_R: PG4406.1 PR4425.2
PWR_CHG_CSOP: PC4424.2 PC4425.1 PR4424.1 PU4401.2
PWR_CHG_CSOP_R: PG4405.1 PR4424.2
PWR_CHG_DATA: PR4488.2 PU4401.21
PWR_CHG_DCIN: PC4419.1 PR4403.2 PU4401.17
PWR_CHG_DCIN_R: PD4401.3 PD4407.K PR4403.1
PWR_CHG_LGATE1: PU4401.9 PU4402.8
PWR_CHG_LGATE2: PU4401.7 PU4403.8
PWR_CHG_OTGEN: PR4417.1 PU4401.20
PWR_CHG_OTGPG: PU4401.26 TP4402.1
PWR_CHG_PHASE1: PC4436.2 PL4401.1 PR4416.1 PU4401.10 PU4402.9
PWR_CHG_PHASE2: PC4423.2 PL4401.2 PU4401.6 PU4403.9
PWR_CHG_PROCHOT#: PQ4416.5 PR4435.2 PU4401.23
PWR_CHG_PROCHOT#_R: PQ4402.G PQ4416.2 PQ4416.3 PR4472.2
PWR_CHG_PROG: PR4410.1 PU4401.27
PWR_CHG_SNB: PC4435.1 PR4416.2
PWR_CHG_UGATE1: PU4401.11 PU4402.1
PWR_CHG_UGATE2: PU4401.5 PU4403.1
PWR_CHG_VBAT1: PC4440.1 PR4483.1 PU4401.31
PWR_CHG_VBATIN: PC4449.1 PC4450.1 PG4406.2 PR4407.2 PU4412.1 PU4412.2 PU4412.3 R6625.2
PWR_CHG_VDDP: PC4452.1 PR4405.1 PU4401.8
PWR_CORE_PSYS: PR4413.1 PR4614.1 PU4401.30 PU4601.1
PWR_CORE_VCCST: PC4602.1 PG4601.2 PR4603.1 PR4604.1 PR4605.1 PR4606.1
PWR_DCBATOUT_1D05V: PC5208.1 PC5209.1 PC5210.1 PG5201.2 PG5202.2 PG5203.2 PR5201.1 PU5201.7 PU5201.8 PU5201.9
PWR_DCBATOUT_1D35V: PC8609.1 PC8610.1 PC8615.1 PG8614.2 PG8615.2 PG8616.2 PG8617.2 PU8602.2 PU8602.3 PU8602.4 PU8602.5
PWR_DCBATOUT_VCCGT: PC4801.1 PC4802.1 PC4803.1 PC4804.1 PL4802.2 PL4803.2 PU4801.8 PU4801.9 PU4801.10 PU4801.11 PU4801.33 R6611.1 TC4805.1
PWR_DCBATOUT_VCCGT_R: CN1.3 R6611.2
PWR_DCBATOUT_VCCSA: AFTP5001.1 FC8922.1 FC8959.1 PC5002.1 PC5003.1 PC5004.1 PU5001.5 PU5001.6 PU5001.7 PU5001.8 R5001.2 R6616.1
PWR_DCBATOUT_VCCSA_R: CN1.17 R6616.2
PWR_DCBATOUT_VCOREA: PC4702.1 PC4703.1 PC4704.1 PC4705.1 PC4714.1 PC4715.1 PC4716.1 PC4717.1 PL4703.2 PL4704.2 PU4701.8 PU4701.9 PU4701.10 PU4701.11 PU4701.33 PU4702.8 PU4702.9 PU4702.10 PU4702.11 PU4702.33 R6622.2 TC4702.1
PWR_DCBATOUT_VCOREA_R: CN1.14 R6622.1
PWR_DCBATOUT_VDDQ: PC5101.1 PC5105.1 PC5108.1 PD5101.K PR5108.1 PU5101.21 PU5101.22 PU5101.23 PU5101.24 PU5101.34 R5101.2 R6614.1
PWR_DCBATOUT_VDDQ_R: CN1.13 R6614.2
PWR_IMVP_PWRGD: PR4609.2 PU4601.39 TP4601.1
PWR_LEVEL: D7902.A GPU1.D7 R7905.2
PWR_VCCGT_BOOT: PR4805.2 PU4801.5
PWR_VCCGT_BOOT_RC: PC4807.1 PR4805.1
PWR_VCCGT_BOOTR: PC4807.2 PU4801.7
PWR_VCCGT_COMP: PC4639.1 PR4656.1 PU4601.16
PWR_VCCGT_COMP1: PC4640.1 PR4656.2
PWR_VCCGT_FB: PR4657.1 PR4658.1 PR4660.1 PU4601.17
PWR_VCCGT_FB1: PC4641.1 PR4657.2
PWR_VCCGT_FB2: PC4642.2 PC4643.2 PC4644.1 PR4660.2 PR4686.2 PR4695.2
PWR_VCCGT_FB_RC: PC4643.1 PR4658.2
PWR_VCCGT_FCCM#: PR4806.2 PU4601.21
PWR_VCCGT_FCCM#_R: PR4806.1 PU4801.2
PWR_VCCGT_IMON: PC4638.1 PR4661.1 PU4601.14
PWR_VCCGT_ISUMN: PC4631.1 PC4634.1 PR4648.2 PR4649.2 PR4650.1 PR4651.2 PR4652.2 PR4801.2
PWR_VCCGT_ISUMN_G: PG4808.1 PR4801.1
PWR_VCCGT_ISUMN_P_1: PC4635.1 PC4652.1 PR4649.1
PWR_VCCGT_ISUMN_P_2: PR4650.2 PR4653.2
PWR_VCCGT_ISUMN_RC: PC4632.1 PR4651.1
PWR_VCCGT_ISUMNA: PC4632.2 PR4648.1 PU4601.20
PWR_VCCGT_ISUMP: PC4634.2 PC4635.2 PC4652.2 PR4652.1 PR4653.1 PR4808.2 PU4601.19
PWR_VCCGT_ISUMP_G: PG4807.1 PR4808.1
PWR_VCCGT_NTC: PR4662.1 PU4601.15
PWR_VCCGT_NTC1: PR4654.1 PR4655.2 PR4662.2
PWR_VCCGT_PWM: PR4802.2 PU4601.22
PWR_VCCGT_PWM_R: PR4802.1 PR4812.1 PU4801.1
PWR_VCCGT_RTN: PC4637.1 PC4642.1 PR4659.2 PR4694.2 PU4601.18
PWR_VCCGT_SNB: PC4806.1 PR4803.2
PWR_VCCGT_SW: PG4807.2 PL4801.1 PR4803.1 PU4801.16 PU4801.17 PU4801.18 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.25 PU4801.26
PWR_VCCGT_VCC_R: PC4808.1 PR4804.1 PU4801.3
PWR_VCCSA_BST: PR5001.2 PU5002.2
PWR_VCCSA_BST_RC: PC5005.1 PR5001.1
PWR_VCCSA_COMP: PC4624.1 PR4640.1 PU4601.24
PWR_VCCSA_COMP_RC: PC4601.1 PR4640.2
PWR_VCCSA_DRVH: PU5001.4 PU5002.1
PWR_VCCSA_DRVL: PU5002.5 PU5003.4
PWR_VCCSA_FB: PR4632.2 PR4637.1 PR4638.2 PU4601.25
PWR_VCCSA_FB1: PC4621.2 PR4638.1
PWR_VCCSA_FB2: PC4616.2 PC4617.2 PC4620.1 PR4637.2 PR4693.1
PWR_VCCSA_FB_RC: PC4617.1 PR4632.1
PWR_VCCSA_FCCM: PU4601.29 PU5002.7
PWR_VCCSA_IMON: PC4629.2 PR4644.1 PU4601.23
PWR_VCCSA_ISUMN: PC4603.2 PC4605.1 PR4611.1 PR4613.1 PR4615.1 PR4618.2 PR4620.1 PR5004.1
PWR_VCCSA_ISUMN_P_1: PC4608.2 PR4613.2
PWR_VCCSA_ISUMN_P_2: PR4611.2 PR4625.2
PWR_VCCSA_ISUMN_R: PG5001.2 PR5004.2
PWR_VCCSA_ISUMN_RC: PC4611.1 PR4615.2
PWR_VCCSA_ISUMNB: PC4611.2 PR4620.2 PU4601.28
PWR_VCCSA_ISUMP: PC4605.2 PC4608.1 PR4618.1 PR4625.1 PR5003.1 PU4601.27
PWR_VCCSA_ISUMP_R: PG5011.2 PR5003.2
PWR_VCCSA_PWM: PU4601.30 PU5002.3
PWR_VCCSA_RTN: PC4613.1 PC4616.1 PR4627.2 PR4692.1 PU4601.26
PWR_VCCSA_SW: PC5005.2 PG5011.1 PL5001.1 PU5001.1 PU5001.2 PU5001.3 PU5002.8 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCORE_ALERT#: PR4623.2 PU4601.36
PWR_VCORE_BOOTA: PR4704.2 PU4701.5
PWR_VCORE_BOOTA_RC: PC4708.1 PR4704.1
PWR_VCORE_BOOTB: PR4710.2 PU4702.5
PWR_VCORE_BOOTB_RC: PC4711.1 PR4710.1
PWR_VCORE_BOOTRA: PC4708.2 PU4701.7
PWR_VCORE_BOOTRB: PC4711.2 PU4702.7
PWR_VCORE_COMP: PC4610.2 PR4626.2 PU4601.4
PWR_VCORE_COMP1: PC4612.1 PC4651.1 PR4626.1
PWR_VCORE_FB: PR4630.2 PR4633.2 PR4636.2 PU4601.5
PWR_VCORE_FB1: PC4614.1 PR4630.1
PWR_VCORE_FB2: PC4615.2 PC4618.2 PC4619.1 PR4631.1 PR4633.1 PR4665.2
PWR_VCORE_FB_RC: PC4618.1 PR4636.1
PWR_VCORE_FCCM#: PR4706.1 PR4712.1 PU4601.11
PWR_VCORE_FCCM#_RA: PR4706.2 PU4701.2
PWR_VCORE_FCCM#_RB: PR4712.2 PU4702.2
PWR_VCORE_IMON: PC4604.2 PR4608.2 PU4601.2
PWR_VCORE_ISEN1: PC4625.1 PR4669.2 PR4721.1 PR4724.1 PU4601.9
PWR_VCORE_ISEN2: PC4626.1 PR4635.1 PR4669.1 PR4722.1 PR4723.1 PU4601.10
PWR_VCORE_ISUMN: PC4625.2 PC4626.2 PC4630.2 PC4633.1 PR4642.2 PR4643.2 PR4645.2 PR4646.2 PR4647.1 PR4709.1 PR4715.1
PWR_VCORE_ISUMN_GA: PG4709.2 PR4709.2 PR4722.2
PWR_VCORE_ISUMN_GB: PG4715.2 PR4715.2 PR4724.2
PWR_VCORE_ISUMN_P_1: PC4628.2 PC4653.2 PC4654.2 PR4647.2
PWR_VCORE_ISUMN_P_2: PR4641.2 PR4646.1
PWR_VCORE_ISUMN_RC: PC4623.1 PR4645.1
PWR_VCORE_ISUMNB: PC4623.2 PR4642.1 PU4601.8
PWR_VCORE_ISUMP: PC4628.1 PC4630.1 PC4653.1 PC4654.1 PR4641.1 PR4643.1 PR4708.1 PR4716.1 PU4601.7
PWR_VCORE_ISUMP_GA: PG4708.2 PR4708.2 PR4721.2
PWR_VCORE_ISUMP_GB: PG4713.2 PR4716.2 PR4723.2
PWR_VCORE_NTC: PR4616.2 PU4601.3
PWR_VCORE_NTC1: PR4616.1 PR4617.1 PR4621.2
PWR_VCORE_PROG1: PR4629.1 PU4601.32
PWR_VCORE_PROG2: PR4628.1 PU4601.31
PWR_VCORE_PWMA: PR4702.1 PU4601.12
PWR_VCORE_PWMA_RA: PR4702.2 PR4717.1 PU4701.1
PWR_VCORE_PWMB: PR4711.1 PU4601.13
PWR_VCORE_PWMB_RA: PR4711.2 PR4718.1 PU4702.1
PWR_VCORE_RTN: PC4619.2 PC4622.1 PR4666.2 PR4685.1 PU4601.6
PWR_VCORE_SCLK: PR4624.2 PU4601.37
PWR_VCORE_SDIO: PR4622.2 PU4601.35
PWR_VCORE_SNB1: PC4710.1 PR4705.2
PWR_VCORE_SNB2: PC4713.1 PR4714.2
PWR_VCORE_SWA: PG4708.1 PL4701.1 PR4705.1 PU4701.16 PU4701.17 PU4701.18 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.25 PU4701.26
PWR_VCORE_SWB: PG4713.1 PL4702.1 PR4714.1 PU4702.16 PU4702.17 PU4702.18 PU4702.19 PU4702.20 PU4702.21 PU4702.22 PU4702.23 PU4702.24 PU4702.25 PU4702.26
PWR_VCORE_VCC: PC4607.1 PR4610.2 PU4601.34
PWR_VCORE_VCCDA: PC4709.1 PR4703.2 PU4701.3
PWR_VCORE_VCCDB: PC4712.1 PR4713.2 PU4702.3
PWR_VCORE_VIN: PC4606.1 PR4612.2 PU4601.33
PWR_VCORE_VRHOT#: PR4607.2 PU4601.38
PWR_VDDQ: PC5106.1 PC5107.1 PC5109.1 PC5113.1 PG5104.2 PG5105.1 PG5106.1 PG5107.1 PG5108.1 PG5109.1 PG5110.1 PG5112.1 PG5114.1 PL5101.2
PWR_VDDQ_BOOT: PR5111.1 PU5101.27
PWR_VDDQ_BOOTA: PC5110.2 PR5111.2
PWR_VDDQ_BOOTB: PC5110.1 PU5101.25
PWR_VDDQ_CS: PR5102.2 PU5101.10
PWR_VDDQ_EN: PR5152.2 PR5156.1 PU5101.6 PU5151.7
PWR_VDDQ_FB: PR5105.2 PR5106.1 PU5101.3
PWR_VDDQ_PG: PR5104.2 PU5101.8 R4011.1
PWR_VDDQ_PH: PL5101.1 PR5110.1 PU5101.17 PU5101.18 PU5101.19 PU5101.20 PU5101.35
PWR_VDDQ_SNB: PC5115.1 PR5110.2
PWR_VDDQ_TON: PR5108.2 PU5101.7
PWR_VDDQ_VCC: PC5104.1 PR5101.2 PR5102.1 PU5101.9
PWR_VDDQ_VDDQ: PG5104.1 PR5105.1 PU5101.2
PWR_VDDQ_VLDOIN: PC5103.1 PG5115.2 PG5116.2 PU5101.28
PWR_VDDQ_VTT: PC5111.1 PC5112.1 PG5111.2 PG5113.2 PU5101.29 PU5101.31
PWR_VDDQ_VTTREF: PC5114.1 PU5101.1
PWR_VGA_NVVDD_OR: Q8504.D R8521.1
PWR_VGA_NVVDD_OR#: Q8504.G Q8509.3 Q8509.6 Q8605.G R8541.2
PWR_VGA_NVVDD_PG#: Q8615.5 Q8615.6 R8612.2
PWR_VGA_NVVDDS_BOOT1: PR8551.1 PU8551.1
PWR_VGA_NVVDDS_BOOT1_A: PC8556.1 PR8551.2
PWR_VGA_NVVDDS_BOOT2: PR8573.1 PU8551.15
PWR_VGA_NVVDDS_BOOT2_A: PC8569.1 PR8573.2
PWR_VGA_NVVDDS_EN: C8525.1 PU8551.3 R8521.2 R8529.2
PWR_VGA_NVVDDS_HG1: PU8551.2 PU8552.1 PU8553.1
PWR_VGA_NVVDDS_HG2: PU8551.14 PU8554.1 PU8555.1
PWR_VGA_NVVDDS_LGATE1: PU8551.19 PU8552.8 PU8553.8
PWR_VGA_NVVDDS_LGATE2: PU8551.17 PU8554.8 PU8555.8
PWR_VGA_NVVDDS_OCSET: PC8561.1 PR8564.1 PU8551.12
PWR_VGA_NVVDDS_PG: PR8557.2 PU8551.13 Q8612.2 R8532.1 R8617.1
PWR_VGA_NVVDDS_PHASE1: PC8556.2 PL8552.1 PU8551.20 PU8552.9 PU8553.9
PWR_VGA_NVVDDS_PHASE2: PC8569.2 PL8551.1 PU8551.16 PU8554.9 PU8555.9
PWR_VGA_NVVDDS_PSI: PC8557.1 PR8522.2 PR8559.2 PR8563.1 PU8551.4
PWR_VGA_NVVDDS_PVCC: PC8555.1 PR8556.2 PU8551.18
PWR_VGA_NVVDDS_REFADJ: PR8567.2 PU8551.6
PWR_VGA_NVVDDS_REFADJ_R: PC8565.1 PR8566.2 PR8567.1 PR8568.1
PWR_VGA_NVVDDS_REFIN: PC8567.1 PR8568.2 PR8570.1 PU8551.7
PWR_VGA_NVVDDS_REFIN_R: PR8570.2 PR8572.1
PWR_VGA_NVVDDS_TON: PR8562.2 PU8551.9
PWR_VGA_NVVDDS_TON_1: PC8554.1 PR8561.2 PR8562.1
PWR_VGA_NVVDDS_VID: PC8560.2 PR8510.2 PU8551.5
PWR_VGA_NVVDDS_VREF: PC8562.2 PR8566.1 PU8551.8
PWR_VGA_NVVDDS_VSEN1_N: PC8563.1 PC8564.1 PC8565.2 PC8567.2 PR8520.2 PR8569.1 PR8572.2 PU8551.10
PWR_VGA_NVVDDS_VSEN1_P: PC8563.2 PC8566.1 PR8517.2 PR8571.1 PR8577.1 PU8551.11
PWR_VGA_S0_PG: PR8623.1 PR8625.2 PU8603.2
PWR_VPP1D8V: PC5152.1 PC5153.1 PC5154.1 PG5152.2 PR5154.1 PU5151.3 PU5151.4
PWR_VPP1D8V_EN: PC5156.1 PR5151.1 PR5153.2 PU5151.8
PWR_VPP1D8V_FB: PC5152.2 PR5154.2 PR5155.1 PU5151.2
PWR_VTT_EN: PR5107.2 PU5101.5
Q502_G: Q501.D Q502.G R506.2
Q6204_G: Q6504.2 Q6504.5 R6510.2
Q6407_B: Q6406.C Q6407.B R6426.1
Q6407_C: Q6407.C R6413.1
Q6701_G: C6703.1 Q6701.2 R6701.2
Q6701_G_D: C6701.2 D6701.A Q6701.5 Q6701.6 R6702.2
Q7601_G: Q7901.2 Q7901.5 R7957.2
RAM1_ZQ0: R1202.1 RAM1.B3
RAM1_ZQ1: R1201.1 RAM1.B4
RAM2_ZQ0: R1203.1 RAM2.B3
RAM2_ZQ1: R1204.1 RAM2.B4
RAM3_ZQ0: R1302.1 RAM3.B3
RAM3_ZQ1: R1301.1 RAM3.B4
RAM4_ZQ0: R1304.1 RAM4.B3
RAM4_ZQ1: R1303.1 RAM4.B4
RESET_OUT#: ED1703.1 Q2602.G R1706.1 U2401.73
RTC_3P3_EN_D: Q2510.D R2511.2
RTC_3P3_EN_G: C2517.1 Q2510.G R2567.2
RTC_AUX_S5: Q2507.D R1730.1 R2204.1 R2511.1 RN1801.1(A) RN1801.2(A)
RTC_DET#: CPU1.CP22 Q2505.D R1519.1 R1554.2
RTC_RST#: C1806.1 CPU1.BR34 G1801.2 RN1801.4(B)
RTC_VCC_C: R2510.2 RTC1.1
RTCRST_ON: Q2507.G R2518.1 R2567.1 U2401.31
RUNPWROK: R2482.2 U2401.48
SATA_PCIE_LED#: D6401.3 Q6403.S
SD_1P8_SEL: R3326.1 U3301.1
SD_CD_N: CPU1.CH35 U3301.15
SD_CLK: CPU1.CK36 R3316.1
SD_CLK_R: C3313.1 R3316.2 U3301.6
SD_CMD: CPU1.CH36 R3315.1
SD_CMD_R: R3315.2 U3301.4
SD_PWR_EN#: CPU1.BW36 R3325.2 R3329.1
SD_PWR_EN#_R: R3329.2 U3301.32
SD_RCOMP: CPU1.CK33 CPU1.CM34 R1901.1
SD_SDATA0: CPU1.CL35 R3317.1
SD_SDATA0_R: R3317.2 U3301.7
SD_SDATA1: CPU1.CL36 R3318.1
SD_SDATA1_R: R3318.2 U3301.8
SD_SDATA2: CPU1.CM35 R3319.1
SD_SDATA2_R: R3319.2 U3301.2
SD_SDATA3: CPU1.CN35 R3320.1
SD_SDATA3_R: R3320.2 U3301.3
SD_WP: CPU1.CK34 R3331.2 R3332.1 U3301.16
SIO_EXT_SCI#: CPU1.CP8 R1608.2
SIO_EXT_SMI#: CPU1.CP7 R402.2
SIO_EXT_WAKE#: CPU1.CN12 R2041.2 U2401.116
SIO_PWRBTN#: CPU1.BU28 TP1714.1 U2401.52
SIO_RCIN#: CPU1.BV29 R1820.2
SKTOCC#: CPU1.E1 TP619.1
SM_INTRUDER#: CPU1.BR35 R1730.2
SM_PGCNTL: CPU1.C35 Q501.G
SM_RCOMP_0: CPU1.BN28 R501.1
SM_RCOMP_1: CPU1.BN27 R502.1
SM_RCOMP_2: CPU1.BN29 R503.1
SMBC_THERM_NV: GPU1.D9 Q7901.4 RN7901.4(B)
SMBD_THERM_NV: GPU1.D8 Q7901.1 RN7901.3(B)
SPI_CLK_CPU: CPU1.CH37 EC2501.1 R2508.2 R9138.1
SPI_CLK_PD: U7201.A3 U7202.6
SPI_CLK_ROM: BIOS1.6 R2508.1
SPI_CLK_ROM_TPM: R9138.2 U9101.19
SPI_CS2#_IC: R9130.2 R9148.2 U9101.20
SPI_CS_CPU_N0: BIOS1.1 CPU1.CG36 R2519.2
SPI_CS_CPU_N2: CPU1.CH34 R9118.2 R9130.1
SPI_CS_PD: R7228.1 U7201.B3 U7202.1
SPI_HOLD_CPU: CPU1.CG34 R1510.2 R1511.1 R2503.2
SPI_HOLD_PD: R7226.1 U7202.7
SPI_HOLD_ROM: BIOS1.7 R2503.1
SPI_IRQ#_TPM2: R9123.1 R9124.1 R9151.2 U9101.18
SPI_SI_CPU: CPU1.CF36 R1506.2 R1507.1 R2509.2 R9133.1
SPI_SI_PD: U7201.B4 U7202.5
SPI_SI_ROM: BIOS1.5 R2509.1
SPI_SI_ROM_TPM: R9133.2 U9101.21
SPI_SO_CPU: CPU1.CF37 R2506.1 R9132.1
SPI_SO_PD: R7230.1 U7201.A4 U7202.2
SPI_SO_ROM: BIOS1.2 R2506.2
SPI_SO_ROM_TPM: R9132.2 U9101.24
SPI_WP_CPU: CPU1.CF34 R1508.2 R1509.1 R2507.1
SPI_WP_PD: R7225.1 U7202.3
SPI_WP_ROM: BIOS1.3 R2507.2
SPK_ID: CPU1.CR14 R2110.2
SPKR: CPU1.CF35 R1501.1 R2741.1
SRTC_RST#: C1805.1 CPU1.BR37 RN1801.3(B)
SSD_CLK_CPU_N: CPU1.BA1 SSD1.53
SSD_CLK_CPU_P: CPU1.BA2 SSD1.55
SSD_CLKREQ_CPU_N: CPU1.CE30 RN1813.6(B) SSD1.52
SSD_DEVSLP: CPU1.CM8 R6301.1 R6303.2 R6304.1
SSD_PCIE_RX_N1: CPU1.BG5 SSD1.29
SSD_PCIE_RX_N2: CPU1.BJ6 SSD1.17
SSD_PCIE_RX_N3: CPU1.BK6 SSD1.5
SSD_PCIE_RX_P1: CPU1.BG6 SSD1.31
SSD_PCIE_RX_P2: CPU1.BJ5 SSD1.19
SSD_PCIE_RX_P3: CPU1.BK5 SSD1.7
SSD_PCIE_TX_CON_N1: C6312.1 SSD1.35
SSD_PCIE_TX_CON_N2: C6314.1 SSD1.23
SSD_PCIE_TX_CON_N3: C6316.1 SSD1.11
SSD_PCIE_TX_CON_P1: C6311.1 SSD1.37
SSD_PCIE_TX_CON_P2: C6313.1 SSD1.25
SSD_PCIE_TX_CON_P3: C6315.1 SSD1.13
SSD_PCIE_TX_N1: C6312.2 CPU1.BL4
SSD_PCIE_TX_N2: C6314.2 CPU1.BL2
SSD_PCIE_TX_N3: C6316.2 CPU1.BM4
SSD_PCIE_TX_P1: C6311.2 CPU1.BL3
SSD_PCIE_TX_P2: C6313.2 CPU1.BL1
SSD_PCIE_TX_P3: C6315.2 CPU1.BM3
SSD_SATA_RX_N: CPU1.BE5 SSD1.43
SSD_SATA_RX_P: CPU1.BE6 SSD1.41
SSD_SATA_TX_CON_N: C6303.1 SSD1.47
SSD_SATA_TX_CON_P: C6302.1 SSD1.49
SSD_SATA_TX_N: C6303.2 CPU1.BJ4
SSD_SATA_TX_P: C6302.2 CPU1.BJ3
SSD_SCP#: R2449.2 R6314.1 R6606.1 U2401.21
SSD_SCP#_1: R6314.2 SSD1.8
SSD_SCP#_2: IO2.8 R6606.2
SSEQ0_A0: R7145.2 R7146.1 U7101.11
SSEQ1: R7144.1 R7152.2 U7101.3
ST_GND: R9131.1 U9101.2
ST_PP: TP9105.1 U9101.7
STRAP0: GPU1.D1 R7908.1 R7919.2
STRAP1: GPU1.D2 R7909.2 R7911.1
STRAP2: GPU1.E4 R7914.2 R7915.1
STRAP3: GPU1.E3 R7925.2 R7926.1
STRAP4: GPU1.D3 R7928.2 R7929.1
STRAP5: GPU1.C1 R7938.2 R7939.1
STRAP_REF0_GND_N9: GPU1.F6 R7907.1
SUS_CLK: CPU1.BT32 R2461.2 R6117.1
SUSACK#_R: CPU1.BY32 R1708.1
SUSCLK_WLAN: R6117.2 WLAN1.50
SVID_ALERT#_CPU: PR4605.2 PR4623.1 R727.2 R728.2
SVID_ALERT#_CPU_R: CPU1.AA3 R728.1
SVID_CLK_CPU: PR4606.2 PR4624.1 R723.2 R732.2
SVID_CLK_CPU_R: CPU1.AA1 R732.1
SVID_DATA_CPU: PR4604.2 PR4622.1 R709.2
SVID_DATA_CPU_R: CPU1.AA2 R709.1 R726.2
SYS_LED_MASK#: C2436.1 PR2455.2 R2410.1 R2457.1 U2401.55
SYS_LED_MASK#_R: R2410.2 R2456.2 R6419.1 U6402.2
SYS_PEX_RST_MON#: GPU1.AC7 R7604.2 R7606.1 U7601.4
SYS_PWROK: CPU1.CR10 ED1701.1 R1717.2 U2401.28
SYSPWR_PRES: R2454.1 R2463.2 U2401.120
T_CRIT#: R2601.1 R2604.2 U2601.4
TABLE_MODE#: R2027.2 U2401.85
TBTA_SENSEN: R7217.2 U7201.A10
TBTA_SENSEP: R7216.2 U7201.B10
TESTMODE: GPU1.AD9 R7602.1
THERM_SYS_SHDN#: Q2602.S R2601.2
THERMTRIP#_CPU: CPU1.BJ1 ED301.1 R308.2
TOUCH_DETECT: ED5502.2 LCD1.25 R2102.1 R5504.2
TOUCH_DETECT_R: CPU1.CN14 R2102.2
TOUCH_PANEL_INTR#: CPU1.CN3 ED5502.5 LCD1.27
TOUCH_PANEL_PD#: CPU1.CC35 ED5502.4 LCD1.26
TOUCH_REPORT_SW: D2402.A ED5502.1 LCD1.24
TP_65982D_RESET_N: R7229.2 TP7205.1
TP_WAKE_KBC#: AFTP6536.1 CPU1.CB34 R303.2 R6511.2 TPAD1.4 U2401.33
TPM_GPIO0: R9121.1 U9101.29
TPM_GPIO1: TP9102.1 U9101.30
TPM_GPIO3: TP9103.1 U9101.6
TPM_GPIO4: R9118.1 U9101.13
TPM_GPIO6_PP: TP9104.1 U9101.4
TPM_ID: CPU1.CK25 R1910.2 R1911.1
TPM_SPI_IRQ#: CPU1.CF20 R9124.2
TS_VREF: GPU1.AE2 TP7614.1
TYPEC_DCIN1_EN#: Q7406.2 Q7407.2 R7428.1 U2401.63
TYPEC_SMBCLK: R7220.1 RN2413.4(B) U2401.91 U7201.B5
TYPEC_SMBDA: R7221.1 RN2413.3(B) U2401.89 U7201.A5
U3_PD#_EC: IO1.15 R2407.2
U3301_GPIO0: AFTP3301.1 U3301.31
U3301_GPIO1: AFTP3302.1 U3301.30
UART_2_CRXD_DTXD: CPU1.CR12 R2048.2 R6803.1
UART_2_CRXD_DTXD_CON: DB1.14 R6803.2
UART_2_CTXD_DRXD: CPU1.CP12 R2049.2 R6802.1
UART_2_CTXD_DRXD_CON: DB1.13 R6802.2
UPD1_ALERT_R: R7235.2 U7201.B6
UPD1_SMBINT#: R7215.2 R7235.1 U2401.32
USB1_CC1: C7217.1 ED7304.1 ED7304.10 R7211.2 U7201.L9 USB1.A5
USB1_CC2: C7218.1 ED7304.2 ED7304.9 R7212.2 U7201.L10 USB1.B5
USB1_SBU1: ED7304.4 ED7304.7 R7153.2 R7330.1 USB1.A8
USB1_SBU1_R: R7153.1 U7101.27
USB1_SBU2: ED7304.5 ED7304.6 R7151.2 R7331.1 USB1.B8
USB1_SBU2_R: R7151.1 U7101.26
USB1_SSRX_CON_N1: C7121.2 R7120.1 USB1.B10
USB1_SSRX_CON_N2: C7123.2 R7122.1 USB1.A10
USB1_SSRX_CON_P1: C7120.2 R7119.1 USB1.B11
USB1_SSRX_CON_P2: C7122.2 R7123.1 USB1.A11
USB1_SSRX_MUX_N1: C7121.1 ED7301.4 ED7301.7 U7101.31
USB1_SSRX_MUX_N2: C7123.1 ED7302.2 ED7302.9 U7101.39
USB1_SSRX_MUX_P1: C7120.1 ED7301.5 ED7301.6 U7101.30
USB1_SSRX_MUX_P2: C7122.1 ED7302.1 ED7302.10 U7101.40
USB1_SSTX_CON_N1: C7163.2 ED7301.1 ED7301.10 USB1.A3
USB1_SSTX_CON_N2: C7162.2 ED7302.5 ED7302.6 USB1.B3
USB1_SSTX_CON_P1: C7164.2 ED7301.2 ED7301.9 USB1.A2
USB1_SSTX_CON_P2: C7161.2 ED7302.4 ED7302.7 USB1.B2
USB1_SSTX_MUX_N1: C7163.1 U7101.34
USB1_SSTX_MUX_N2: C7162.1 U7101.36
USB1_SSTX_MUX_P1: C7164.1 U7101.33
USB1_SSTX_MUX_P2: C7161.1 U7101.37
USB1_USB20_CON_N: IO1.14 R6609.2
USB1_USB20_CON_P: IO1.13 R6608.2
USB1_USB20_N: CPU1.CE3 R6609.1
USB1_USB20_P: CPU1.CE4 R6608.1
USB1_USB30_RX_N: CPU1.CB5 IO1.8
USB1_USB30_RX_P: CPU1.CB6 IO1.7
USB1_USB30_TX_N: CPU1.CA4 IO1.11
USB1_USB30_TX_P: CPU1.CA3 IO1.10
USB2_ID: CPU1.CE8 R1601.2
USB2_VBUSSENSE: CPU1.CC6 R1602.2
USB4_USB20_CMC_N1: EL7201.1 U7201.L6
USB4_USB20_CMC_N2: EL7202.1 U7201.L7
USB4_USB20_CMC_P1: EL7201.4 U7201.K6
USB4_USB20_CMC_P2: EL7202.4 U7201.K7
USB4_USB20_CON_N1: ED7303.1 ED7303.10 EL7201.2 USB1.A7
USB4_USB20_CON_N2: ED7303.4 ED7303.7 EL7202.2 USB1.B7
USB4_USB20_CON_P1: ED7303.2 ED7303.9 EL7201.3 USB1.A6
USB4_USB20_CON_P2: ED7303.5 ED7303.6 EL7202.3 USB1.B6
USB4_USB20_N: CPU1.CD3 U7201.K5
USB4_USB20_P: CPU1.CD4 U7201.L5
USB4_USB30_RX_C_N: C7106.2 U7101.4
USB4_USB30_RX_C_P: C7105.2 U7101.5
USB4_USB30_RX_N: C7106.1 CPU1.BW6
USB4_USB30_RX_P: C7105.1 CPU1.BW5
USB4_USB30_TX_C_N: C7104.2 U7101.7
USB4_USB30_TX_C_P: C7103.2 U7101.8
USB4_USB30_TX_N: C7104.1 CPU1.BW2
USB4_USB30_TX_P: C7103.1 CPU1.BW1
USB_ADT: PD4407.A PD4408.2 R7411.1 U7418.5 U7418.6 U7418.7 U7418.8 U7419.A1 U7419.B1 U7419.C1 U7419.D1
USB_EN#: IO1.16 R2434.2 U2401.13
USB_OC0#: CPU1.CK6 IO1.17 RN1601.5(B)
USB_OC1#: CPU1.CK5 RN1601.6(B)
USB_OC2#: CPU1.CK8 RN1601.7(B)
USB_OC3#: CPU1.CK9 RN1601.8(B) U7201.B2
USB_PWR_SHR_EN_L#: R2435.2 U2401.118
USBCOMP: CPU1.CC5 R1603.2
V_SM_VREF_CNTA: C1250.1 CPU1.D35 CPU1.D37 R1224.2
V_SM_VREF_CNTB: C1339.1 CPU1.E36 R1323.2
VCORE_OVP_+: PC44A9.1 PD44A1.K PR44A1.1 PR44A6.2 PU44A1.3
VCORE_OVP_-: PC44A1.1 PR44A2.2 PR44A3.1 PU44A1.1
VCORE_OVP_OUT: PD44A1.A PQ44A1.2 PR44A4.2 PU44A1.4
VGA_B7: GPU1.B7 R7701.2
VGA_CORE_DISCHG: Q8605.D R8624.2
VGA_CORE_PSI: GPU1.A4 PR8522.1
VGA_CORE_VID: GPU1.C6 PR8510.1
VGACORE_GND_SENSE_1: GPU1.F1 PR8520.1
VGACORE_VDD_SENSE_1: GPU1.F2 PR8517.1
VIDEO_CLK_XTAL_SS: GPU1.A10 R7901.1
VIO_18: R3321.1 U3301.14
VR_CAP: C2418.2 U2401.18
VRALERT#: CPU1.CC36 TP1708.1
VRAM_ID1: CPU1.CE27 R2034.1 R2035.2
VRAM_ID2: CPU1.CN23 R2037.1 R2038.2
VSYS_UVP_+: PC44B3.1 PR44B1.1 PR44B7.2 PU44B1.3
VSYS_UVP_-: PC44B1.1 PR44B2.2 PR44B3.1 PU44B1.1
VSYS_UVP_OUT: PD44B1.A PQ44A1.5 PQ44B1.3 PR44B4.2 PU44B1.4
VTT_CNTL: PR5107.1 Q502.D R507.2
WHITE_LED_BAT: EC6401.1 Q6401.C R6402.1
WIFI_RF_EN: AFTP6110.1 CPU1.CG25 R6106.1
WIFI_RF_EN_R: R6106.2 R6113.2 WLAN1.56
WLAN_CLK_CPU_N: CPU1.BC1 WLAN1.49
WLAN_CLK_CPU_P: CPU1.BC2 WLAN1.47
WLAN_CLKREQ_CPU_N: AFTP6109.1 CPU1.CE32 RN1813.8(B) WLAN1.53
WLAN_COEX1: R6107.2 WLAN1.48
WLAN_COEX2: R6108.2 WLAN1.46
WLAN_COEX3: R6109.2 WLAN1.44
WLAN_PCIE_RX_N: CPU1.BN6 WLAN1.43
WLAN_PCIE_RX_P: CPU1.BN5 WLAN1.41
WLAN_PCIE_TX_CON_N: C6107.1 WLAN1.37
WLAN_PCIE_TX_CON_P: C6108.1 WLAN1.35
WLAN_PCIE_TX_N: C6107.2 CPU1.BR4
WLAN_PCIE_TX_P: C6108.2 CPU1.BR3
WSSD_DEVSLP: CPU1.CR8 R6605.1
WSSD_DEVSLP_R: IO2.16 R6605.2
WWAM_CARD_PWR_OFF#: CPU1.CN22 R6607.1
WWAM_CARD_PWR_OFF#_R: IO2.26 R6607.2
WWAN_BB_RST#: CPU1.CF17 IO2.22 R2120.2
WWAN_CLKREQ_CPU_N: CPU1.CF30 IO2.24 RN1813.7(B)
WWAN_GPO_PEREST#: CPU1.CH22 R6603.1
WWAN_GPO_PEREST#_R: IO2.18 R6603.2 R6604.2
WWAN_PCIE_CLK_N: CPU1.BD3 IO2.27
WWAN_PCIE_CLK_P: CPU1.BC3 IO2.29
WWAN_PCIE_RX_N11: CPU1.BN10 IO2.9
WWAN_PCIE_RX_N12: CPU1.BL6 IO2.21
WWAN_PCIE_RX_P11: CPU1.BN8 IO2.11
WWAN_PCIE_RX_P12: CPU1.BL5 IO2.23
WWAN_PCIE_TX_N11: CPU1.BN4 IO2.3
WWAN_PCIE_TX_N12: CPU1.BN2 IO2.15
WWAN_PCIE_TX_P11: CPU1.BN3 IO2.5
WWAN_PCIE_TX_P12: CPU1.BN1 IO2.17
WWAN_USB20_N: CPU1.CH5 IO2.30
WWAN_USB20_P: CPU1.CH6 IO2.32
XCLK_BIASREF: CPU1.CJ1 R1803.1
XDP_CLK_CPU_N: CPU1.AU1 TP1808.1
XDP_CLK_CPU_P: CPU1.AU2 TP1807.1
XDP_DBRESET#: CPU1.CN10 R1701.2
XDP_PRDY#: CPU1.W1 TP306.1
XDP_PREQ#: CPU1.W2 TP305.1
XDP_TCLK: CPU1.P6 CPU1.T6 R317.2 TP309.1
XDP_TDI: CPU1.U5 CPU1.U6 TP310.1
XDP_TDO_CPU: CPU1.W5 CPU1.Y5 R310.2 TP316.1
XDP_TMS: CPU1.P5 CPU1.T5 TP317.1
XDP_TRST#: CPU1.AB6 CPU1.Y6 TP313.1
XTL_24M_X1_CPU: CPU1.CK3 R1839.1
XTL_24M_X1_R: C1807.1 R1839.2 R1841.2 X1801.1
XTL_24M_X2_CPU: CPU1.CK2 R1840.1
XTL_24M_X2_R: C1808.1 R1840.2 R1841.1 X1801.3
XTL_27M_X2: C7908.1 R7904.2 X7901.3
XTL_32K_X1_CPU: C1804.1 CPU1.BN31 R1815.1 X1802.1
XTL_32K_X2_CPU: C1803.1 CPU1.BN32 R1815.2 X1802.2

Pads without a net: CPU1 A34 A35 AA4 AA24 AA26 AA35 AB25 AC6 AC7 AC24 AC25 AC26 AC35 AD24 AD26 AE34 AE35 AF31 AG6 AG7 AG37 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AL34 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC24 BC28 BE1 BE2 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP5 BP6 BP8 BP9 BP28 BP29 BP34 BP35 BR1 BR2 BR18 BT8 BT9 BT31 BU29 BU31 BV24 BV25 BV30 BY3 BY4 BY6 BY7 BY8 BY9 BY30 BY31 C34 CA1 CA2 CA32 CA35 CA36 CB8 CB9 CC29 CC30 CE1 CE2 CE31 CF12 CF22 CF31 CG1 CG2 CG3 CG4 CG8 CG9 CG14 CG20 CG23 CG35 CH7 CH8 CH9 CH17 CH25 CH30 CH32 CJ17 CJ22 CJ29 CK17 CM16 CM18 CM19 CM20 CM23 CM27 CM28 CN4 CN8 CN16 CN18 CN19 CN26 CN28 CN36 CP3 CP4 CP6 CP16 CP18 CP20 CP28 CR3 CR4 CR16 CR18 CR20 CR24 CR28 CR35 D34 F34 F37 G1 G2 G3 G4 H3 H4 J1 J2 J3 K12 K14 K15 K17 K18 K20 L1 L2 L3 L4 L5 L25 M3 M4 M24 M26 N1 N2 N3 N4 N5 P24 P26 R1 R2 R4 R24 R25 R26 T3 T4 T25 V24 V25 W3 W25 W31 W37 Y3 Y24 Y25 Y29; DB1 1 12; DCIN1 5; ED5501 1 4 5; ED5502 6 7 9 10; ED5703 5 6; ED9201 4 5 6 7; GPU1 A3 A7 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE22 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF22 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C2 C3 C4 C7 C14 D4 D5 D10 D11 D12 D23 E6 E7 E9 E10 F3 F4 F5 F7 F10 F19 P25 T27 V7 W5 W6 W7 W22 Y3 Y4 Y6; HDMI1 13 14; IO1 5; IO2 33 34; KB1 2 3; KBBL1 3; LCD1 4; PU4501 15; PU4701 4 6 27 30 31 35; PU4702 4 6 27 30 31 35; PU4801 4 6 27 30 31 35; PU5101 26; PU5301 5; PU8601 5; PU8602 12; PU8603 5; RAM1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; RAM2 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; RAM3 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; RAM4 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; RN7203 5; SSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; TPAD1 1 2; U2401 3 4 35 49 70 71; U2502 3; U5501 3; U7201 F4 G4 L11; U9101 3 5 9 10 11 12 14 15 25 26 27 28 31 32; VRAM1 A5 A10 U5 U10; VRAM4 A5 A10 U5 U10; WLAN1 6 8 12 16 20 38 40 42 58 60 62 66 68 70

## Via types
v1: diameter 0.356, hole 0.178, TOP to BOTTOM, 986 vias
v2: diameter 0.508, hole 0.254, TOP to BOTTOM, 3569 vias
v3: diameter 0.457, hole 0.203, TOP to BOTTOM, 997 vias
v4: diameter 0.711, hole 0.406, TOP to BOTTOM, 533 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_CPU_CORE: length 102.8
  L3 w0.305: v2(56.4,61.56) 56.93,61.56 57.09,61.4 73.63,61.4 74.55,60.49 79.7,60.49 79.9,60.29
  L5 w0.254: v2(91.8,67.44) 92.68,66.55 v2(93.89,66.55)
  L6 w0.254: v3(133.85,56.12) 133.51,55.78 131.82,55.78 131.22,56.38 128.58,56.38 128.3,56.09 127.87,56.09 127.58,56.39 127.58,56.44 127.51,56.51 125.42,56.51 125.11,56.82 124.26,56.82 v3(123.85,57.23)
  L8 w0.254: v3(123.85,57.23) 123.85,57.31 123.64,57.52 123.64,58.7 124.26,59.32 124.26,63.72 123.1,64.89 123.1,66.58 123.44,66.93 123.44,67.83 120.33,70.94 113.69,70.94 113.55,70.8 110.63,70.8 109.51,71.92 109.51,72.36 108,73.86 97.43,73.86 95.9,75.39 93.8,75.39 92.57,74.16 87.75,74.16 v4(86.94,74.96)
  BOTTOM w0.203: v2(85.44,65.72) 85.27,65.56 CPU1.AK2 ; CPU1.AB2 80.39,66.08 v2(80.35,66.12) ; CPU1.V2 77.95,65.83 v2(77.92,65.86) ; CPU1.AF2 v2(82.83,66.12) ; CPU1.BB2 92.59,65.65 91.8,66.45 v2(91.8,67.44)
  BOTTOM w0.254: CPU1.AV2 89.84,65.51 89.84,65.71 89.66,65.88 v2(89.66,66.03) ; CPU1.BE9 CPU1.BF9 ; CPU1.BF2 95.03,65.41 v2(93.89,66.55) ; v2(87.59,66.39) 87.71,66.27 CPU1.AP2
  BOTTOM w0.305: v3(133.85,56.12) 133.97,56.24 PR44A6.1 ; v2(56.4,61.56) 56.4,60.65 PR4631.2
  vias: v1(89.61,75.59) v2(79.53,55.8) v2(79.54,55.16) v2(79.55,54.52) v2(79.55,53.86) v2(79.57,58.68) v2(79.55,57.95) v2(79.55,57.2) v2(79.56,56.47) v2(79.55,53.22) v2(79.56,52.53) v2(80.3,59.49) v2(81.6,59.44) v2(83.07,59.41) v2(84.34,59.41) v2(85.52,58.68) v2(85.5,57.95) v2(85.5,57.2) v2(85.51,56.47) v2(85.48,55.8) v2(85.49,55.16) v2(85.5,54.52) v2(85.5,53.86) v2(85.5,53.22) v2(86.5,65.1) v2(87.87,51.25) v2(88.33,50.8) v2(88.61,59.44) v2(88.78,62.46) v2(88.78,61.82) v2(88.78,61.19) v2(88.78,51.25) v2(89.24,50.8) v2(89.67,62.48) v2(89.69,51.25) v2(89.69,48.85) v2(89.88,59.46) v2(90.59,62.48) v2(90.61,61.85) v2(90.59,61.19) v2(90.61,51.25) v2(90.61,48.85) v2(91.06,50.8) v2(91.35,59.44) v2(91.45,57.98) v2(91.45,57.23) v2(91.43,55.84) v2(91.44,55.2) v2(91.44,54.55) v2(91.44,53.89) v2(91.45,53.26) v2(91.53,62.56) v2(91.53,61.14) v2(91.47,58.71) v2(91.46,56.5) v2(91.49,51.28) v2(91.52,48.85) v2(91.96,50.79) v2(92.44,61.8) v2(92.4,51.28) v2(92.43,48.85) v2(92.47,62.43) v2(92.62,59.35) v2(93.34,51.25) v2(93.34,48.85) v2(93.8,50.8) v2(94.25,51.25) v2(94.25,48.85) v2(94.71,50.8) v2(95.16,51.25) v2(95.16,48.85) v4(74.03,75.27) v4(74.94,75.29) v4(74.96,77.52) v4(74.96,76.63) v4(75.66,75.75) v4(75.83,77.52) v4(75.83,76.63) v4(76.5,75.75) v4(76.66,77.52) v4(76.66,76.63) v4(77.36,75.75) v4(77.5,77.52) v4(77.5,76.63) v4(78.2,75.75) v4(78.37,77.52) v4(78.37,76.63) v4(79.04,75.75) v4(79.2,77.52) v4(79.2,76.63) v4(79.21,74.9) v4(79.56,59.46) v4(79.87,75.75) v4(80.04,77.52) v4(80.04,76.63) v4(80.05,74.83) v4(80.71,75.75) v4(80.88,77.52) v4(80.88,76.63) v4(81.72,77.52) v4(81.72,76.63) v4(81.68,75.75) v4(82.33,59.49) v4(82.57,75.75) v4(82.68,77.52) v4(82.68,76.63) v4(83.52,75.8) v4(83.5,74.96) v4(83.57,77.52) v4(83.57,76.63) v4(84.44,75.73) v4(84.44,74.81) v4(85.18,59.36) v4(85.45,75.6) v4(85.97,74.86) v4(86.47,75.69) v4(87.36,75.69) v4(87.84,59.51) v4(90.61,59.51) v4(93.35,59.3)
