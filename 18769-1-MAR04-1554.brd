# Allegro board 18769-1-MAR04-1554.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
Net_9732 on TOP_-MB (solid shape): 155.53,17.04 155.53,16.05 155.03,15.54 154.35,15.54 154.35,15.63 154.36,15.67 154.37,15.72 154.38,15.78 154.37,15.83 154.36,15.88 154.34,15.93 154.32,15.98 154.28,16.03 154.24,16.06 154.2,16.1 154.16,16.12 154.74,16.12 154.74,16.37 154.49,16.37 154.49,16.12 154.16,16.12 154.1,16.14 154.04,16.15 153.99,16.15 153.94,16.15 153.88,16.14 153.83,16.12 153.78,16.09 153.75,16.06 153.64,16.06 153.45,16.25 153.45,16.73 153.83,17.11 155.46,17.11
Net_9733 on TOP_-MB (solid shape): 192.42,17.58 192.42,16.29 192.27,16.14 192.21,16.16 192.15,16.17 192.12,16.17 191.84,16.17 191.82,16.17 191.78,16.16 191.73,16.15 191.7,16.13 191,16.13 190.92,16.21 190.92,16.71 192.09,16.71 192.09,17.24 191.83,17.24 191.83,16.71 190.92,16.71 190.92,17.28 191.27,17.63 192.37,17.63
Net_9734 on TOP_-MB (solid shape): 118.43,20.98 118.43,20.12 118.32,20.01 118.25,20.01 118.21,20 118.18,19.99 118.15,19.97 118.05,19.97 117.92,19.84 117.92,17.99 117.64,17.71 116.85,17.71 116.83,17.73 116.42,17.73 116.37,17.68 116.37,16.56 115.91,16.09 115.32,16.09 115.17,16.24 115.17,16.8 115.65,16.8 115.66,16.77 115.66,16.51 115.92,16.51 115.92,16.77 115.9,16.8 115.9,17.05 115.65,17.05 115.65,16.8 115.17,16.8 115.17,17.29 115.15,17.31 115.9,17.31 115.9,17.56 115.65,17.56 115.65,17.31 115.15,17.31 115.14,17.31 115.14,17.39 115.13,17.43 115.12,17.46 115.09,17.49 115.07,17.52 115.05,17.53 115.05,20.75 116.31,20.75 116.34,20.75 117.51,20.75 117.51,21 117.25,21 117.25,20.75 116.59,20.75 116.59,21 116.34,21 116.31,21 116.05,21 116.05,20.75 115.05,20.75 115.05,21.5 115.28,21.73 117.68,21.73
Net_9735 on TOP_-MB (solid shape): 188.35,18.32 188.38,18.32 188.42,18.27 189.04,18.27 189.17,18.14 189.17,16.77 189.12,16.72 188.23,16.72 188.07,16.87 188.07,17.53 187.85,17.76 188.16,17.76 188.23,17.75 188.23,17.49 188.48,17.49 188.48,17.75 188.41,17.76 188.41,18.01 188.16,18.01 188.16,17.76 187.85,17.76 187.79,17.81 187.79,18.34 187.87,18.42 188.25,18.42
Net_9736 on TOP_-MB (solid shape): 100.55,20.76 100.55,18.47 100.42,18.35 100.42,16.8 100.31,16.69 98.64,16.69 98.51,16.82 98.51,17.05 99.06,17.05 99.06,17.18 99.97,17.18 99.97,17.68 99.72,17.68 99.72,17.18 99.06,17.18 99.06,17.3 98.81,17.3 98.81,17.05 98.51,17.05 98.51,17.33 98.89,17.71 98.89,17.94 99.97,17.94 99.97,18.19 99.72,18.19 99.72,17.94 98.89,17.94 98.89,18.22 99.5,18.22 99.5,18.47 99.25,18.47 99.25,18.22 98.89,18.22 98.89,18.72 99.5,18.72 99.5,18.98 99.25,18.98 99.25,18.72 98.89,18.72 98.89,19.09 100.11,19.09 100.11,19.35 99.85,19.35 99.85,19.09 98.89,19.09 98.89,19.88 99.56,19.88 99.85,19.6 100.11,19.6 100.11,19.86 99.81,20.14 99.56,20.14 99.56,19.88 98.89,19.88 98.89,20.25 99.53,20.88 100.42,20.88
Net_9737 on TOP_-MB (solid shape): outline of 216 points within 77.69,16.69 82.51,24.19
Net_9738 on TOP_-MB (solid shape): 21.22,18.61 21.26,18.59 21.31,18.58 21.35,18.58 21.4,18.59 21.6,18.38 21.6,17.86 21.7,17.76 21.7,16.95 21.55,16.79 20.99,16.79 20.99,17.49 20.78,17.49 20.78,16.79 20.48,16.79 20.48,17.49 20.28,17.49 20.28,16.79 19.98,16.79 19.98,17.49 19.77,17.49 19.77,16.79 19.34,16.79 19.24,16.9 19.24,17.53 19.6,17.89 20.5,17.89 20.5,18.15 20.25,18.15 20.25,17.89 19.6,17.89 19.82,18.12 19.82,18.5 19.95,18.62 21.19,18.62
Net_9739 on TOP_-MB (solid shape): outline of 469 points within 30.18,17.03 36.5,46.76
Net_9740 on TOP_-MB (solid shape): outline of 112 points within 14.84,16.97 17.09,22.03
Net_9741 on TOP_-MB (solid shape): 177.5,20.74 177.5,20.35 177.85,20.01 178.06,20.01 178.3,19.77 178.3,19.35 179.46,18.19 179.56,18.19 180.09,17.66 180.09,17.53 180.03,17.46 178.74,17.46 178.59,17.61 178.49,17.61 177.87,18.23 177.79,18.23 177.76,18.24 177.7,18.25 177.65,18.25 177.46,18.44 177.46,18.82 177.4,18.89 177.93,18.89 177.93,18.63 178.19,18.63 178.19,18.89 178.19,18.92 178.19,19.17 177.94,19.17 177.94,18.92 177.93,18.89 177.4,18.89 176.87,19.41 176.87,19.83 177.41,19.83 177.41,20.09 177.15,20.09 177.15,19.83 176.87,19.83 176.87,19.88 176.86,19.92 176.86,19.95 176.86,20.76 176.95,20.86 177.38,20.86
Net_9742 on TOP_-MB (solid shape): outline of 160 points within 75.27,18.22 77.43,24.31
Net_9743 on TOP_-MB (solid shape): outline of 186 points within 94.2,18.22 96.35,24.31
Net_9745 on TOP_-MB (solid shape): 103.34,24.19 103.34,23.99 103.29,23.96 103.25,23.93 103.22,23.89 103.19,23.85 103.17,23.81 103.15,23.76 103.15,23.71 103.15,23.66 103.15,23.61 103.17,23.56 103.19,23.52 103.22,23.48 103.25,23.44 103.29,23.41 103.34,23.38 103.34,23.16 103.32,23.15 103.27,23.12 103.24,23.08 103.2,23.04 103.18,22.99 103.16,22.94 103.16,22.89 103.16,22.84 103.16,22.79 103.18,22.74 103.2,22.69 103.24,22.65 103.27,22.61 103.32,22.58 103.34,22.57 103.34,22.25 103.33,22.24 103.33,21.66 103.21,21.54 103.09,21.54 102.24,20.69 102.24,20.55 102.2,20.5 102.2,18.47 102.09,18.36 102.07,18.34 100.93,18.34 100.8,18.47 100.8,19.09 101.33,19.09 101.33,19.35 101.07,19.35 101.07,19.09 100.8,19.09 100.8,19.6 101.33,19.6 101.33,19.86 101.07,19.86 101.07,19.6 100.8,19.6 100.8,19.88 101.92,19.88 101.92,20.14 101.67,20.14 101.67,19.88 100.8,19.88 100.8,20.8 101.92,20.8 101.92,21.05 101.67,21.05 101.67,20.8 100.8,20.8 100.8,22.15 102.96,24.31 103.21,24.31
Net_9746 on TOP_-MB (solid shape): 113.78,24.31 113.98,24.16 114.22,24.18 114.25,24.19 114.51,23.94 114.51,23.92 114.58,23.78 114.71,23.72 114.73,23.72 114.79,23.65 114.9,23.65 114.9,18.47 114.64,18.22 113.88,18.22 113.37,18.72 113.37,19.69 113.41,19.76 113.5,19.78 113.85,20.07 113.5,20.36 113.41,20.38 113.37,20.45 113.37,20.49 113.41,20.56 113.5,20.58 113.85,20.87 113.5,21.16 113.41,21.18 113.37,21.25 113.37,22.7 113.63,22.7 114.23,22.9 113.63,23.1 113.37,23.1 113.37,24.19 113.5,24.31
Net_9747 on TOP_-MB (solid shape): 181.03,19.45 181.36,19.45 181.72,19.08 181.72,18.42 181.57,18.27 181.34,18.27 181.2,18.4 181.19,18.4 180.73,18.85 180.73,19.36 180.84,19.46 181.01,19.46
Net_9748 on TOP_-MB (solid shape): 64.93,24.19 65.24,24.19 65.24,23.96 65.22,23.95 65.17,23.92 65.14,23.88 65.1,23.84 65.08,23.79 65.06,23.74 65.06,23.69 65.06,23.64 65.06,23.59 65.08,23.54 65.1,23.49 65.14,23.45 65.17,23.41 65.22,23.38 65.24,23.37 65.24,23.16 65.22,23.15 65.17,23.12 65.14,23.08 65.1,23.04 65.08,22.99 65.06,22.94 65.06,22.89 65.06,22.84 65.06,22.79 65.08,22.74 65.1,22.69 65.14,22.65 65.17,22.61 65.22,22.58 65.24,22.57 65.24,22.25 65.19,22.2 65.19,21.59 65.11,21.52 64.73,21.52 62.83,19.61 62.83,18.47 62.7,18.34 61.81,18.34 61.68,18.47 61.68,19.94 62.74,19.94 62.74,20.2 62.48,20.2 62.48,19.94 61.68,19.94 61.68,20.25 62.29,20.25 62.29,20.5 62.04,20.5 62.04,20.25 61.68,20.25 61.68,20.76 62.29,20.76 62.29,21.01 62.04,21.01 62.04,20.76 61.68,20.76 61.68,21.52 64.48,24.31 64.81,24.31
Net_9749 on TOP_-MB (solid shape): 84.16,24.19 84.16,23.96 84.14,23.95 84.1,23.92 84.06,23.88 84.03,23.84 84,23.79 83.99,23.74 83.98,23.69 83.98,23.64 83.99,23.59 84,23.54 84.03,23.49 84.06,23.45 84.1,23.41 84.14,23.38 84.16,23.37 84.16,23.16 84.14,23.15 84.1,23.12 84.06,23.08 84.03,23.04 84,22.99 83.99,22.94 83.98,22.89 83.98,22.84 83.99,22.79 84,22.74 84.03,22.69 84.06,22.65 84.1,22.61 84.14,22.58 84.16,22.57 84.16,22.25 84.14,22.23 84.14,21.65 84.03,21.54 83.95,21.54 83.26,20.85 83.26,20.74 83.02,20.5 83.02,18.84 82.52,18.34 81.75,18.34 81.62,18.47 81.62,21.65 82.28,21.65 82.28,21.9 82.03,21.9 82.03,21.65 81.62,21.65 81.62,22.16 82.28,22.16 82.28,22.41 82.03,22.41 82.03,22.16 81.62,22.16 81.62,22.53 83.4,24.31 84.04,24.31
Net_9750 on TOP_-MB (solid shape): outline of 96 points within 180.13,18.58 185.09,22.81
Net_9751 on TOP_-MB (solid shape): 183.96,19.89 183.96,19.44 183.71,19.18 183.71,18.93 183.45,18.67 183.3,18.67 183.17,18.8 183.17,19.74 183.45,20.02 183.83,20.02
Net_9752 on TOP_-MB (solid shape): 183.63,21.39 183.63,20.91 183.12,20.4 183.12,19.87 183.04,19.79 183.04,18.9 182.89,18.75 182.79,18.75 182.68,18.86 182.69,18.89 182.73,19.13 182.65,19.36 182.64,19.38 182.64,19.46 182.31,19.79 182.31,20.66 183.2,21.54 183.48,21.54
Net_9753 on TOP_-MB (solid shape): 187.46,20.06 187.46,19.38 187.35,19.26 185.66,19.26 185.64,19.26 185.59,19.25 185.55,19.23 185.51,19.21 185.47,19.18 185.44,19.14 185.43,19.11 185.07,18.75 184.52,18.75 184.4,18.87 184.4,19.03 184.83,19.46 186.05,19.46 186.05,19.71 185.8,19.71 185.8,19.46 185.55,19.46 185.55,19.71 185.29,19.71 185.29,19.46 184.83,19.46 184.89,19.52 184.89,19.74 185.13,19.98 186.15,19.98 186.35,20.19 187.33,20.19
Net_9754 on TOP_-MB (solid shape): outline of 313 points within 115.01,20 121.28,32.81
Net_9755 on TOP_-MB (solid shape): 163.26,25.71 163.26,24.19 163.29,24.16 163.29,23.75 163.26,23.74 163.05,23.42 163.24,23.09 163.24,22.9 163.29,22.85 163.29,22.83 163.3,22.73 163.33,22.65 163.34,22.64 163.34,21.02 163.21,20.89 163.12,20.82 163.06,20.75 162.65,20.75 162.49,20.86 162.29,20.88 162.27,20.87 162.09,21.05 162.09,25.4 162.67,25.97 163,25.97
Net_9756 on TOP_-MB (solid shape): outline of 13272 points within 43.01,21.9 115.66,47.72
Net_9757 on TOP_-MB (solid shape): outline of 109 points within 56.1,21.9 58.25,28
Net_9758 on TOP_-MB (solid shape): 111.97,24.04 111.97,24.02 112.02,23.91 112.1,23.82 112.1,23.52 111.97,23.27 112.1,23.02 112.1,22.72 112,22.61 111.97,22.47 111.97,22.45 111.91,22.39 111.9,22.39 111.79,22.35 111.7,22.27 111.62,22.23 111.54,22.27 111.47,22.34 111.38,22.38 111.36,22.39 111.26,22.49 111.31,22.54 111.33,22.54 111.62,22.84 111.38,23.18 111.36,23.19 111.26,23.29 111.31,23.34 111.33,23.34 111.62,23.64 111.38,23.98 111.36,23.99 111.28,24.07 111.47,24.25 111.76,24.25
Net_9759 on TOP_-MB (solid shape): 183.17,25.33 183.2,25.29 183.23,25.25 183.27,25.22 183.31,25.2 183.36,25.18 183.41,25.17 183.46,25.17 183.51,25.18 183.55,25.19 183.6,25.22 183.65,25.26 183.9,25.01 183.9,23.63 183.59,23.32 180.16,23.32 180.13,23.36 180.1,23.38 180.07,23.4 180.04,23.42 180,23.42 179.9,23.42 179.75,23.58 179.75,23.93 180.17,23.93 180.17,24.19 179.92,24.19 179.92,23.93 179.75,23.93 179.75,24.2 180.66,25.11 180.7,25.12 180.73,25.13 180.77,25.14 180.8,25.17 180.82,25.19 180.84,25.23 180.85,25.26 180.86,25.33 181.18,25.33 181.24,25.38 183.15,25.38
Net_9760 on TOP_-MB (solid shape): 166.78,25.47 166.78,24.75 166.67,24.65 166.67,24.2 166.85,24.02 166.85,23.45 166.73,23.33 166.34,23.33 165.9,23.77 166.37,23.77 166.37,24.02 166.12,24.02 166.12,23.77 165.9,23.77 165.83,23.84 165.83,24.43 165.42,24.84 165.42,24.87 166.26,24.87 166.26,25.12 166.01,25.12 166.01,24.87 165.42,24.87 165.42,25.47 165.54,25.59 166.66,25.59
Net_9761 on TOP_-MB (solid shape): outline of 305 points within 36.01,22.12 44.13,30.98
Net_9762 on TOP_-MB (solid shape): 147.16,25.14 147.16,24.66 147.01,24.52 146.51,24.52 146.41,24.42 146.41,23.7 146.26,23.55 145.31,23.55 145.2,23.66 145.2,23.73 146.02,23.73 146.02,23.98 145.76,23.98 145.76,23.73 145.2,23.73 145.2,24.21 145.2,24.21 145.2,24.46 145.21,24.48 145.22,24.53 145.22,24.57 145.22,24.59 145.68,24.59 145.76,24.49 145.76,24.24 146.02,24.24 146.02,24.49 145.94,24.59 145.94,24.85 145.68,24.85 145.68,24.59 145.22,24.59 145.2,24.65 145.2,25.02 145.47,25.29 147.01,25.29
Net_9763 on TOP_-MB (solid shape): 141.5,24.47 142.23,24.47 142.28,24.43 142.28,23.83 141.97,23.53 141.24,23.53 140.94,23.82 141.92,23.82 141.92,24.08 141.67,24.08 141.67,23.82 140.94,23.82 140.66,24.11 141.24,24.11 141.24,24.36 140.99,24.36 140.99,24.11 140.66,24.11 140.6,24.17 140.6,24.65 140.7,24.76 141.22,24.76
Net_9765 on TOP_-MB (solid shape): outline of 703 points within 46.37,24.35 55.89,31.23
Net_9766 on TOP_-MB (solid shape): 19.12,26.4 19.12,26.37 19.12,26.05 19.38,25.84 19.39,25.84 19.42,25.82 20.1,25.82 20.22,25.7 20.22,25.38 19.98,25.13 19.65,25.13 19.5,24.99 19.49,24.98 19.4,24.93 19.35,24.85 19.35,24.83 19.12,24.6 19.1,24.61 19,24.61 18.9,24.59 18.88,24.59 18.56,24.9 18.56,25.25 18.7,25.36 18.78,25.51 18.78,25.53 18.87,25.61 18.87,25.74 18.65,25.96 18.52,25.96 18.47,25.97 18.41,25.98 18.28,26.11 18.28,26.47 18.4,26.59 18.93,26.59
Net_9767 on TOP_-MB (solid shape): 188.75,27.05 188.75,26.71 189.06,26.4 189.06,25.61 189.2,25.47 189.2,24.67 189.01,24.49 188.6,24.49 188.47,24.61 188.47,24.71 188.48,25.14 188.48,25.16 188.47,25.19 188.46,25.23 188.44,25.26 188.41,25.28 188.38,25.31 188.35,25.32 188.31,25.33 188.27,25.33 187.09,26.51 188.09,26.51 188.09,26.26 188.34,26.26 188.34,26.51 188.36,26.56 188.36,26.81 188.1,26.81 188.1,26.56 188.09,26.51 187.09,26.51 186.65,26.95 186.65,27.25 186.72,27.32 188.48,27.32
Net_9768 on TOP_-MB (solid shape): 46.06,27.87 46.06,25.95 46.06,25.94 46.06,25.36 45.98,25.29 45.86,25.29 45.77,25.2 44.54,25.2 44.28,25.46 44.28,27.41 44.87,27.41 44.87,27.66 44.62,27.66 44.62,27.41 44.28,27.41 44.28,27.92 44.87,27.92 44.87,28.17 44.62,28.17 44.62,27.92 44.28,27.92 44.28,28.63 44.41,28.76 45.17,28.76
Net_9769 on TOP_-MB (solid shape): 178.58,26.27 178.58,25.64 178.42,25.47 176.99,25.47 176.86,25.6 177.7,25.6 177.7,25.86 177.45,25.86 177.45,25.6 176.86,25.6 176.75,25.72 176.75,26.14 177.09,26.48 178.16,26.48 178.16,26.48 178.37,26.48
Net_9770 on TOP_-MB (solid shape): outline of 152 points within 152.57,25.76 157.51,28.35
Net_9771 on TOP_-MB (solid shape): outline of 89 points within 19.12,25.99 22.75,28.79
Net_9772 on TOP_-MB (solid shape): 178.19,28.27 178.21,28.25 178.25,28.21 178.29,28.18 178.34,28.15 178.39,28.13 178.44,28.12 178.5,28.11 178.55,28.11 178.61,28.12 178.66,28.14 178.71,28.17 178.75,28.2 178.77,28.22 179.77,28.22 179.91,28.35 182.47,28.35 182.54,28.28 182.54,28.06 182.44,27.95 181.86,27.95 181.85,27.96 181.7,27.96 181.69,27.94 181.6,27.94 181.43,27.77 181.39,27.73 181.31,27.66 180.05,27.66 179.68,27.28 178.79,27.28 178.1,26.6 176.84,26.6 176.72,26.73 176.72,27.13 177.7,27.13 177.7,27.38 177.45,27.38 177.45,27.13 176.72,27.13 176.72,27.44 177.09,27.81 177.09,27.85 177.1,27.89 177.11,27.94 177.12,27.99 177.11,28.04 177.1,28.1 177.09,28.13 177.09,28.21 177.36,28.48 177.99,28.48
Net_9773 on TOP_-MB (solid shape): 146.45,29.65 146.45,27.08 146.31,26.94 145.92,26.94 145.69,27.16 145.69,27.5 145.55,27.64 144.74,27.64 144.42,27.96 144.42,28.09 145.19,28.09 145.19,28.34 145.44,28.34 145.44,28.09 145.69,28.09 146.03,28.41 146.03,28.66 145.77,28.66 145.44,28.34 144.93,28.34 144.93,28.09 144.42,28.09 144.42,29.17 145.77,29.17 145.77,28.91 146.03,28.91 146.03,29.17 146.08,29.21 146.08,29.46 145.83,29.46 145.83,29.21 145.77,29.17 144.42,29.17 144.42,29.54 144.65,29.76 146.34,29.76
Net_9774 on TOP_-MB (solid shape): outline of 922 points within 22.52,28.73 32.3,45.6
Net_9775 on TOP_-MB (solid shape): 156.25,30.56 156.23,30.5 156.23,30.45 156.23,30.39 156.24,30.33 156.26,30.28 156.29,30.23 156.33,30.19 156.37,30.15 156.42,30.12 156.45,30.11 156.89,29.67 157.03,29.67 157.09,29.61 157.09,29.23 156.91,29.04 156.48,29.04 156.05,29.47 156.05,29.48 156.61,29.48 156.61,29.73 156.36,29.73 156.36,29.48 156.05,29.48 156.05,29.73 155.74,30.03 155.74,30.06 155.75,30.07 155.75,30.49 155.92,30.66 156.15,30.66
Net_9776 on TOP_-MB (solid shape): 45.78,30.76 45.83,30.74 45.88,30.73 45.93,30.72 45.99,30.72 46.02,30.7 46.04,30.69 46.05,30.66 46.06,30.62 46.06,30.1 46.04,30.09 46,30.06 45.97,30.02 45.94,29.97 45.92,29.92 45.91,29.87 45.9,29.82 45.91,29.77 45.92,29.72 45.94,29.67 45.97,29.62 46,29.58 46.04,29.55 46.06,29.54 46.06,29.27 45.94,29.14 43.4,29.14 43.01,29.52 43.01,29.82 43.35,29.82 43.53,29.64 43.56,29.64 43.74,29.46 43.92,29.64 43.74,29.82 43.71,29.82 43.53,29.99 43.35,29.82 43.01,29.82 43.01,30.5 44.18,30.5 44.18,30.66 45.39,30.66 45.42,30.66 45.48,30.67 45.53,30.69 45.59,30.71 45.63,30.75 45.67,30.78 45.75,30.78
Net_9777 on TOP_-MB (solid shape): 169.94,31.79 169.94,30.82 169.74,30.63 168.86,30.63 168.63,30.4 168.63,29.64 168.5,29.51 167.82,29.51 167.2,30.13 167.2,30.35 167.86,30.35 167.86,30.61 167.6,30.61 167.6,30.35 167.2,30.35 167.2,31.35 169.2,31.35 169.26,31.26 169.51,31.26 169.51,31.51 169.26,31.51 169.2,31.6 168.95,31.6 168.95,31.35 168.7,31.35 168.7,31.6 168.44,31.6 168.44,31.35 167.2,31.35 167.2,31.8 167.41,32.01 169.72,32.01
Net_9778 on TOP_-MB (solid shape): outline of 187 points within 38.8,30.46 42.84,36.2
Net_9779 on TOP_-MB (solid shape): 187.8,31.83 187.82,31.82 187.85,31.79 187.89,31.78 187.93,31.77 187.95,31.77 188.33,31.77 188.35,31.77 188.39,31.78 188.42,31.79 188.46,31.82 188.47,31.83 188.59,31.83 188.6,31.81 188.63,31.78 188.67,31.75 188.71,31.73 188.76,31.72 188.78,31.72 189.29,31.72 189.35,31.72 189.38,31.71 189.4,31.69 189.41,31.66 189.42,31.62 189.42,31.04 188.92,30.55 188.2,30.55 188.14,30.49 186.73,30.49 186.63,30.59 186.63,31.01 188.26,31.01 188.55,30.81 188.81,30.81 188.81,31.06 188.52,31.26 188.26,31.26 188.26,31.01 188.01,31.01 188.01,31.26 187.76,31.26 187.76,31.01 186.63,31.01 186.63,31.42 187.03,31.83
Net_9780 on TOP_-MB (solid shape): 117.49,33.33 117.49,32.93 117.05,32.5 117.05,32.4 116.98,32.33 116.98,31.58 117.43,31.14 117.43,30.62 117.32,30.51 116.16,30.51 116,30.67 116,31.26 116.35,31.26 116.39,31.19 116.39,30.94 116.64,30.94 116.67,30.97 116.92,30.97 116.92,31.23 116.61,31.52 116.35,31.52 116.35,31.26 116,31.26 116,32.04 116.35,32.04 116.35,32.03 116.35,31.77 116.61,31.77 116.61,32.03 116.6,32.04 116.6,32.29 116.35,32.29 116.35,32.04 116,32.04 116,32.62 115.78,32.83 115.99,32.83 116.35,32.55 116.6,32.55 116.6,32.8 116.24,33.09 115.99,33.09 115.99,32.83 115.78,32.83 115.68,32.94 115.56,32.94 115.52,32.98 115.52,33.37 115.6,33.44 117.38,33.44
Net_9781 on TOP_-MB (solid shape): 36.49,33.36 37.19,33.36 37.35,33.51 37.86,33.51 38.01,33.36 38.01,32.13 37.82,31.94 36.31,31.94 35.93,32.31 37.2,32.31 37.2,32.42 37.45,32.42 37.45,32.67 37.2,32.9 36.94,32.9 36.94,32.31 36.69,32.31 36.69,32.9 36.44,32.9 36.44,32.31 35.93,32.31 35.76,32.49 35.76,33.35 35.97,33.56 36.29,33.56
Net_9782 on TOP_-MB (solid shape): 170.23,33.32 170.23,32.78 170.15,32.7 169.19,32.7 169.18,32.73 169.11,32.8 169.01,32.82 168.63,32.82 168.54,32.8 168.47,32.73 168.45,32.7 167.39,32.7 167.3,32.8 167.3,33.43 167.42,33.56 169.99,33.56
Net_9783 on TOP_-MB (solid shape): outline of 132 points within 141.29,32.69 148.45,42.5
Net_9784 on TOP_-MB (solid shape): 153.17,42.98 153.17,41.31 151.96,40.09 151.96,38.47 151.89,38.47 151.89,33.09 151.68,32.87 148.98,32.87 148.63,33.23 148.63,37.77 148.65,37.8 148.65,38.44 148.37,38.72 148.37,38.73 148.29,38.85 148.17,38.95 148.17,41 148.37,41.2 148.37,41.94 148.35,41.97 148.35,42.83 148.83,43.31 152.84,43.31
Net_9785 on TOP_-MB (solid shape): 141.49,43 141.49,39.17 141.08,38.77 141.08,33.2 140.96,33.08 138.16,33.08 137.93,33.3 137.93,39.86 136.36,41.43 136.36,42.85 136.51,43.01 137.4,43.01 137.68,43.29 137.68,43.67 137.83,43.82 140.68,43.82
Net_9786 on TOP_-MB (solid shape): 123.38,37.75 123.38,36.64 123.48,36.53 123.48,35.67 122.9,35.08 122.44,35.08 122.24,35.29 122.24,35.87 123.03,35.87 123.03,36.08 122.24,36.08 122.24,36.39 123.03,36.39 123.03,36.58 122.24,36.58 122.24,36.89 123.03,36.89 123.03,37.09 122.24,37.09 122.24,37.44 122.14,37.54 122.14,37.68 121.27,37.68 121.27,37.67 120.05,37.67 119.95,37.77 119.95,38.18 120.03,38.26 122.87,38.26
Net_9787 on TOP_-MB (solid shape): outline of 86 points within 49.1,34.85 60.25,40.91
Net_9788 on TOP_-MB (solid shape): 163.92,37.01 163.92,36.53 162.73,35.34 157.77,35.34 157.76,35.32 157.06,35.32 156.83,35.55 156.83,35.73 158.48,35.73 158.48,35.99 158.22,35.99 158.22,35.73 157.97,35.73 157.97,35.99 157.71,35.99 157.71,35.73 156.83,35.73 156.83,35.74 157.47,35.74 157.47,36 157.21,36 157.21,35.74 156.83,35.74 156.83,36.13 159.15,36.13 159.16,36.13 160.33,36.13 160.36,36.12 161.53,36.12 161.54,36.11 162.45,36.11 162.73,35.82 162.99,35.82 162.99,36.08 162.97,36.11 162.97,36.36 162.72,36.36 162.71,36.37 162.45,36.37 162.45,36.11 161.79,36.11 161.79,36.37 161.54,36.37 161.53,36.37 161.27,36.37 161.27,36.12 160.61,36.12 160.61,36.37 160.36,36.37 160.33,36.38 160.08,36.38 160.08,36.13 159.42,36.13 159.42,36.38 159.16,36.38 159.15,36.39 158.89,36.39 158.89,36.13 158.23,36.13 158.23,36.39 157.62,36.39 157.62,36.13 156.83,36.13 156.83,37.09 156.98,37.24 163.69,37.24
Net_9789 on TOP_-MB (solid shape): 34.22,36.8 34.63,36.8 34.66,36.77 34.75,36.57 34.95,36.49 34.97,36.49 35.1,36.36 35.1,35.94 34.9,35.73 33.62,35.73 33.55,35.81 33.19,35.81 32.8,36.2 32.8,36.65 32.95,36.8 34.22,36.8
Net_9790 on TOP_-MB (solid shape): outline of 367 points within 96.27,35.74 98.27,49.89
Net_9791 on TOP_-MB (solid shape): outline of 400 points within 0.51,36.01 11.49,50.79
Net_9792 on TOP_-MB (solid shape): outline of 97 points within 189.17,35.95 192.81,39.02
Net_9793 on TOP_-MB (solid shape): 194.88,37.96 194.88,36.22 194.62,35.96 193.52,35.96 193.33,36.15 193.33,36.62 193.96,36.62 194.06,36.6 194.06,36.34 194.31,36.34 194.31,36.6 194.21,36.62 194.21,36.87 193.96,36.87 193.96,36.62 193.33,36.62 193.33,37.75 193.34,37.78 193.35,37.8 193.38,37.8 193.97,37.8 193.99,37.81 194.03,37.81 194.08,37.83 194.11,37.86 194.15,37.89 194.17,37.93 194.19,37.97 194.2,38.01 194.2,38.2 194.64,38.2
Net_9794 on TOP_-MB (solid shape): outline of 1580 points within 34.45,36.84 66.56,80.98
Net_9795 on TOP_-MB (solid shape): 34.12,38.43 34.1,38.39 34.07,38.13 34.21,37.91 34.21,37.71 34.28,37.64 34.28,37.31 34.08,37.11 32.76,37.11 32.76,37.32 32.6,37.48 32.6,38.16 32.95,38.5 34.04,38.5
Net_9796 on TOP_-MB (solid shape): outline of 251 points within 135.29,37.45 163.9,48.44
Net_9797 on TOP_-MB (solid shape): outline of 242 points within 42.48,37.72 48.98,44.63
Net_9798 on TOP_-MB (solid shape): outline of 126 points within 134.42,38.23 138.49,50.04
Net_9801 on TOP_-MB (solid shape): 36.23,40.53 36.23,40.18 35.92,39.87 35.92,39.5 35.88,39.46 35.54,39.46 35.52,39.48 35.47,39.43 34.96,39.43 34.94,39.45 34.94,39.81 35.5,39.81 35.5,40.06 35.24,40.06 35.24,39.81 34.94,39.81 34.94,39.86 34.73,40.06 34.54,40.06 34.21,40.06 34.2,40.06 33.9,40.06 33.72,40.24 33.72,40.52 33.86,40.66 35.51,40.66 35.52,40.67 36.09,40.67
Net_9802 on TOP_-MB (solid shape): 35.57,41.66 35.57,40.89 35.46,40.78 32.36,40.78 32.3,40.84 32.3,41.73 32.39,41.83 35.4,41.83
Net_9803 on TOP_-MB (solid shape): outline of 162 points within 171.64,41.65 188.3,49.26
Net_9804 on TOP_-MB (solid shape): 36.35,42.95 36.35,42.31 36.2,42.16 33.02,42.16 32.87,42.3 32.87,42.44 32.88,42.46 32.88,42.5 33.02,42.64 33.67,42.64 34.01,42.98 34.01,43.32 34.1,43.4 35.9,43.4
Net_9805 on TOP_-MB (solid shape): outline of 5192 points within 162.5,42.22 192.96,77.53
Net_9806 on TOP_-MB (solid shape): 45.17,45.78 45.17,44.76 44.54,44.12 41.52,44.12 41.06,44.58 41.06,44.76 41.67,44.76 41.67,44.83 44.83,44.83 44.83,45.09 44.58,45.09 44.58,44.83 43.92,44.83 43.92,45.09 43.31,45.09 43.31,44.83 42.65,44.83 42.65,45.09 42.39,45.09 42.39,44.83 41.67,44.83 41.67,45.01 41.42,45.01 41.42,44.76 41.06,44.76 41.06,44.91 41.29,45.14 42.02,45.14 42.38,45.49 42.38,45.78 42.63,46.03 44.92,46.03
Net_9807 on TOP_-MB (solid shape): outline of 162 points within 17.5,45.12 29.01,47.58
Net_9808 on TOP_-MB (solid shape): outline of 101 points within 109.56,46.56 114.03,49.89
Net_9809 on TOP_-MB (solid shape): 113.04,48.42 113.06,48.41 113.11,48.38 113.16,48.37 113.21,48.36 113.27,48.36 113.32,48.37 113.37,48.38 113.53,48.23 113.53,46.97 113.09,46.53 112.63,46.53 112.28,46.88 112.28,47.4 112.13,47.55 112.13,47.59 111.99,47.73 112.6,47.73 112.6,47.98 112.35,47.98 112.35,47.73 111.99,47.73 111.97,47.76 110.85,47.76 110.63,47.98 110.63,48.19 110.86,48.42
Net_9810 on TOP_-MB (solid shape): outline of 2722 points within 49.2,46.72 79.77,66.14
Net_9811 on TOP_-MB (solid shape): 99.24,47.66 100.98,47.66 101.18,47.46 101.18,47.16 101.1,47.09 101.02,47.06 100.95,47.1 100.6,47.25 100.29,47.03 100.28,47 99.28,47 99.13,47.15 98.91,47.31 98.64,47.29 98.61,47.27 98.51,47.37 98.51,47.71 98.61,47.81 99.09,47.81
Net_9813 on TOP_-MB (solid shape): outline of 3870 points within 73.44,48.49 95.49,77.91
Net_9814 on TOP_-MB (solid shape): outline of 205 points within 80.11,48.7 84.88,58.95
Net_9815 on TOP_-MB (solid shape): 86.83,51.1 86.83,50.42 86.7,50.3 86.7,49.51 86.35,49.15 86.28,49.15 86.24,49.18 86.2,49.2 86.15,49.22 86.09,49.23 86.04,49.23 85.99,49.23 85.94,49.21 85.89,49.2 85.84,49.17 85.82,49.15 84.57,49.15 84.37,49.36 84.37,50.07 84.39,50.09 86.51,50.09 86.51,50.35 86.26,50.35 86.26,50.09 85.73,50.09 85.73,50.35 85.19,50.35 85.19,50.09 84.39,50.09 84.71,50.42 84.75,50.42 84.81,50.44 84.86,50.46 84.91,50.49 84.95,50.53 84.99,50.57 85.02,50.62 85.04,50.67 85.06,50.73 85.06,50.77 85.16,50.87 85.21,50.88 85.26,50.89 85.31,50.91 85.35,50.94 85.4,50.97 85.43,51.01 85.46,51.06 85.49,51.1 85.51,51.15 85.52,51.21 85.52,51.28 86.65,51.28
Net_9817 on TOP_-MB (solid shape): outline of 93 points within 102.5,49.28 106.39,52.23
Net_9818 on TOP_-MB (solid shape): outline of 125 points within 74.36,49.33 77.05,58.94
Net_9819 on TOP_-MB (solid shape): 125.92,56.36 125.92,56.24 126.2,55.96 126.2,55.56 126.31,55.45 126.32,55.42 126.34,55.39 126.37,55.36 126.4,55.34 126.43,55.32 126.46,55.3 126.72,55.04 126.72,54.44 126.56,54.27 125.98,54.27 125.92,54.33 125.69,54.33 125.68,54.35 125.65,54.37 125.61,54.39 125.57,54.39 125.55,54.39 125.17,54.39 125.15,54.39 125.11,54.39 125.08,54.37 125.05,54.35 125.02,54.33 125,54.29 124.99,54.26 124.98,54.22 124.98,54.1 124.32,53.44 124.32,49.38 124.17,49.24 123.43,49.24 123.22,49.45 123.22,53.55 124.78,55.11 124.78,55.29 124.98,55.29 124.98,55.21 124.98,54.95 125.23,54.95 125.23,55.21 125.49,55.21 125.49,54.95 125.74,54.95 126.02,55.29 126.02,55.55 125.77,55.55 125.49,55.21 125.23,55.21 125.23,55.29 125.23,55.55 124.98,55.55 124.98,55.29 124.78,55.29 124.78,55.35 124.79,55.37 124.82,55.41 124.83,55.46 124.84,55.51 124.85,55.56 124.84,55.61 124.83,55.66 124.82,55.71 124.79,55.76 124.78,55.78 124.78,56.25 124.96,56.44 125.84,56.44
Net_9820 on TOP_-MB (solid shape): 97.09,52.58 97.09,51.52 97.22,51.39 97.22,51.11 97.2,51.09 97.16,51.06 97.13,51.02 97.1,50.97 97.08,50.92 97.07,50.88 96.96,50.78 96.96,50.14 96.71,49.89 96.38,49.89 95.87,49.38 94.27,49.38 94.22,49.43 94.22,50.27 94.45,50.5 94.47,50.5 94.49,50.48 94.54,50.45 94.59,50.43 94.65,50.42 94.71,50.42 94.76,50.42 94.82,50.43 94.87,50.45 94.92,50.48 94.94,50.5 95.38,50.5 95.4,50.48 95.45,50.46 95.5,50.43 95.56,50.42 95.61,50.42 95.67,50.42 95.73,50.43 95.78,50.45 95.83,50.48 95.87,50.51 95.91,50.55 95.94,50.6 95.97,50.65 95.99,50.7 96,50.76 96,50.81 95.99,50.87 95.98,50.92 95.96,50.98 95.93,51.02 95.89,51.07 95.85,51.1 95.8,51.13 95.75,51.16 95.75,51.36 95.9,51.52 96.74,51.52 96.74,51.77 96.48,51.77 96.48,51.52 95.9,51.52 96,51.62 96,51.65 96,51.65 96,52.28 96.48,52.28 96.48,52.03 96.74,52.03 96.74,52.28 96.75,52.3 96.75,52.55 96.5,52.55 96.5,52.3 96.48,52.28 96,52.28 96,52.82 96.18,52.99 96.69,52.99
Net_9823 on TOP_-MB (solid shape): 9.87,51.16 9.94,51.14 10.23,50.97 10.56,50.91 12,50.91 12.25,50.94 12.48,51.04 12.59,51.04 12.64,50.95 12.64,50.93 11.34,49.64 11.34,49.6 11.31,49.55 11.25,49.56 10.55,50.26 3.57,50.26 3.57,50.58 3.57,50.62 3.56,50.66 3.58,50.75 3.66,50.79 9.05,50.79 9.46,50.88 9.8,51.13
Net_9824 on TOP_-MB (solid shape): outline of 118 points within 40.98,49.46 48.97,57.46
Net_9825 on TOP_-MB (solid shape): 166.04,51.79 166.04,50.26 165.63,49.86 165.3,49.86 165.07,50.09 165.07,51.59 163.35,53.31 162.85,53.31 162.64,53.1 162.63,53.1 162.37,52.84 161.8,53.41 161.65,53.26 162.22,52.69 161.91,52.39 161.59,52.39 161.33,52.65 161.33,53.09 161.41,53.18 161.41,53.34 161.51,53.44 160.86,54.09 161.03,54.09 161.18,53.93 161.72,54.47 161.57,54.62 161.03,54.09 160.86,54.09 160.76,54.19 160.76,54.73 161.11,55.08 162.74,55.08
Net_9826 on TOP_-MB (solid shape): outline of 194 points within 99.98,50.19 107.81,53.31
Net_9827 on TOP_-MB (solid shape): outline of 1123 points within 95.03,50.5 104.28,78.03
Net_9828 on TOP_-MB (solid shape): outline of 280 points within 92.53,51.6 95.88,64.8
Net_9829 on TOP_-MB (solid shape): 41.11,56.32 41.11,53.9 40.47,53.27 40.47,52 40.35,51.87 39.59,51.87 39.33,52.13 39.33,54.07 40.51,54.07 40.51,54.33 40.26,54.33 40.26,54.07 39.33,54.07 39.33,55.24 40.26,55.24 40.26,54.99 40.51,54.99 40.51,55.24 40.52,55.25 40.52,55.5 40.27,55.5 40.27,55.25 40.26,55.24 39.33,55.24 39.33,56.16 40.52,56.16 40.52,56.42 40.27,56.42 40.27,56.16 39.33,56.16 39.33,56.19 39.71,56.57 40.86,56.57
Net_9831 on TOP_-MB (solid shape): outline of 153 points within 98.58,52.68 104.52,55.85
Net_9832 on TOP_-MB (solid shape): 102.12,56.86 102.17,56.85 102.22,56.85 102.27,56.85 102.32,56.86 102.35,56.87 103.41,56.87 103.66,56.62 105.44,56.62 105.57,56.49 105.57,54.2 105.82,53.95 106.59,53.95 106.63,54 106.64,54 106.7,54.06 106.99,54.06 107.09,53.95 107.09,53.57 106.71,53.19 106.47,53.19 106.44,53.21 106.41,53.22 106.37,53.23 106.35,53.23 105.96,53.23 105.94,53.23 105.9,53.22 105.87,53.21 105.84,53.19 105.39,53.19 105.01,52.81 104.68,52.81 104.55,52.93 104.55,53.29 105.3,53.29 105.3,53.55 105.05,53.55 105.05,53.29 104.55,53.29 104.55,55.09 104.65,55.19 104.71,55.18 104.77,55.17 104.82,55.16 104.88,55.17 104.93,55.19 104.98,55.21 105.03,55.24 105.07,55.28 105.11,55.32 105.14,55.37 105.16,55.42 105.18,55.48 105.18,55.53 105.18,55.59 105.17,55.64 105.15,55.7 105.13,55.75 105.09,55.79 105.06,55.83 105.06,55.85 104.93,55.98 100.11,55.98 99.91,56.18 99.92,56.27 99.92,56.34 99.91,56.42 100.11,56.62 101.76,56.62 102.01,56.87 102.08,56.87
Net_9833 on TOP_-MB (solid shape): 112.48,54.22 112.48,54.2 112.5,54.11 112.53,54.02 112.53,53.92 112.45,53.87 111.82,53.87 111.82,53.57 112.55,53.57 112.55,53.78 112.6,53.86 112.69,53.87 112.99,53.85 113.21,54.05 116.27,54.05 116.57,53.75 116.57,53.04 116.35,52.82 115.98,52.82 115.75,53.05 115.11,53.05 115.02,53.11 115.03,53.21 114.72,53.82 114.41,53.21 114.42,53.11 114.33,53.05 114.05,53.05 114.02,53.06 113.99,53.06 113.6,53.06 113.57,53.06 113.53,53.05 113.44,53.05 113.39,53.12 112.98,53.44 112.63,53.05 112.63,53 111.79,53 111.66,53.13 111.66,53.65 111.66,53.66 111.66,54.23 111.75,54.31 112.39,54.31
Net_9834 on TOP_-MB (solid shape): outline of 148 points within 105.72,54.12 113.4,56.64
Net_9835 on TOP_-MB (solid shape): 160.54,58.15 160.54,57.74 160.41,57.61 160.37,57.6 160.33,57.57 160.28,57.54 160.24,57.51 160.21,57.47 160.18,57.42 160.16,57.37 160.15,57.32 160.14,57.26 160.15,57.21 160.16,57.16 160.18,57.11 160.21,57.06 160.24,57.02 160.26,57 160.26,56.42 160.15,56.3 160.15,55.98 160.19,55.93 160.2,55.91 160.23,55.87 160.25,55.86 160.25,55.65 159.43,54.84 159.23,54.84 158.98,55.08 158.98,55.28 159.01,55.29 159.05,55.34 159.08,55.39 159.1,55.45 159.11,55.49 159.25,55.62 159.25,56.11 159.32,56.19 159.32,56.5 158.98,56.83 158.98,56.93 159.51,56.93 159.69,56.75 159.87,56.93 159.69,57.11 159.51,56.93 158.98,56.93 158.98,57.05 159.03,57.05 159.28,57.29 159.69,57.29 159.9,57.51 159.9,57.9 159.8,58 159.8,58.12 160.11,58.43 160.26,58.43
Net_9836 on TOP_-MB (solid shape): 98.88,56.82 98.88,56.68 98.97,56.58 99.61,56.58 99.78,56.41 99.78,55.61 99.56,55.39 99.32,55.39 99.11,55.6 98.51,55.6 98.51,55.6 98.38,55.46 97.61,55.46 97.52,55.56 97.52,55.98 97.65,56.12 97.83,56.12 98.77,56.12 98.77,56.37 98.51,56.37 98.51,56.12 97.83,56.12 97.87,56.12 97.9,56.14 97.93,56.16 97.96,56.18 97.98,56.21 98,56.26 98.04,56.26 98.11,56.32 98.11,56.86 98.16,56.91 98.64,56.91 98.66,56.91 98.7,56.92 98.75,56.94
Net_9837 on TOP_-MB (solid shape): 110.83,56.82 110.83,56.44 110.82,56.4 110.82,56.37 110.82,55.8 110.58,55.55 110.32,55.55 110.07,55.81 110.07,56.7 110.08,56.71 110.08,56.82 110.21,56.95 110.71,56.95
Net_9838 on TOP_-MB (solid shape): outline of 1002 points within 146.88,55.93 163.27,79.73
Net_9839 on TOP_-MB (solid shape): outline of 327 points within 112.05,56.28 119.15,62.34
Net_9840 on TOP_-MB (solid shape): outline of 93 points within 99.98,56.74 106.29,59.46
Net_9841 on TOP_-MB (solid shape): outline of 96 points within 104.04,57 107.96,60
Net_9842 on TOP_-MB (solid shape): outline of 88 points within 151.12,57.18 155.84,62.06
Net_9843 on TOP_-MB (solid shape): outline of 85 points within 157.39,57.17 159.77,60.5
Net_9844 on TOP_-MB (solid shape): 104.74,61.13 104.74,60.33 103.83,59.42 103.83,57.96 103.72,57.85 102.68,57.85 102.6,57.93 102.6,58.7 102.74,58.84 102.74,59.27 103.07,59.59 103.07,59.73 103.07,59.74 103.09,59.85 103.07,59.95 103.07,59.96 103.07,60.18 103.12,60.23 103.36,60.23 103.9,60.77 103.9,61.31 103.92,61.33 104.54,61.33
Net_9845 on TOP_-MB (solid shape): 16.02,61.5 16.53,61.5 16.55,61.51 16.71,61.51 16.8,61.42 16.8,59.94 16.72,59.86 16.44,59.86 16.32,59.74 16.32,59.2 16.14,59.02 15.58,59.02 15.14,59.46 15.14,59.49 15.84,59.49 15.84,59.75 15.58,59.75 15.58,59.49 15.14,59.49 15.14,59.9 15.21,59.98 15.21,61.26 15.47,61.51 16.01,61.51
Net_9846 on TOP_-MB (solid shape): 20.88,61.82 20.86,61.77 20.85,61.72 20.85,61.67 20.86,61.62 20.87,61.58 20.9,61.53 20.93,61.49 20.96,61.46 21,61.43 21.05,61.4 21.09,61.39 21.14,61.38 21.19,61.38 21.24,61.39 21.29,61.41 21.57,61.14 21.57,60.27 21.88,59.96 22,59.96 22.23,59.72 22.23,59.33 21.91,59.01 20.79,59.01 20.62,59.18 20.62,59.23 21.37,59.23 21.37,59.49 21.11,59.49 21.11,59.23 20.62,59.23 20.62,59.74 21.37,59.74 21.37,60 21.11,60 21.11,59.74 20.62,59.74 20.62,60.21 19.74,61.09 18.99,61.09 18.85,61.23 18.85,61.52 19.6,61.52 19.6,61.68 20.56,61.68 20.56,61.93 20.31,61.93 20.31,61.68 20.05,61.68 20.05,61.93 19.8,61.93 19.8,61.68 19.6,61.68 19.6,61.78 19.34,61.78 19.34,61.52 18.85,61.52 18.85,61.74 19.34,62.23 19.39,62.23 19.44,62.23 19.49,62.25 19.54,62.27 19.58,62.29 19.62,62.33 19.64,62.34 20.36,62.34
Net_9847 on TOP_-MB (solid shape): outline of 104 points within 71.61,59.24 78.45,64.36
Net_9848 on TOP_-MB (solid shape): 13.63,63.46 13.63,62.19 14.12,61.7 14.17,61.7 14.18,61.69 14.46,61.58 14.73,61.7 14.96,61.7 15.08,61.58 15.08,61.11 15.01,60.89 15.08,60.67 15.08,60.46 15.02,60.26 15.06,60.06 15.08,60.03 14.87,59.82 14.03,59.82 12.45,61.4 12.45,62.54 12.39,62.61 12.38,62.61 12.28,62.67 12.37,63.32 11.91,63.61 11.75,63.61 11.55,63.57 11.38,63.44 11.36,63.43 11.29,63.43 11.29,63.54 11.63,63.89 13.21,63.89
Net_9849 on TOP_-MB (solid shape): 153.37,65.77 153.39,65.77 153.68,65.48 153.68,65.24 153.73,65.19 154.86,64.06 154.86,64.06 155.1,63.82 155.1,63.36 155.85,62.61 156.35,62.61 156.51,62.45 156.51,61.88 156.6,61.79 156.6,61.73 157.12,61.21 157.12,60.77 157.04,60.69 156.88,60.69 156.75,60.55 156.36,60.55 156.01,60.9 156.01,61.76 155.71,62.06 155.26,62.06 154.62,62.7 154.62,63.09 154.48,63.22 154.48,63.23 154.42,63.31 154.34,63.37 154.33,63.37 153.14,64.57 153.13,64.58 153.05,64.72 152.9,64.81 152.89,64.81 152.16,65.54 152.16,65.87 152.67,66.38 152.77,66.38
Net_9850 on TOP_-MB (solid shape): 69.27,64.07 69.3,64.08 69.33,64.08 69.36,64.08 69.38,64.06 69.4,64.04 69.42,64.02 69.43,63.99 69.43,63.98 69.43,62.96 69.55,62.84 70.42,62.84 70.52,62.73 70.52,61.44 70.39,61.31 69.76,61.31 69.27,60.83 68.26,60.83 67.98,60.55 61.88,60.55 61.68,60.75 67.88,60.75 67.88,61 67.63,61 67.63,60.75 61.68,60.75 61.63,60.81 61.63,61.23 66.66,61.23 66.66,61.49 67.32,61.49 67.32,61.23 67.58,61.23 67.88,61.54 68.8,61.54 68.8,61.79 68.54,61.79 68.54,61.54 67.88,61.54 67.88,61.79 67.63,61.79 67.32,61.49 66.05,61.49 66.05,61.23 65.39,61.23 65.39,61.49 64.78,61.49 64.78,61.23 64.12,61.23 64.12,61.49 63.51,61.49 63.51,61.23 62.85,61.23 62.85,61.49 62.24,61.49 62.24,61.23 61.63,61.23 61.63,61.95 61.66,61.98 70.38,61.98 70.38,62.24 70.13,62.24 70.13,61.98 69.6,61.98 69.6,62.24 69.34,62.24 69.34,61.98 61.66,61.98 61.88,62.2 61.93,62.2 62.82,63.09 68.57,63.09 68.77,63.29 68.77,64.01 69.14,64.01 69.16,64.01 69.2,64.02 69.24,64.04
Net_9851 on TOP_-MB (solid shape): 151.68,64.15 152.06,64.15 152.63,63.57 152.63,63.2 151.65,62.22 151.65,61.84 150.89,61.08 150.4,61.08 149.71,61.77 150.92,61.77 151.1,61.59 151.28,61.77 151.1,61.95 150.92,61.77 149.71,61.77 149.33,62.16 149.33,62.33 150.37,62.33 150.55,62.15 150.73,62.33 150.55,62.51 150.37,62.33 149.33,62.33 149.33,62.57 149.47,62.57 149.65,62.39 149.83,62.57 149.65,62.75 149.47,62.57 149.33,62.57 149.33,62.77 149.33,62.78 149.33,62.93 149.83,62.93 150.01,62.75 150.19,62.93 150.07,63.04 151.09,63.04 151.26,62.87 151.44,63.04 151.26,63.22 151.09,63.04 150.07,63.04 150.01,63.11 149.83,62.93 149.33,62.93 149.33,63.14 149.52,63.33 149.53,63.34 149.55,63.38 149.57,63.41 149.58,63.45 149.57,63.49 149.57,63.53 149.69,63.66 149.69,64.51 150.39,65.2 150.63,65.2
Net_9852 on TOP_-MB (solid shape): 129.02,62.52 129.02,62.23 128.91,62.12 128.59,62.12 128.59,62.03 128.12,61.56 127.11,61.56 127.03,61.64 127.03,61.95 127.1,62.02 127.98,62.02 128.59,62.64 128.9,62.64
Net_9853 on TOP_-MB (solid shape): 154.5,68.22 154.61,68.22 155.24,67.6 155.2,67.56 155.2,66.6 159.32,62.48 159.32,62.26 159.1,62.04 158.47,62.04 157.33,63.17 157.32,63.21 157.29,63.25 157.26,63.29 157.23,63.33 157.19,63.36 157.14,63.38 157.11,63.39 155.86,64.64 155.85,64.67 155.82,64.71 155.79,64.75 155.75,64.78 155.71,64.81 155.68,64.82 155.16,65.34 155.53,65.34 155.71,65.16 155.89,65.34 155.71,65.52 155.53,65.34 155.16,65.34 154.67,65.83 154.67,65.99 154.89,65.99 155.07,65.81 155.25,65.99 155.07,66.17 154.89,65.99 154.67,65.99 154.67,66.27 154.57,66.37 154.57,66.5 154.26,66.81 154.45,66.81 154.63,66.63 154.81,66.81 154.63,66.99 154.45,66.81 154.26,66.81 153.42,67.65 153.62,67.65 153.8,67.47 153.8,67.46 153.98,67.28 154.16,67.46 153.98,67.64 153.98,67.65 153.8,67.83 153.62,67.65 153.42,67.65 153.13,67.94 153.13,68.42 153.54,68.83 153.9,68.83
Net_9854 on TOP_-MB (solid shape): 106.39,63.58 106.39,63 106.29,62.9 106.24,62.89 106.18,62.87 106.12,62.85 106.07,62.81 106.05,62.79 105.3,62.79 105.15,62.94 105.97,62.94 105.97,63.2 105.71,63.2 105.71,62.94 105.15,62.94 105.12,62.97 105.12,63.18 105.4,63.45 105.63,63.45 105.83,63.66 106.31,63.66
Net_9855 on TOP_-MB (solid shape): outline of 140 points within 43.05,62.92 48.73,67.11
Net_9856 on TOP_-MB (solid shape): 156.12,70.04 156.12,69.61 156.09,69.58 156.09,69.47 156.08,69.44 156.08,69.39 156.09,69.36 156.09,69.12 156.89,68.32 156.94,68.32 157.04,68.23 157.31,68.23 157.85,67.69 157.85,67.23 157.9,67.19 157.9,67.14 158.29,66.76 158.33,66.76 159.29,65.79 159.41,65.79 159.52,65.68 159.54,65.66 159.58,65.61 159.61,65.59 160.24,64.96 160.26,64.93 160.3,64.88 160.35,64.84 160.38,64.82 160.78,64.42 160.78,63.66 160.6,63.48 160.28,63.48 157.11,66.64 157.11,66.85 156.93,67.03 157.21,67.03 157.39,66.85 157.57,67.03 157.39,67.21 157.21,67.03 156.93,67.03 156.43,67.53 156.43,67.68 156.57,67.68 156.74,67.5 156.92,67.68 156.74,67.86 156.57,67.68 156.43,67.68 156.43,67.7 156.41,67.71 156.41,67.79 155.31,68.89 155.31,69.21 154.87,69.65 154.87,70.04 155.15,70.33 155.17,70.33 155.31,70.47 155.69,70.47
Net_9857 on TOP_-MB (solid shape): outline of 101 points within 19.37,64.27 22.52,67.11
Net_9858 on TOP_-MB (solid shape): 45.97,68.52 45.97,67.54 45.56,67.12 44.44,67.12 44.23,67.33 44.18,67.4 44.18,68.14 44.67,68.14 45.04,67.88 45.29,67.88 45.29,68.13 44.92,68.39 44.67,68.39 44.67,68.14 44.24,68.14 44.24,68.67 44.44,68.87 45.62,68.87
Net_9859 on TOP_-MB (solid shape): 50.19,69.33 50.19,68.67 50.19,68.67 50.19,67.88 50.01,67.7 48.48,67.7 48.11,67.33 47.25,67.33 47.09,67.49 47.09,67.61 46.98,67.72 47.8,67.72 47.8,67.98 47.55,67.98 47.55,67.72 46.98,67.72 46.8,67.9 46.8,68.52 46.65,68.67 47.99,68.67 48.02,68.64 49.59,68.64 49.59,68.9 49.34,68.9 49.34,68.64 49.09,68.64 49.09,68.9 48.53,68.9 48.53,68.64 48.27,68.64 48.27,68.9 48.02,68.9 47.99,68.92 47.74,68.92 47.74,68.67 47.49,68.67 47.49,68.92 46.93,68.92 46.93,68.67 46.65,68.67 46.5,68.82 46.5,69.18 46.76,69.44 50.07,69.44
Net_9860 on TOP_-MB (solid shape): outline of 333 points within 154.18,67.76 160.42,85.26
Net_9861 on TOP_-MB (solid shape): 33.69,71.84 33.69,70.57 33.65,70.53 33.65,69.54 33.38,69.26 33.36,69.26 33.2,69.16 33.1,69 33.1,68.98 32.42,68.31 32.02,68.31 31.03,68.31 30.93,68.41 30.93,70.19 30.99,70.25 31.24,70.25 31.38,70.4 31.38,70.85 32.08,71.55 32.08,71.56 32.16,71.63 32.16,72.13 32.32,72.29 33.24,72.29
Net_9862 on TOP_-MB (solid shape): 28.04,76.72 28.04,73.99 28.15,73.88 28.15,71.61 30.52,71.61 30.62,71.52 30.62,71.27 30.59,71.27 30.59,70.36 30.62,70.36 30.62,68.94 29.99,68.31 29.43,68.31 29.43,68.33 28.44,68.33 28.23,68.53 28.23,68.69 28.21,68.71 28.23,68.74 28.25,68.94 28.18,69.12 28.18,69.4 27.78,69.8 27.78,69.8 27.67,69.91 27.63,69.98 27.63,70.15 27.64,70.16 27.67,70.22 27.68,70.28 27.68,70.66 27.67,70.72 27.64,70.78 27.63,70.79 27.63,70.84 27.55,70.92 27.55,70.93 27.31,71.18 27.31,71.2 27.22,71.48 26.95,71.61 26.88,71.65 26.85,71.72 26.85,71.8 26.83,71.88 26.83,72.24 26.93,72.69 26.61,73.02 26.6,73.02 26.16,73.46 26.16,73.79 26.17,73.8 26.21,73.95 26.17,74.09 26.16,74.1 26.16,76.65 26.41,76.9 27.35,76.9 27.35,76.95 27.81,76.95
Net_9863 on TOP_-MB (solid shape): 63.94,74.79 63.94,74 63.94,73.98 63.89,73.83 63.94,73.67 63.94,73.66 63.94,69.57 63.3,68.93 63.29,68.93 63.25,68.88 62.52,68.88 62.32,69.08 62.32,69.66 62.48,69.81 62.48,73.52 62.72,73.76 62.72,74.93 63.08,75.3 63.43,75.3
Net_9864 on TOP_-MB (solid shape): 23.79,73.44 23.79,71.76 23.63,71.61 23.63,70.69 23.3,70.36 22.79,70.36 22.77,70.41 22.75,70.44 22.73,70.47 22.69,70.49 22.66,70.5 22.62,70.51 22.6,70.51 22.22,70.51 22.21,70.51 22.17,70.5 22.13,70.49 22.1,70.47 22.07,70.44 22.05,70.41 22.04,70.38 21.76,70.1 21.27,70.1 21.24,70.13 21.24,71.07 22.8,71.07 22.8,71.32 22.54,71.32 22.54,71.07 22.29,71.07 22.29,71.32 22.03,71.32 22.03,71.07 21.24,71.07 21.24,71.23 21.9,71.89 21.9,73.25 22.16,73.51 23.71,73.51
Net_9865 on TOP_-MB (solid shape): outline of 107 points within 23.76,70.24 26.82,73.51
Net_9866 on TOP_-MB (solid shape): 39.67,72.61 39.67,71.71 40.06,71.32 40.79,71.32 40.89,71.23 40.89,70.67 40.64,70.42 39.05,70.42 38.88,70.59 38.88,72.06 39.02,72.2 39.02,72.62 39.12,72.72 39.56,72.72
Net_9867 on TOP_-MB (solid shape): 9.05,73.08 9.05,72.73 9.29,72.49 9.29,72.08 9.29,72.08 9.29,71.75 8.64,71.1 8.12,71.1 8.05,71.17 8.05,72.16 8.5,72.61 8.5,73.08 8.6,73.18 8.94,73.18
Net_9868 on TOP_-MB (solid shape): 29.15,79.41 29.15,78.87 29.17,78.85 29.17,78.41 29.58,78.01 30.46,78.01 30.61,77.85 30.61,77.71 30.82,77.5 30.82,74.85 31.64,74.03 31.64,73.43 31.63,73.41 31.63,73.36 31.63,73.31 31.64,73.28 31.64,71.95 31.47,71.79 28.38,71.79 28.33,71.83 28.33,73.95 28.17,74.11 28.17,76.77 28.14,76.79 28.14,77.83 27.82,78.15 27.48,78.15 27.34,78.29 26.4,78.29 26.33,78.36 27.71,78.36 27.71,78.61 27.46,78.61 27.46,78.36 26.33,78.36 26.25,78.44 26.25,78.86 28.73,78.86 28.73,79.12 28.22,79.12 28.22,78.86 26.25,78.86 26.25,78.9 26.3,78.95 27.57,78.95 27.77,79.15 27.77,79.38 27.88,79.48 29.07,79.48
Net_9869 on TOP_-MB (solid shape): 37.55,75.62 37.05,75.11 37.05,72.95 36.18,72.09 33.63,72.09 33.6,72.11 33.29,72.42 33.13,72.42 33.04,72.51 33.06,72.57 33.07,72.61 33.08,72.66 33.07,72.71 33.06,72.76 33.04,72.8 33.02,72.84 32.99,72.88 32.95,72.91 32.91,72.93 32.87,72.95 32.82,72.96 32.77,72.97 32.72,72.96 32.62,73.07 32.62,73.73 32.6,73.75 32.6,74.2 33.34,74.94 33.81,74.94 34.02,74.73 35.52,74.73 36.03,75.24 36.03,75.53 37.16,75.53 37.16,75.79 36.65,75.79 36.65,75.53 36.03,75.53 36.03,75.87 36.28,76.13 37.55,76.13
Net_9870 on TOP_-MB (solid shape): 25.16,78.02 25.22,78 25.28,77.99 25.34,77.99 25.4,78 25.46,78.02 25.49,78.03 25.78,78.03 26.06,77.76 26.06,76.73 26.04,76.7 26.04,73.36 25.7,73.02 25.53,73.02 25.5,72.99 25.5,72.98 25.34,72.83 25.31,72.8 25.26,72.76 25.08,72.57 25.08,72.29 25.01,72.22 24.52,72.22 24.47,72.27 24.47,74.03 23.81,74.69 23.61,74.69 22.85,75.45 23.39,75.45 23.39,75.71 23.14,75.71 23.14,75.45 22.85,75.45 22.66,75.64 22.66,75.97 22.85,76.17 23.26,76.17 23.42,76.32 23.42,77.89 23.57,78.03 25.13,78.03
Net_9871 on TOP_-MB (solid shape): 41.34,79.68 41.4,79.67 41.46,79.68 41.5,79.68 42.35,79.68 42.41,79.63 42.41,79.51 42.56,79.35 42.56,78.24 43.27,77.53 43.27,77.14 43.17,77.04 41.82,77.04 39.69,74.91 39.69,74.12 39.64,74.07 39.64,73.03 39.59,72.98 37.5,72.98 37.43,73.06 37.43,73.37 38.15,73.37 38.16,73.31 39.2,73.31 39.2,73.56 38.67,73.56 38.67,73.31 38.42,73.31 38.42,73.56 38.16,73.56 38.15,73.62 37.9,73.62 37.9,73.37 37.43,73.37 37.43,73.94 39.28,73.94 39.28,74.2 39.03,74.2 39.03,73.94 37.43,73.94 37.43,74.45 39.28,74.45 39.28,74.71 39.03,74.71 39.03,74.45 37.43,74.45 37.43,75.11 37.68,75.37 38.37,75.37 41.01,78.01 41.01,78.14 41.02,78.14 41.02,79.51 41.03,79.55 41.05,79.61 41.06,79.68 41.3,79.68
Net_9872 on TOP_-MB (solid shape): outline of 85 points within 29.99,74.99 33.79,82.64
Net_9873 on TOP_-MB (solid shape): 38.19,79.81 38.19,77.65 37.93,77.4 37.93,76.51 37.81,76.38 36.29,76.38 35.98,76.07 35.98,76 35.9,75.93 35.9,75.29 35.6,74.99 34.51,74.99 34.28,75.22 34.28,76.75 37.66,76.75 37.66,77.01 37.41,77.01 37.41,76.75 37.16,76.75 37.16,77.01 36.65,77.01 36.65,76.75 36.39,76.75 36.39,77.01 36.14,77.01 36.14,76.75 34.28,76.75 34.28,78.03 33.86,78.44 33.33,78.44 33.24,78.54 33.24,80.83 33.87,81.46 36.54,81.46
Net_9874 on TOP_-MB (solid shape): 39.2,80.83 39.2,80.7 39.33,80.57 39.76,80.57 39.97,80.37 39.97,77.2 38.77,76 38.37,76 38.19,76.18 38.19,77.4 38.52,77.73 38.52,79.71 38.39,79.84 38.39,80.24 38.24,80.4 37.93,80.4 37.76,80.57 37.76,80.93 37.87,81.04 38.99,81.04
Net_9875 on TOP_-MB (solid shape): 61.46,78.73 61.48,78.71 61.54,78.69 61.59,78.67 61.64,78.67 61.7,78.67 61.76,78.67 61.81,78.69 61.86,78.71 61.88,78.73 62.11,78.73 62.15,78.71 62.32,78.53 62.32,77.8 61.9,77.38 61.05,77.38 61.04,77.4 61,77.44 60.95,77.47 60.91,77.5 60.86,77.52 60.8,77.53 60.75,77.54 60.69,77.53 60.64,77.52 60.59,77.5 60.54,77.48 60.49,77.45 60.46,77.41 60.42,77.36 60.39,77.29 60.37,77.24 60.36,77.18 60.36,77.13 60.37,77.07 60.39,77.01 60.4,76.98 60.4,76.93 60.25,76.78 59.71,76.78 59.37,77.12 59.91,77.12 59.91,77.37 59.65,77.37 59.65,77.12 59.37,77.12 59.2,77.29 59.2,78.53 59.39,78.73
Net_9876 on TOP_-MB (solid shape): outline of 101 points within 75.75,77.09 90.45,79.19
Net_9877 on TOP_-MB (solid shape): 111.1,79.38 111.1,78.49 110.86,78.2 110.93,77.83 110.96,77.8 110.86,77.69 107.7,77.69 107.3,78.09 107.3,79.36 107.55,79.6 108.98,79.6 108.99,79.61 110.87,79.61
Net_9878 on TOP_-MB (solid shape): outline of 142 points within 97.9,78.28 106.53,85.84
Net_9879 on TOP_-MB (solid shape): 61.08,80.92 61.09,80.93 62.56,80.93 62.92,80.56 62.92,80.02 62.85,79.95 62.85,79.6 62.64,79.39 62.5,79.39 62.46,79.4 62.41,79.42 62.35,79.43 62.29,79.43 62.23,79.42 62.18,79.4 62.14,79.39 61.85,79.39 61.81,79.4 61.76,79.42 61.7,79.43 61.64,79.43 61.59,79.42 61.53,79.4 61.5,79.39 61.39,79.39 61.03,79.03 59.41,79.03 58.98,78.61 58.14,78.61 57.97,78.77 57.97,79.37 59.08,79.37 59.08,79.63 58.83,79.63 58.83,79.37 57.97,79.37 57.97,79.52 58.71,80.27 59.49,80.27 59.52,80.3 60.84,80.3 60.84,80.55 60.59,80.55 60.59,80.3 59.52,80.3 59.73,80.5 59.73,81.13 59.93,81.33 60.67,81.33
Net_9880 on TOP_-MB (solid shape): outline of 859 points within 166.52,79.13 178.41,86.64
Net_9881 on TOP_-MB (solid shape): outline of 744 points within 179.61,79.1 187.56,86.03
Net_9882 on TOP_-MB (solid shape): 41.62,82.22 41.78,82.22 41.87,82.13 41.87,80.83 41.74,80.7 41.35,80.7 40.93,80.29 40.93,79.79 40.93,79.79 40.93,79.73 40.89,79.7 40.89,79.34 40.81,79.26 40.36,79.26 40.22,79.39 40.22,80.26 40.09,80.39 40.09,80.67 40.7,80.67 40.7,80.93 40.45,80.93 40.45,80.67 40.09,80.67 40.09,81.18 40.7,81.18 40.7,81.71 40.45,81.71 40.45,81.18 40.09,81.18 40.09,82.07 40.14,82.12 40.73,82.12 40.83,82.22 41.62,82.22
Net_9883 on TOP_-MB (solid shape): outline of 119 points within 67.65,79.76 97.02,86.29
Net_9884 on TOP_-MB (solid shape): 111.81,82.51 111.81,80.41 111.63,80.23 109.3,80.23 108.8,79.74 108.11,79.74 107.96,79.89 107.96,80.79 108.32,80.79 108.62,80.53 108.87,80.53 108.87,80.78 108.57,81.04 108.32,81.04 108.32,80.79 107.96,80.79 107.96,81.29 108.57,81.29 108.57,81.55 108.32,81.55 108.32,81.29 107.96,81.29 107.96,81.42 108.41,81.87 108.41,81.97 108.41,81.97 108.41,82.78 108.49,82.86 111.46,82.86
Net_9885 on TOP_-MB (solid shape): 44.27,82.11 45.31,82.11 45.35,82.07 45.35,81.77 45.3,81.72 44.97,81.72 44.88,81.62 44.86,81.62 44.8,81.56 44.8,81.1 44.76,81.03 44.74,80.96 44.73,80.95 44.59,80.81 44.58,80.8 44.36,80.68 44.27,80.46 44.26,80.44 44.04,80.22 43.72,80.22 43.64,80.3 43.64,80.31 43.53,80.53 43.31,80.64 43.29,80.64 43.24,80.7 42.79,80.7 42.78,80.71 42.65,80.74 42.52,80.73 42.49,80.72 42.38,80.83 42.38,82.16 42.45,82.22 44.16,82.22
Net_9886 on TOP_-MB (solid shape): outline of 153 points within 132.35,81.13 137.91,87.66
Net_9887 on TOP_-MB (solid shape): 101.24,85.18 101.24,84.02 101.49,83.77 101.49,83.48 101.54,83.43 101.55,83.35 101.55,81.44 101.43,81.32 97.87,81.32 97.34,81.84 97.34,83.07 97.91,83.07 97.91,83.33 97.65,83.33 97.65,83.07 97.34,83.07 97.34,83.58 97.91,83.58 97.91,83.83 100.83,83.83 100.83,84.08 100.57,84.08 100.57,83.83 97.91,83.83 97.91,83.84 97.65,83.84 97.65,83.58 97.34,83.58 97.34,84.34 100.83,84.34 100.83,84.59 100.57,84.59 100.57,84.34 97.34,84.34 97.34,86.3 97.7,86.66 99.75,86.66
Net_9888 on TOP_-MB (solid shape): 112.16,87.2 112.16,84.36 110.79,82.99 108.44,82.99 108.36,82.91 107.75,82.91 107.75,82.91 107.62,82.91 106.88,82.16 105.81,82.16 105.72,82.25 105.72,83.75 106.04,84.07 106.29,84.07 106.37,84.16 106.5,84.16 107.09,84.75 109.04,84.75 109.1,84.81 109.1,86.5 111.48,86.5 111.48,86.75 111.23,86.75 111.23,86.5 109.1,86.5 109.1,86.51 109.12,86.53 109.16,86.57 109.19,86.61 109.22,86.66 109.24,86.71 109.25,86.76 109.26,86.81 109.25,86.87 109.24,86.92 109.23,86.97 109.2,87.02 109.17,87.06 109.14,87.1 109.11,87.12 109.61,87.12 109.62,87.08 110.38,87.08 110.39,87.08 110.64,87.08 110.64,87.33 110.9,87.33 110.9,87.08 111.15,87.08 111.48,87.41 111.48,87.67 111.23,87.67 110.9,87.33 110.39,87.33 110.38,87.34 110.13,87.34 110.13,87.08 109.87,87.08 109.87,87.34 109.62,87.34 109.61,87.38 109.36,87.38 109.36,87.12 109.11,87.12 109.09,87.14 109.05,87.17 109,87.19 108.97,87.19 108.96,87.21 108.96,87.74 109.06,87.84 111.53,87.84
Net_9889 on TOP_-MB (solid shape): 104.84,84.18 104.84,83.11 104.69,82.96 103.14,82.96 102.98,83.11 102.98,84.21 103.09,84.31 104.71,84.31
Net_9890 on TOP_-MB (solid shape): outline of 174 points within 69.43,83.65 96.01,86.35
Net_9891 on TOP_-MB (solid shape): outline of 95 points within 137.17,83.8 140.44,86.28
Net_9892 on TOP_-MB (solid shape): 146.95,87.81 146.95,86.44 146.54,86.03 146.04,86.03 145.84,85.84 145.83,85.82 145.79,85.77 145.77,85.73 145.75,85.68 145.74,85.63 145.73,85.55 145.3,85.55 145.12,85.73 145.12,86.01 145.82,86.01 145.82,86.27 145.57,86.27 145.57,86.01 145.12,86.01 145.12,86.16 145.26,86.3 145.26,88.03 145.4,88.16 146.6,88.16
