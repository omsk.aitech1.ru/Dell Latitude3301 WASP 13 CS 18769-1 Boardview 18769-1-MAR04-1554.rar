# Allegro board 18769-1-MAR04-1554.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 109.78,46.56 109.72,46.62 109.72,47.03 109.81,47.11 109.97,47.11 110.13,47.28 110.13,47.64 110,47.77 109.76,47.77 109.56,47.98 109.56,48.14 109.8,48.38 109.98,48.38 110.36,48.75 110.36,48.88 110.57,49.09 112.59,49.09 112.95,49.46 112.95,49.82 113.02,49.89 113.66,49.89 114.03,49.53 114.03,48.51 113.86,48.35 113.6,48.35 113.4,48.55 110.8,48.55 110.5,48.24 110.5,47.92 110.8,47.63 111.91,47.63 112.01,47.53 112.01,46.76 111.8,46.56 ; 2 cut-outs
GND on TOP: 74.51,49.33 74.36,49.48 74.36,49.99 74.56,50.2 74.56,58.88 74.62,58.94 76.81,58.94 77.05,58.7 77.05,49.63 76.75,49.33 ; 15 cut-outs
GND on TOP: 188.23,16.72 188.07,16.87 188.07,17.53 187.79,17.81 187.79,18.34 187.9,18.45 188.23,18.45 188.35,18.32 188.99,18.32 189.17,18.14 189.17,16.77 189.12,16.72 ; 1 cut-out
GND on TOP: 103.14,82.96 102.98,83.11 102.98,84.21 103.09,84.31 104.71,84.31 104.84,84.18 104.84,83.11 104.69,82.96
GND on TOP: 109.22,9.12 108.93,9.41 108.93,9.66 109.25,9.98 110.82,9.98 112.19,11.35 113.06,11.35 113.19,11.22 113.19,9.6 112.71,9.12 ; 1 cut-out
GND on TOP: 134.53,38.23 134.42,38.34 134.42,38.75 134.58,38.91 134.58,39.84 134.6,39.86 134.6,47.02 135.92,48.34 135.92,49.17 136.8,50.04 137.4,50.04 137.99,49.46 138.32,49.46 138.49,49.3 138.49,48.49 138.22,48.23 136.46,48.23 135.16,46.93 135.16,42.97 135.52,42.61 135.96,42.61 136.16,42.41 136.16,39.66 135.37,38.87 135.37,38.45 135.15,38.23 ; 6 cut-outs
GND on TOP: 89.21,77.09 88.98,77.32 86.19,77.32 85.33,78.19 76.24,78.19 75.86,78.57 75.86,78.95 74.74,80.07 70.62,80.07 68.97,81.72 67.91,81.72 67.65,81.97 67.65,85.4 67.91,85.65 67.91,86.16 68.03,86.29 68.41,86.29 68.92,85.78 68.92,85.15 69.81,84.26 71.34,84.26 72.35,83.24 76.06,83.24 76.75,83.93 78.38,83.93 78.76,84.31 78.76,84.33 89.88,84.33 90.16,84.61 92.39,84.61 92.88,84.13 96.69,84.13 97.02,83.8 97.02,82.68 96.09,81.74 90.72,81.74 87.76,78.79 90.14,78.79 90.45,78.48 90.45,77.24 90.31,77.09 ; 18 cut-outs
GND on TOP: 64.52,4.21 64.3,4.43 64.3,5.35 64.21,5.45 63.33,5.45 63,5.77 63,6.5 63.18,6.68 64.5,6.68 64.64,6.53 72.02,6.53 72.68,7.19 73.74,7.19 74.4,6.53 78.12,6.53 79.08,5.58 79.08,5.16 78.69,4.78 73.5,4.78 73.43,4.7 65.39,4.7 64.9,4.21 ; 20 cut-outs
GND on TOP: 45.81,62.92 45.81,63.56 45.68,63.68 44.79,63.68 44.54,63.94 44.54,65.05 44.37,65.21 43.91,65.21 43.65,64.95 43.65,64.35 43.49,64.2 43.12,64.2 42.96,64.36 42.96,65 43.53,65.58 43.53,66.74 43.64,66.85 45.38,66.85 45.64,67.11 48.35,67.11 48.6,66.86 48.6,63.68 48.73,63.56 48.73,63.05 48.6,62.92 ; 12 cut-outs
GND on TOP: 142.9,32.69 142.16,33.42 142.16,33.43 141.59,33.43 141.29,33.74 141.29,36.96 141.62,37.29 142.3,37.29 142.43,37.42 142.43,38.89 141.67,39.65 141.67,42.3 141.87,42.5 147.94,42.5 148.12,42.32 148.12,41.25 147.82,40.95 147.82,38.61 148.45,37.98 148.45,34.7 148.12,34.37 147.41,34.37 147.15,34.12 147.15,33.61 146.98,33.43 145.86,33.43 145.11,32.69 ; 12 cut-outs
GND on TOP: 106.44,57 106.41,57.03 106.41,58.16 106.18,58.39 104.21,58.39 104.04,58.57 104.04,59.5 104.54,60 104.85,60 105.7,59.16 106.2,59.16 106.43,58.93 106.43,58.91 107.15,58.19 107.15,57.84 107.23,57.76 107.91,57.76 107.96,57.71 107.96,57.21 107.76,57 ; 3 cut-outs
GND on TOP: 128.89,6.77 128.13,7.53 127.71,7.53 127.56,7.68 127.56,8.67 127.2,9.03 126.78,9.03 126.66,9.15 126.66,9.44 126.86,9.64 127.14,9.64 127.45,9.32 131.16,9.32 131.76,8.73 131.76,8.71 132.15,8.32 132.15,8.31 132.39,8.08 133.58,8.08 134.1,7.55 134.33,7.55 134.33,7.55 134.44,7.55 134.46,7.56 135.45,7.56 135.62,7.39 135.62,6.9 135.49,6.77 ; 1 cut-out
GND on TOP: 181.47,41.65 180,43.12 173.24,43.12 171.64,44.72 171.64,48.82 172.08,49.26 172.77,49.26 173.29,48.73 173.29,45.38 174.44,44.23 181.55,44.23 181.8,43.99 181.8,43.31 182.52,42.59 183.38,42.59 183.51,42.73 183.51,43.62 183.49,43.64 183.49,43.95 183.79,44.24 188.19,44.24 188.3,44.12 188.3,42.16 187.79,41.65 ; 15 cut-outs
GND on TOP: 156.67,25.76 156.34,26.09 156.34,26.31 156.08,26.57 155.7,26.57 155.55,26.72 155.55,27.26 155.39,27.41 154.17,27.41 154.08,27.31 154.08,26.77 154.23,26.62 154.44,26.62 154.55,26.5 154.55,25.91 154.48,25.84 153.94,25.84 153.84,25.94 153.84,26.27 153.76,26.35 153.35,26.35 153.17,26.17 152.65,26.17 152.57,26.24 152.57,28.07 152.86,28.35 155.74,28.35 156.39,27.71 157.28,27.71 157.51,27.48 157.51,26.56 157.11,26.16 157.11,25.87 156.99,25.76 ; 7 cut-outs
GND on TOP: 20.79,59.01 20.62,59.18 20.62,60.21 19.74,61.09 18.99,61.09 18.85,61.23 18.85,61.74 19.46,62.34 20.36,62.34 21.57,61.14 21.57,60.27 21.88,59.96 22.17,59.96 22.23,59.89 22.23,59.33 21.91,59.01 ; 5 cut-outs
GND on TOP: 59.71,34.85 56.11,38.45 49.27,38.45 49.1,38.62 49.1,40.15 49.83,40.88 54.09,40.88 54.12,40.85 54.56,40.85 54.61,40.91 54.96,40.91 60.25,35.61 60.25,35.17 59.93,34.85 ; 6 cut-outs
GND on TOP: 80.43,48.7 80.11,49.02 80.11,50.19 80.56,50.63 80.56,51.47 80.84,51.74 80.84,55.5 81.08,55.75 81.08,55.79 81.17,55.87 81.17,57.82 81.28,57.93 81.28,58.83 81.39,58.95 83.48,58.95 83.83,58.59 83.83,57.51 83.83,51.6 84,51.44 84.46,51.44 84.88,51.03 84.88,50.6 84.62,50.34 84.25,50.34 84.06,50.15 84.06,49.44 83.7,49.08 81.85,49.08 81.71,49.22 81.26,49.22 80.75,48.7 ; 20 cut-outs
GND on TOP: 21.27,70.1 21.24,70.13 21.24,71.23 21.9,71.89 21.9,73.25 22.16,73.51 23.71,73.51 23.79,73.44 23.79,71.76 23.63,71.61 23.63,70.69 23.3,70.36 22.44,70.36 22.44,70.36 22.03,70.36 21.76,70.1 ; 2 cut-outs
GND on TOP: 78.19,59.24 77.3,60.13 77.3,60.68 77.05,60.93 74.84,60.93 74.71,61.06 73.69,61.06 73.31,61.44 71.91,61.44 71.79,61.57 71.79,62.91 71.61,63.09 71.61,64.08 71.69,64.16 72.72,64.16 72.93,64.36 74.2,64.36 74.71,63.85 74.71,62.46 75.6,61.57 77.64,61.57 77.94,61.27 77.94,60.89 78.45,60.38 78.45,59.36 78.32,59.24 ; 7 cut-outs
GND on TOP: outline of 157 points within 0.51,0.51 197.49,89.49 ; 60 cut-outs
GND on TOP: 145.92,26.94 145.69,27.17 145.69,27.5 145.55,27.64 144.74,27.64 144.42,27.96 144.42,28.45 144.36,28.51 143.82,28.51 143.72,28.61 143.72,29.53 143.95,29.76 146.34,29.76 146.45,29.65 146.45,27.08 146.31,26.94 ; 3 cut-outs
GND on TOP: 79.9,16.69 79.77,16.83 79.77,17.43 80.25,17.91 80.25,18.81 80.13,18.93 79.09,18.93 78.95,18.78 78.95,18.53 78.6,18.19 77.89,18.19 77.7,18.38 77.69,18.38 77.69,24.06 77.81,24.19 82.38,24.19 82.51,24.06 82.51,23.68 81.37,22.53 81.37,18.09 81.5,17.96 82,17.96 82.13,17.84 82.13,16.82 82,16.69 ; 18 cut-outs
GND on TOP: 105.45,49.28 105.17,49.57 105.17,49.99 105.11,50.05 104.63,50.05 104.45,49.87 104.45,49.54 104.28,49.38 103.73,49.38 103.48,49.63 103.48,50.06 103.27,50.27 103.27,50.61 103.25,50.62 103.25,50.69 103.07,50.87 102.87,50.87 102.86,50.86 102.6,50.86 102.5,50.96 102.5,51.98 102.75,52.23 103.15,52.23 103.24,52.14 103.24,51.68 103.39,51.52 104.95,51.52 105.12,51.36 105.12,51.04 105.38,50.78 105.38,50.47 105.68,50.17 106.34,50.17 106.39,50.12 106.39,49.35 106.32,49.28 ; 2 cut-outs
GND on TOP: 61.88,60.55 61.63,60.81 61.63,61.95 61.88,62.2 61.93,62.2 62.82,63.09 68.57,63.09 68.58,63.1 68.81,63.1 68.94,63.24 69.33,63.24 69.43,63.14 69.43,62.96 69.55,62.84 70.42,62.84 70.52,62.73 70.52,61.44 70.39,61.31 69.76,61.31 69.27,60.83 68.26,60.83 67.98,60.55 ; 9 cut-outs
GND on TOP: 37.43,22.12 36.01,23.55 36.01,26.88 36.92,27.79 36.96,27.79 38.6,29.44 38.6,30.85 38.82,31.07 38.8,31.09 38.8,34.45 38.82,34.45 39.08,34.7 39.97,34.7 41.47,36.2 42.53,36.2 42.84,35.9 42.84,29.52 43.41,28.95 44,28.95 44.13,28.82 44.13,25.12 41.13,22.12 ; 8 cut-outs
GND on BOTTOM: 120.37,33.18 119.69,33.87 119.69,38.08 117.73,40.03 116.8,40.03 115.33,41.5 115.33,45.1 116.71,46.47 120.6,46.47 123,44.08 123,40.42 123.73,39.69 123.73,39.26 123.53,39.05 120.91,39.05 120.03,38.18 120.03,37.73 120.18,37.58 120.46,37.58 120.5,37.54 120.5,37.13 121.5,36.14 123.26,36.14 123.58,35.82 123.58,33.39 123.37,33.18 ; 1 cut-out
GND on BOTTOM: 109.14,9.45 109,9.58 109,12.2 109.07,12.26 110.92,12.26 111.18,12.52 111.18,13.46 111.33,13.62 112.84,13.62 112.85,13.61 113.44,13.61 114.15,12.89 114.93,12.89 115.13,13.1 115.13,13.32 115.27,13.46 118.4,13.46 118.55,13.31 118.55,12.51 118.31,12.26 115.11,12.26 114.93,12.09 114.93,10.35 114.94,10.34 114.94,10.32 114.69,10.07 109.72,10.07 109.6,9.95 109.6,9.58 109.48,9.45
GND on BOTTOM: 111.78,71.13 111.78,71.39 111.93,71.54 112.23,71.54 112.9,70.87 112.9,70.54 112.9,70.53 112.37,70.53
GND on BOTTOM: 7.96,27.69 7.47,28.18 7.47,28.91 7.46,28.92 7.46,30.21 7.97,30.71 8.12,30.71 8.27,30.56 9.03,30.56 9.39,30.21 10.02,30.21 10.38,29.85 11.34,29.85 11.47,29.98 13.37,29.98 13.44,29.91 13.44,28.64 13.45,28.63 13.3,28.48 10.96,28.48 10.17,27.69 ; 3 cut-outs
GND on BOTTOM: 74.83,61.09 74.68,61.24 74.68,61.73 74.48,61.93 72.39,61.93 71.97,62.35 71.97,62.8 72.68,63.51 72.68,64.59 72.81,64.72 73.17,64.72 73.31,64.58 73.31,62.78 73.74,62.35 74.54,62.35 75.2,61.69 80.12,61.69 80.2,61.6 80.2,61.4 79.89,61.09
GND on BOTTOM: 32.98,42.65 32.93,42.7 32.93,43.64 33.44,44.15 33.44,44.5 33.33,44.61 33.06,44.61 33.03,44.59 33.03,44.48 32.85,44.3 32.19,44.3 32.12,44.38 32.12,44.89 32.13,44.9 32.13,45.55 32.68,46.1 32.68,46.56 32.64,46.6 32.63,46.6 32.32,46.91 32.32,49.15 32.55,49.38 33.26,49.38 33.26,49.38 33.94,49.38 34.71,50.14 37.15,50.14 37.17,50.12 37.17,48.24 36.77,47.83 36.77,46.84 36.89,46.72 38.49,46.72 38.54,46.66 38.54,45.8 38.06,45.32 36.66,45.32 36.61,45.37 36.49,45.37 35.73,44.61 35.73,42.83 35.55,42.65 ; 7 cut-outs
GND on BOTTOM: 177.3,33.08 177.18,33.2 177.18,33.58 177.41,33.81 178.65,33.81 178.7,33.86 178.7,34.93 178.35,35.29 178.35,36.33 178.65,36.63 178.65,37.7 178.55,37.8 178.55,38.05 178.7,38.21 179.18,38.21 179.21,38.18 179.21,37.7 179.06,37.55 179.06,36.68 179.54,36.2 179.54,33.23 179.39,33.08
GND on BOTTOM: 125.74,79.68 125.01,80.42 125.01,81.62 125.08,81.69 126.81,81.69 126.94,81.56 126.94,80.93 126.81,80.8 126.81,79.84 126.66,79.68
GND on BOTTOM: 147.19,51.32 145.98,52.53 144.39,52.53 144.15,52.77 144.15,53.26 144.4,53.51 144.69,53.51 145.11,53.93 145.11,54.18 141.06,58.23 141.06,59.31 142.92,61.17 143.43,61.17 144.57,62.31 145.43,62.31 145.61,62.13 145.61,61.88 145.42,61.69 145.15,61.69 145.13,61.71 145.02,61.71 143.74,60.43 143.74,57.95 145.6,56.09 145.99,56.09 148.48,53.6 148.73,53.6 150.29,52.05 150.29,51.53 150.09,51.32 ; 1 cut-out
GND on BOTTOM: 40.73,73.97 40.6,74.1 40.6,76.64 40.73,76.76 40.73,77.65 40.47,77.91 37.2,77.91 36.84,78.26 36.84,79.15 36.89,79.2 37.48,79.2 37.78,79.51 37.78,80.57 37.71,80.65 36.87,80.65 36.82,80.7 36.82,81.87 37,82.05 57.04,82.05 57.29,81.79 57.29,78.08 56.93,77.73 55.08,77.73 54.62,78.19 54.62,78.26 54.75,78.39 54.75,78.97 55.54,79.76 55.54,80.9 55,81.44 38.39,81.44 38.16,81.21 38.16,78.57 38.44,78.29 47.84,78.29 47.97,78.16 47.97,77.86 47.13,77.02 42.23,77.02 41.87,76.66 41.87,74.35 41.49,73.97 ; 4 cut-outs
GND on BOTTOM: 26.4,45.29 25.34,46.36 25.34,47.76 25.26,47.83 24.45,47.83 24.37,47.91 24.37,48.14 24.07,48.44 22.9,48.44 22.62,48.72 22.62,49.03 22.8,49.2 23.13,49.2 23.43,49.51 25.39,49.51 26.2,48.7 26.2,46.97 26.4,46.77 26.96,46.77 27.09,46.64 27.09,45.32 27.06,45.29 ; 1 cut-out
GND on BOTTOM: 26.78,60.46 26.73,60.51 26.73,60.99 26.84,61.09 26.84,61.26 26.68,61.41 26.12,61.41 25.72,61.01 25.4,61.01 25.24,61.17 24.96,61.17 24.82,61.31 24.82,61.66 24.95,61.79 25.14,61.79 25.29,61.93 25.29,62.31 24.86,62.74 24.86,62.98 25.14,63.26 25.64,63.26 25.96,62.94 27.18,62.94 27.32,62.79 27.32,61.55 27.53,61.34 27.73,61.34 27.79,61.28 27.79,61.18 28.02,60.95 28.19,60.95 28.26,60.88 28.26,60.62 28.1,60.46
GND on BOTTOM: 99.6,58.23 98.71,59.12 98.71,61.07 98.3,61.48 96.22,61.48 95.97,61.73 95.97,61.98 96.01,62.01 100.12,62.01 100.98,61.15 100.98,59.92 100.64,59.58 99.78,59.58 99.62,59.42 99.62,59.23 100.13,58.73 100.13,58.45 99.91,58.23
GND on BOTTOM: 95.28,62.84 94.77,63.35 94.01,63.35 93.76,63.09 87.79,63.09 87.28,63.6 87.28,64.36 87.66,64.74 88.3,64.11 89.57,64.11 90.08,64.62 90.84,64.62 91.09,64.36 91.73,64.36 92.11,64.74 92.49,64.74 93.12,64.11 93.76,64.11 94.39,64.74 95.16,64.74 95.41,64.49 95.41,64.24 95.92,63.73 95.92,63.35 95.41,62.84
GND on BOTTOM: 181.83,32.24 181.17,32.9 181.17,34.17 181.34,34.35 184.24,34.35 184.39,34.19 184.39,33.43 184.59,33.23 185.08,33.23 185.28,33.43 185.28,34.02 185.36,34.09 185.94,34.09 185.97,34.07 185.97,32.56 185.64,32.24
GND on BOTTOM: 82.49,0.9 82.24,1.15 82.24,2.03 82.37,2.16 83.5,2.16 83.71,2.36 95.32,2.36 97.22,4.27 97.22,12.11 97.97,12.86 98.74,12.86 98.87,12.74 98.87,8.86 104.21,3.52 108.29,3.52 110.1,1.71 110.1,1.23 109.77,0.9 ; 6 cut-outs
GND on BOTTOM: 143.28,32.53 142.91,32.91 142.91,32.91 142.41,33.41 141.72,33.41 141.44,33.69 141.44,42.17 142.51,43.24 147.21,43.24 147.59,42.85 147.59,39.1 148.5,38.18 148.5,33.51 148.4,33.41 145.29,33.41 144.41,32.53 ; 2 cut-outs
GND on BOTTOM: 110.86,64.79 110.84,64.81 110.84,65.06 110.88,65.1 110.96,65.1 111.11,65.25 111.11,65.64 111.24,65.77 111.24,65.95 111.8,66.51 112.21,66.51 112.33,66.39 112.33,66.19 112.69,65.83 112.69,65 112.58,64.89 112.15,64.89 112.05,64.79
GND on BOTTOM: 142.87,10.34 142.65,10.56 142.65,13.66 142.95,13.95 142.95,17.13 143.22,17.41 144.9,17.41 145.56,16.75 145.56,15.5 145.41,15.36 145.09,15.36 144.98,15.25 144.98,11.44 143.88,10.34 ; 2 cut-outs
GND on BOTTOM: outline of 166 points within 0.51,0.51 197.49,89.49 ; 50 cut-outs
GND on BOTTOM: 179.95,62.63 179.63,62.96 179.63,68.12 180.04,68.53 180.04,68.98 180.31,69.25 180.68,69.25 180.96,68.97 188.15,68.97 188.38,68.74 188.38,64.49 189.61,63.27 189.61,62.94 189.39,62.72 184.86,62.72 184.76,62.63 ; 20 cut-outs
GND on BOTTOM: 70.11,46.57 70.04,46.63 70.04,47.48 69.92,47.61 69.22,47.61 69.09,47.73 68.2,47.73 68.08,47.86 68.08,47.99 68.2,48.12 69.85,48.12 69.98,48.24 69.98,50.02 69.73,50.27 68.2,50.27 68.2,50.53 69.85,50.53 70.11,50.78 70.11,51.04 69.98,51.16 69.98,51.67 70.11,51.8 70.24,51.8 70.36,51.67 70.36,51.42 71.12,50.66 71.12,50.53 70.87,50.27 70.62,50.27 70.49,50.4 70.36,50.4 70.24,50.27 70.24,49.39 71.12,49.39 71.25,49.26 71.25,49 70.74,48.5 70.74,48.24 70.24,47.74 70.24,46.99 70.28,46.95 70.28,46.64 70.21,46.57
GND on BOTTOM: 66.33,63.8 66.23,63.9 66.23,65.55 66.96,66.29 69.1,66.29 69.2,66.19 69.2,65.91 69.4,65.71 69.53,65.71 69.58,65.65 69.58,65.4 69.53,65.35 68.84,65.35 68.03,64.54 68.03,63.85 67.98,63.8
GND on BOTTOM: 66.44,41.61 66.31,41.74 66.31,42 66.43,42.12 66.77,42.12 67.63,42.98 67.63,43.39 67.79,43.55 68.05,43.55 68.2,43.7 69.15,43.7 69.3,43.54 69.3,42.96 67.96,41.61
GND on BOTTOM: 32.17,56.95 32.02,57.1 32.02,60.91 32.12,61.02 32.35,61.02 32.5,61.17 32.5,61.85 32.35,62.01 32.09,62.01 31.99,62.11 31.99,62.51 32.09,62.62 33.06,62.62 33.41,62.26 34.18,62.26 34.3,62.13 34.3,61.3 34.47,61.13 34.47,59.05 34.23,58.81 33.21,58.81 32.98,58.58 32.98,57.05 32.88,56.95 ; 2 cut-outs
GND on BOTTOM: 149.98,68.08 149.73,68.33 149.73,69.08 149.57,69.24 149.24,69.24 149.12,69.11 149.12,68.44 148.96,68.29 148.96,68.21 148.63,68.21 147.98,68.86 147.98,71.31 151.89,75.22 153.27,75.22 154.36,74.14 154.88,74.14 155.33,74.59 155.94,74.59 156.59,73.94 156.59,72.27 154.29,69.97 153.48,69.97 152.58,69.07 152.58,68.34 152.31,68.08
GND on BOTTOM: 130.76,38.01 129.89,38.88 129.89,39.24 128.48,40.65 128.15,40.65 127.87,40.92 127.87,43.64 127.14,44.38 127.14,46.54 127.16,46.54 127.87,47.25 127.87,47.6 129.04,48.76 129.04,50 129.43,50.4 130.96,50.4 131.22,50.14 131.22,48.89 130.68,48.35 129.84,48.35 129.14,47.65 129.14,42.93 129.15,42.92 129.15,41.09 129.17,41.07 129.17,40.78 129.37,40.58 130.35,40.58 131.08,41.31 131.08,42.09 131.61,42.62 134.45,42.62 135.21,41.87 135.21,38.86 134.35,38.01 ; 6 cut-outs
GND on BOTTOM: 125.17,13.68 125,13.85 125,17.87 126.33,19.2 126.33,20.17 126.54,20.37 129.46,20.37 130.77,21.68 134.11,21.68 134.31,21.48 137.56,21.48 138.07,20.97 138.07,19.19 137.32,18.44 134.63,18.44 133.94,19.14 127.4,19.14 126.65,18.39 126.65,17.22 126.22,16.79 126.22,13.8 126.1,13.68
GND on BOTTOM: 75.06,78.41 74.81,78.67 74.81,79.94 74.94,80.06 74.94,80.32 74.62,80.63 73.18,80.63 71.46,82.35 67.91,82.35 67.78,82.48 67.78,83.16 67.93,83.32 68.49,83.32 68.57,83.39 68.57,84.49 68.39,84.66 67.81,84.66 67.73,84.74 67.73,85.83 67.81,85.91 69.18,85.91 69.23,85.86 69.23,84.74 69.61,84.36 72.02,84.36 72.27,84.11 72.27,84.1 72.52,83.85 72.52,83.37 72.65,83.24 75.95,83.24 76.46,82.73 78.87,82.73 78.87,84.89 79.92,85.94 79.92,88.05 80.08,88.21 80.73,88.21 81,87.94 81,86.9 81.49,86.41 85.86,86.41 86.24,86.03 86.24,82.1 84.08,79.94 84.08,79.05 83.45,78.41 ; 5 cut-outs
GND on BOTTOM: 125.4,85.79 125.31,85.88 125.31,86.29 125.4,86.38 125.4,87.03 125.25,87.18 124.07,87.18 123.95,87.3 123.95,87.86 124.02,87.93 125.28,87.93 125.42,88.06 126.07,88.06 126.12,88.02 126.12,86.98 125.93,86.78 125.93,85.85 125.86,85.79 ; 1 cut-out
GND on BOTTOM: 183.8,41.9 183.56,42.15 183.56,45 183.88,45.33 189.79,45.33 190.32,44.8 190.32,43.89 189.96,43.54 187.07,43.54 186.32,42.79 186.25,42.79 185.36,41.9 ; 11 cut-outs
GND on BOTTOM: 139.41,84.26 138.65,85.02 138.65,86.16 138.52,86.29 137.88,86.29 137.76,86.42 137.76,86.67 137.88,86.8 139.03,86.8 139.41,86.42 139.41,85.53 139.66,85.27 140.04,85.27 140.3,85.02 140.3,84.51 140.04,84.26
GND on BOTTOM: 128.05,86.42 127.9,86.57 127.9,88.22 128.21,88.52 131.13,88.52 131.36,88.3 131.36,86.52 131.25,86.42
GND on BOTTOM: 35.83,31.81 35.67,31.96 35.67,32.75 35.88,32.95 36.39,32.95 36.41,32.97 36.41,33.46 36.42,33.47 36.28,33.61 35.65,33.61 35.47,33.43 34,33.43 33.9,33.53 33.9,33.86 33.92,33.89 33.92,34.19 33.82,34.3 33.41,34.3 32.93,34.78 32.93,35.51 32.58,35.87 31.53,35.87 31.36,35.69 31.36,34.78 31.28,34.7 29.07,34.7 28.71,35.06 27.34,35.06 27.24,35.16 27.24,35.92 28.26,36.94 33.03,36.94 33.77,36.2 36.26,36.2 36.28,36.23 40.09,36.23 41.08,35.23 41.08,33.45 39.87,32.24 39.31,32.24 39.31,32.24 37.63,32.24 37.2,31.81 ; 5 cut-outs
GND on BOTTOM: 118.94,2.5 118.73,2.72 118.73,3.91 118.85,4.02 119.92,4.02 119.98,3.96 120.52,3.96 121.29,4.73 126.36,4.73 127.67,6.04 127.67,6.57 127.76,6.66 130.36,6.66 130.51,6.81 130.51,7.86 130.28,8.09 128.01,8.09 127.65,8.44 127.65,9.1 127.87,9.32 132.69,9.32 132.86,9.15 132.86,8.26 131.99,7.39 131.99,3.57 132.35,3.21 132.84,3.21 132.86,3.23 135.58,3.23 135.73,3.08 135.73,2.61 135.62,2.5
GND on BOTTOM: 19.09,33.66 18.45,34.3 17.87,34.3 17.74,34.42 17.74,36.66 16.93,37.47 16.93,38 17.03,38.11 17.41,38.11 17.78,37.74 19.61,37.74 19.88,38 19.88,38.61 20,38.74 19.98,38.77 20.66,38.77 21.58,37.85 21.7,37.85 21.78,37.77 21.78,37.17 21.37,36.76 21.17,36.76 21.04,36.63 21.04,35.92 21.32,35.64 21.48,35.64 21.6,35.51 21.6,34.96 20.31,33.66 ; 8 cut-outs
GND on BOTTOM: 40.91,48.32 40.88,48.34 40.88,49 40.6,49.28 39.61,49.28 39.54,49.36 39.54,50.68 39.59,50.73 40.88,50.73 41.01,50.86 41.01,53.55 41.62,54.16 41.62,57.21 41.87,57.46 45.05,57.46 45.81,56.7 46.7,56.7 47.08,56.32 47.08,53.01 46.95,52.89 45.17,52.89 44.16,53.9 43.65,53.9 43.01,53.27 43.01,49.46 42.89,49.33 42.13,49.33 42.05,49.41 42.05,50.12 42,50.17 41.06,50.17 40.93,50.04 40.93,49.23 41.19,48.98 41.19,48.34 41.16,48.32 ; 3 cut-outs
GND on BOTTOM: 76.95,8.49 75.09,10.34 74.76,10.34 74.51,10.6 74.51,11.65 74.42,11.73 74.08,11.73 73.95,11.87 73.95,12.43 74.4,12.88 77.16,12.88 77.48,12.56 77.48,8.64 77.34,8.49 ; 2 cut-outs
GND on BOTTOM: 90.89,12.76 90.64,13.01 90.64,13.9 91.02,14.28 96.48,14.28 97.12,13.64 97.12,13.01 96.86,12.76 ; 5 cut-outs
GND on BOTTOM: 50.15,71.76 50.08,71.84 50.08,73.23 50.23,73.39 50.23,75.49 50.58,75.85 51.65,75.85 51.83,75.67 51.83,75.44 52.01,75.27 52.92,75.27 53.12,75.06 53.12,74.76 52.84,74.48 52.08,74.48 51.97,74.36 51.97,72.74 50.99,71.76 ; 2 cut-outs
GND on BOTTOM: 35.62,0.51 35.62,1.4 35.16,2.29 34.18,2.46 34.18,2.62 34.43,2.88 35.37,2.88 36.18,3.69 61.91,3.69 62.22,3.99 62.22,5.44 61.58,6.08 61.58,8.62 61.76,8.79 62.06,8.79 62.14,8.72 62.14,8.69 64.96,8.69 65.27,8.39 65.27,7.68 64.96,7.37 64,7.37 63.91,7.28 63.91,4.91 64.74,4.07 64.74,3.31 65.08,2.97 65.08,1.25 65.52,0.82 65.52,0.51 ; 1 cut-out
GND on BOTTOM: 109.94,62.79 109.4,63.34 109.06,63.34 108.82,63.59 108.82,65.02 109.45,65.65 109.8,65.65 109.87,65.59 109.87,65.43 109.55,65.11 109.55,64.57 109.62,64.5 109.77,64.5 109.88,64.61 109.88,65.09 110.5,65.7 110.83,65.7 110.89,65.64 110.89,65.46 110.15,64.72 110.15,64.45 109.9,64.21 109.84,64.21 109.78,64.16 109.78,63.98 109.86,63.9 110.57,63.9 110.87,63.6 110.87,63.43 111.02,63.29 111.54,63.29 111.71,63.11 111.71,62.95 111.55,62.79
GND on BOTTOM: 84.04,5.77 83.79,6.03 83.79,6.52 83.92,6.66 86.32,6.66 86.7,7.04 87.72,7.04 88.1,6.66 88.86,6.66 89.12,6.91 89.12,7.55 89.24,7.68 90.39,7.68 90.64,7.42 90.64,6.41 90.39,6.15 87.97,6.15 87.72,5.9 86.45,5.9 86.32,5.77
GND on BOTTOM: 135.9,77.58 135.24,78.24 134.07,78.24 133.69,78.62 133.69,79.81 133.54,79.96 132.73,79.96 132.09,80.6 129.73,80.6 129.45,80.88 129.45,81.51 129.68,81.74 133.95,81.74 134.2,81.49 135.22,81.49 135.32,81.39 135.32,80.83 134.99,80.5 134.68,80.5 134.53,80.35 134.53,79.02 134.71,78.85 135.39,78.85 135.88,78.36 136.36,78.36 136.51,78.21 136.51,77.65 136.44,77.58 ; 5 cut-outs
GND on BOTTOM: 47.71,41.33 47.59,41.46 47.59,45.52 47.84,45.78 48.22,45.78 48.48,45.52 48.48,41.58 48.22,41.33
GND on BOTTOM: 25.51,63.98 25.38,64.1 25.38,65.25 25.64,65.5 26.14,65.5 26.65,64.99 26.65,64.49 26.52,64.36 26.4,64.36 26.27,64.23 26.27,64.1 26.14,63.98
GND on BOTTOM: 105.97,57.02 105.65,57.34 105.65,57.68 106,58.02 106,58.52 105.77,58.74 101.88,58.74 101.64,58.97 101.64,59.39 102.34,60.09 103.22,60.09 103.33,60.2 103.33,61.07 102.97,61.43 102.16,61.43 102.04,61.55 102.04,61.71 102.33,62.01 103.61,62.01 103.82,61.79 103.82,61.19 103.81,61.17 103.81,60.13 103.97,59.97 104.09,59.97 104.37,60.25 104.37,61.24 104.81,61.68 107.85,61.68 108.18,61.35 107.89,61.06 104.87,61.06 104.77,60.96 104.77,60.13 105.07,59.83 105.07,59.67 105.22,59.52 106.94,59.52 107.13,59.72 107.37,59.72 107.41,59.68 107.41,59.39 107.07,59.05 107.07,58.04 107.44,57.67 107.44,57.26 107.2,57.02
GND on BOTTOM: 70.62,63.7 70.37,63.96 70.37,65.93 70.48,66.05 70.74,66.05 70.99,65.8 70.99,63.8 70.89,63.7
GND on BOTTOM: 80.45,48.57 79.9,49.12 79.5,49.12 79.34,48.95 79.25,48.95 79.01,49.2 79.01,49.29 79.1,49.39 81.74,49.39 81.79,49.44 81.79,51.04 82.3,51.54 84.33,51.54 84.84,51.04 84.84,50.02 84.71,49.89 84.36,49.89 84.36,49.88 84.11,49.63 84.11,49.12 83.85,48.87 82.98,48.87 82.71,49.13 82.17,49.13 82.05,49 81.92,49 81.67,48.75 80.95,48.75 80.78,48.57
GND on BOTTOM: 8.5,35.66 8.42,35.74 8.42,36.04 8.52,36.14 8.99,36.14 9.5,36.65 9.92,36.65 10.41,36.16 10.41,35.78 10.29,35.66
GND on BOTTOM: 74.76,4.88 74.51,5.14 74.51,5.9 74.89,6.28 75.78,6.28 75.91,6.15 76.8,6.15 77.18,6.53 80.1,6.53 80.35,6.28 80.35,5.9 80.23,5.77 78.57,5.77 78.19,5.39 77.18,5.39 76.8,5.77 75.91,5.77 75.78,5.64 75.78,5.14 75.53,4.88
GND on BOTTOM: 118.42,86.44 117.66,87.2 116.64,87.2 116.09,87.76 112.62,87.76 112.11,87.25 111.8,87.25 111.55,87.5 109.6,87.5 109.23,87.88 109.23,88.52 109.43,88.72 116.23,88.72 116.43,88.51 116.43,88.04 116.75,87.72 119.4,87.72 120.32,88.64 120.76,88.64 120.9,88.5 120.9,88.02 120.61,87.74 120.61,86.57 120.49,86.44 ; 2 cut-outs
GND on BOTTOM: 93.9,81.83 93.13,82.61 88.73,82.61 88.61,82.73 88.61,83.24 88.53,83.32 88.53,86.11 88.66,86.24 89.93,86.24 90.11,86.06 90.11,84.82 90.16,84.76 92.72,84.76 93.26,84.23 95.75,84.23 95.95,84.03 95.95,83.29 94.49,81.83 ; 2 cut-outs
GND on BOTTOM: 157.08,30.62 156.9,30.8 156.9,31.93 157.32,32.35 157.32,32.6 157.31,32.61 157.31,36.56 156.55,37.32 154.76,37.32 154.47,37.61 154.47,38.54 154.6,38.67 159.79,38.67 159.79,38.67 161.87,38.67 162.2,38.34 162.2,36.36 162.55,36 162.55,31.64 162.55,31.64 162.06,31.15 159.1,31.15 158.99,31.25 158.99,32.23 158.7,32.52 158.3,32.52 157.77,31.99 157.77,30.73 157.67,30.62 ; 14 cut-outs
GND on BOTTOM: outline of 194 points within 67.19,43.11 84.84,53.45 ; 1 cut-out
GND on BOTTOM: 118.94,47.83 118.79,47.99 118.79,48.43 118.92,48.56 119.3,48.56 119.42,48.67 119.42,49.05 118.99,49.48 118.99,49.81 118.86,49.94 118.35,49.94 118.2,50.09 118.2,53.01 118.35,53.17 118.68,53.17 118.94,53.42 118.94,54.39 119.16,54.62 119.57,54.62 119.72,54.46 119.72,54.08 119.98,53.83 120.21,53.83 120.38,53.65 120.38,53.27 120.18,53.07 120.03,53.07 119.85,52.89 119.85,49.48 120.31,49.03 120.31,48.75 120.56,48.49 120.92,48.49 121.09,48.32 121.09,47.93 120.99,47.83 ; 8 cut-outs
GND on BOTTOM: 30.09,2.7 30.09,5.77 30.49,6.18 30.54,6.18 32.35,7.98 36.16,7.98 37.66,6.48 37.66,4.6 37.45,4.4 36.97,4.4 36.89,4.48 34.63,4.48 32.85,2.7
GND on L2GND: outline of 116 points within 0.51,0.51 197.49,89.49 ; 3 cut-outs
GND on L3: 106.53,48.8 106.53,46.78 106.36,46.61 105.83,46.61 105.49,46.95 105.49,48.8 104.85,49.44 102.29,49.44 101.73,50 101.73,50.82 102.25,51.34 103.98,51.34
GND on L3: 142.76,42.27 146.75,42.27 147.1,41.92 147.1,33.89 146.52,33.3 143.85,33.3 142.53,34.63 142.53,42.04
GND on L3: 67.98,85.7 68.62,85.7 69.23,85.1 69.23,84.59 69.43,84.38 76.16,84.38 77.33,85.55 85.61,85.55 87.11,84.05 87.11,81.72 83.58,78.19 71.08,78.19 67.45,81.82 67.45,85.17
GND on L3: 42.89,57.28 45.02,57.28 45.73,56.57 46.85,56.57 47.21,56.22 47.21,52.68 45.43,50.91 45.43,49.31 45.28,49.15 41.34,49.15 40.98,49.51 40.98,55.38
GND on L3: outline of 168 points within 0.51,0.51 197.49,89.49 ; 6 cut-outs
GND on L4VCC: outline of 116 points within 0.51,0.51 197.49,89.49 ; 3 cut-outs
GND on L5: 142.74,42.55 146.85,42.55 147.36,42.04 147.36,33.89 146.67,33.2 143.57,33.2 142.46,34.32 142.46,42.27
GND on L5: outline of 267 points within 0.51,0.51 197.49,89.49 ; 5 cut-outs
GND on L5: 42.94,57.51 45,57.51 45.83,56.67 46.7,56.67 46.98,56.39 46.98,52.81 43.4,49.23 41.77,49.23 40.93,50.07 40.93,55.5
GND on L6: 93.08,84.71 94.12,83.67 95.49,83.67 95.85,83.32 95.85,82.12 95.16,81.44 73.24,81.44 72.91,81.77 72.91,84.21 73.29,84.59 76.52,84.59 76.64,84.71
GND on L6: outline of 163 points within 0.51,0.51 197.49,89.49 ; 4 cut-outs
GND on L6: 142.3,42.63 146.62,42.63 147.21,42.04 147.21,33.89 146.44,33.13 143.24,33.13 142.23,34.14 142.23,42.55
GND on L6: 43.35,57.51 44.95,57.51 45.4,57.97 46.11,57.97 47.18,56.9 47.18,52.81 43.62,49.26 41.62,49.26 40.83,50.04 40.83,55
GND on L7VCC: outline of 116 points within 0.51,0.51 197.49,89.49 ; 2 cut-outs
GND on L8: outline of 162 points within 0.51,0.51 197.49,89.49 ; 5 cut-outs
GND on L8: 143.4,33.33 146.7,33.33 147.33,33.96 147.33,42.02 146.77,42.58 143.09,42.58 142.48,41.97 142.48,34.24
GND on L8: 114.64,7.09 117.82,7.09 120.28,4.63 124.14,4.63 124.42,4.35 124.42,3.36 124.24,3.18 117.84,3.18 115.99,5.03 110.12,5.03 108.37,3.28 93.15,3.28 91.83,4.6 91.83,5.87 93.43,7.47 101.38,7.47 101.74,7.12 114.62,7.12
GND on L8: 67.98,85.55 68.85,85.55 69.33,85.07 69.33,84.89 69.89,84.33 77.69,84.33 78.8,85.45 85.84,85.45 85.99,85.3 88.35,85.3 88.91,85.86 89.88,85.86 90.28,85.45 90.28,85.1 90.59,84.79 94.98,84.79 96.25,83.52 96.25,80.27 94.17,78.19 70.6,78.19 66.03,82.76 66.03,84.16 66.46,84.59 67.32,84.59 67.65,84.92 67.65,85.22
GND on L8: 6.16,18.22 9.11,18.22 10.71,16.62 10.71,8.82 11.52,8.01 11.52,6.28 11.06,5.82 10.6,5.82 9.33,7.09 9.33,8.18 5.78,11.74 5.78,17.84
GND on L9GND: outline of 116 points within 0.51,0.51 197.49,89.49 ; 1 cut-out
V3D3_STB on TOP: 183.02,9.68 182.89,9.81 182.89,10.21 182.75,10.35 182.75,11.56 182.8,11.61 183.16,11.61 183.5,11.27 183.5,9.81 183.38,9.68
0D6V_VREF_S0 on TOP: 61.56,14.66 57.75,18.47 45.43,18.47 45.17,18.72 45.17,20.25 58.38,20.25 59.78,21.65 59.78,22.28 60.54,23.04 60.54,23.55 60.67,23.68 62.57,23.68 62.7,23.55 62.7,23.17 59.91,20.38 59.91,18.34 61.81,16.44 77.85,16.44 77.85,16.45 79.07,17.67 79.07,18.61 79.22,18.76 79.88,18.76 80.01,18.63 80.01,17.84 79.65,17.48 79.65,16.61 79.82,16.44 95.85,16.44 97.88,18.47 97.88,21.16 97.07,21.97 97.07,22.84 97.13,22.9 98.11,22.9 98.27,22.74 98.27,21.9 98.41,21.77 100.29,21.77 100.42,21.65 100.42,21.26 100.29,21.14 99.4,21.14 98.64,20.38 98.64,18.09 97.37,16.82 97.37,16.57 97.5,16.44 114.01,16.44 114.13,16.31 114.13,14.79 114.01,14.66 ; 55 cut-outs
0D6V_VREF_S0 on BOTTOM: 28.32,37.16 28.13,37.35 28.13,38.32 28.5,38.69 29.34,38.69 29.38,38.64 29.38,37.23 29.31,37.16
0D6V_VREF_S0 on L5: 28.31,38.38 31.84,38.38 32.32,37.9 39.24,37.9 39.27,37.93 43.69,37.93 44.07,37.55 44.07,37.1 43.69,36.72 28.71,36.72 28,37.43 28,38.06
0D6V_VREF_S0 on L8: 60.23,21.1 60.23,20.65 59.76,20.18 45.56,20.18 44.51,21.23 44.51,22.62 44.09,23.04 44.06,23.04 43.98,23.13 43.98,30.72 42.8,31.9 42.8,37.59 43.09,37.88 43.9,37.88 44.22,37.55 44.22,31.91 45.02,31.11 45.02,28.86 46.02,27.86 46.02,22.42 47.08,21.37 57.6,21.37 57.89,21.66 59.67,21.66
1D0V_S5 on TOP: 105.81,82.16 105.72,82.25 105.72,83.75 106.12,84.16 106.5,84.16 107.09,84.75 109.04,84.75 109.1,84.81 109.1,87.07 108.96,87.21 108.96,87.74 109.06,87.84 111.53,87.84 112.16,87.2 112.16,84.36 110.71,82.91 107.62,82.91 106.88,82.16 ; 4 cut-outs
1D0V_S5 on TOP: 136.46,81.13 136.16,81.43 134.02,81.43 133.72,81.73 133.72,82.35 132.99,83.09 132.99,84.59 132.89,84.69 132.48,84.69 132.35,84.83 132.35,86.93 132.78,87.37 135.4,87.37 135.7,87.66 137.7,87.66 137.91,87.45 137.91,86.81 137.47,86.37 137.23,86.37 137.09,86.23 137.09,83.07 137.35,82.81 137.35,81.37 137.11,81.13 ; 8 cut-outs
1D0V_S5 on TOP: 98.84,52.68 98.58,52.93 98.58,53.31 98.71,53.44 99.6,53.44 99.98,53.82 99.98,54.08 99.73,54.33 99.73,55.38 100.21,55.85 104.3,55.85 104.55,55.6 104.55,55.22 104.43,55.09 104.43,52.93 104.3,52.81 102.14,52.81 102.01,52.93 102.01,53.95 101.89,54.08 101.51,54.08 101,53.57 100.24,53.57 99.98,53.31 99.98,52.93 99.73,52.68 ; 7 cut-outs
1D0V_S5 on TOP: 100.49,56.74 99.98,57.25 99.98,58.14 100.11,58.27 100.62,58.27 100.74,58.39 100.74,58.4 101.07,58.4 101.13,58.47 101.33,58.47 101.48,58.62 101.48,59.36 101.57,59.46 102.26,59.46 102.4,59.32 102.4,58.14 102.9,57.63 103.54,57.63 104.05,58.14 104.05,58.14 104.29,58.37 106.13,58.37 106.31,58.2 106.31,57.64 106.18,57.5 105.95,57.5 105.32,56.87 103.92,56.87 103.79,57 101.63,57 101.38,56.74 ; 5 cut-outs
1D0V_S5 on BOTTOM: 100.87,51.92 100.49,52.3 99.85,52.3 99.41,52.74 99.41,53.89 99.98,54.46 99.98,56.36 99.73,56.62 99.73,57.89 100.49,58.65 102.14,58.65 102.27,58.52 102.27,57.5 102.52,57.25 103.92,57.25 104.3,57.63 104.3,58.52 104.43,58.65 105.82,58.65 105.95,58.52 105.95,58.01 105.57,57.63 105.57,56.74 104.55,55.73 104.55,55.35 104.93,54.96 104.93,52.93 104.81,52.81 103.66,52.81 102.78,51.92
1D0V_S5 on BOTTOM: 112.75,79.92 112.5,80.17 111.95,80.17 109.35,82.76 109.35,85.93 109.21,86.08 109.21,86.57 110.01,87.37 116.99,87.37 117.24,87.12 117.3,87.12 117.82,86.61 117.82,80.48 117.26,79.92 ; 9 cut-outs
1D0V_S5 on L5: 100.41,58.48 103.84,58.48 104.77,57.55 106.26,57.55 106.5,57.31 106.5,55.26 104.02,52.78 100.17,52.78 99.99,52.97 99.99,54.52 99.23,55.28 99.23,57.3
1D0V_S5 on L6: 101.75,52.53 104.33,52.53 105.83,54.03 105.83,57.89 107.56,59.63 108.96,59.63 109.02,59.68 110.11,59.68 112.15,61.73 112.15,65.29 113.22,66.35 113.22,69.89 112.27,70.84 111.2,70.84 110.55,71.48 110.55,72.98 113.23,75.66 124.19,75.66 126.54,78 126.54,80.98 127.1,81.54 127.83,81.54 128.38,80.98 135.01,80.98 135.7,81.67 135.7,83.77 133.67,85.81 122.62,85.81 122.4,85.58 122.4,81.03 121.93,80.56 119.2,80.56 118.63,81.12 118.63,84.79 117.65,85.78 117.65,85.81 115.3,85.81 114.83,86.28 110.3,86.28 109.1,87.49 107.06,87.49 105.36,85.79 105.36,81.19 105.34,81.18 105.34,76.13 105.28,76.06 105.28,73.28 102.14,70.14 102.14,64.15 101.76,63.77 101.76,61.6 101.74,61.58 101.74,60.06 101.75,60.06 101.75,59.7 101.48,59.44 101.48,56.9 101.41,56.83 101.41,56.05 101.44,56.03 101.44,52.85
1D0V_S5 on L8: 100.52,55.84 104.28,55.84 104.4,55.72 104.4,53.3 103.79,52.69 99.35,52.69 99.17,52.88 99.17,54.01 100.21,55.06 100.21,55.53
1D0V_VCCPRIM_MPHY on TOP: 102.68,57.85 102.6,57.93 102.6,58.7 102.74,58.84 102.74,59.27 103.07,59.59 103.07,60.18 103.62,60.74 103.62,61.03 103.92,61.33 104.54,61.33 104.74,61.13 104.74,60.33 103.83,59.42 103.83,57.96 103.72,57.85
1D0V_VCCPRIM_MPHY on BOTTOM: 102.52,57.38 102.39,57.5 102.39,58.52 102.52,58.65 103.92,58.65 104.05,58.52 104.05,57.5 103.92,57.38
1D2V_S3 on TOP: outline of 145 points within 43.01,21.9 115.66,47.72 ; 157 cut-outs
1D2V_S3 on TOP: 33.13,35.73 32.8,36.07 32.8,36.65 32.95,36.8 34.22,36.8 34.22,36.8 34.67,36.8 35.1,36.36 35.1,35.94 34.9,35.73
1D2V_S3 on BOTTOM: 63.46,18.34 60.67,21.14 45.92,21.14 43.01,24.04 43.01,35.6 43.63,36.21 43.63,36.23 43.63,36.24 44.03,36.24 44.49,36.69 45.14,36.69 45.34,36.89 45.34,37.38 45.32,37.39 54.66,37.39 59.33,32.72 67.12,32.72 67.14,32.69 98.71,32.69 99.71,31.7 99.71,31.7 100.83,30.57 112.33,30.57 113.63,29.27 113.63,19.11 112.86,18.34 ; 2 cut-outs
1D2V_VCCSFR_OC on TOP: 97.36,35.74 97.36,36.56 97.42,36.61 97.42,44.86 96.27,46.01 96.27,49.59 96.57,49.89 97.14,49.89 97.19,49.84 98.11,49.84 98.27,49.68 98.27,49.47 97.95,49.15 97.74,49.15 97.63,49.04 97.63,45.5 98.07,45.07 98.07,36 97.81,35.74
1D8V_AON_S0 on TOP: 165.32,49.84 165.07,50.09 165.07,51.59 163.35,53.31 162.85,53.31 162.64,53.1 162.63,53.1 161.91,52.39 161.59,52.39 161.33,52.65 161.33,53.09 161.41,53.18 161.41,53.33 161.76,53.68 161.76,53.95 160.92,54.78 160.92,54.89 161.11,55.08 161.11,55.12 161.51,55.51 162.31,55.51 166.04,51.79 166.04,50 165.88,49.84
1D8V_AON_S0 on TOP: 158.71,57.17 157.4,58.48 157.4,59.94 157.96,60.5 158.15,60.5 158.54,60.11 158.54,59.36 159.06,58.84 159.22,58.84 159.63,58.43 159.63,57.99 159.77,57.85 159.77,57.56 159.63,57.42 159.22,57.42 158.98,57.17 ; 4 cut-outs
1D8V_AON_S0 on BOTTOM: 132.44,72.79 131.8,73.43 131.11,73.43 130.7,73.84 130.7,74.34 131.08,74.72 133.42,74.72 133.66,74.47 133.66,73.79 133.21,73.33 133.21,72.99 133.01,72.79 ; 3 cut-outs
1D8V_AON_S0 on BOTTOM: 138.42,78.41 138.3,78.53 138.3,79.59 138.29,79.6 138.29,79.68 138.43,79.82 139.76,79.82 139.91,79.67 139.91,79.24 139.78,79.11 139.53,79.11 139.4,78.98 139.4,78.53 139.28,78.41
1D8V_AON_S0 on L5: 159.45,58.15 161.3,58.15 165.9,53.55 165.9,49.99 165.52,49.61 165.16,49.61 159.22,55.55 159.22,57.92
1D8V_FBA_PLL_AVDD on L3: 161.42,68.17 161.78,68.17 162.89,67.06 162.89,66.02 164.12,64.79 164.12,64.07 162.84,62.79 162.84,60.25 162.48,59.89 161.89,59.89 161.68,60.11 161.68,60.71 161.88,60.91 161.88,65.93 161.17,66.64 161.17,67.92
1D8V_S3 on TOP: 75.78,18.22 75.27,18.72 75.27,24.19 75.4,24.31 76.42,24.31 77.43,23.3 77.43,18.34 77.3,18.22 ; 6 cut-outs
1D8V_S3 on TOP: 113.88,18.22 113.37,18.72 113.37,24.19 113.5,24.31 114.26,24.31 114.9,23.68 114.9,18.47 114.64,18.22
1D8V_S3 on TOP: 56.6,21.9 56.1,22.41 56.1,27.87 56.22,28 57.24,28 58.25,26.98 58.25,22.03 58.13,21.9 ; 3 cut-outs
1D8V_S3 on TOP: 44.54,25.2 44.28,25.46 44.28,28.63 44.41,28.76 45.17,28.76 46.06,27.87 46.06,25.33 45.94,25.2 ; 2 cut-outs
1D8V_S3 on TOP: 61.81,18.34 61.68,18.47 61.68,21.52 64.48,24.31 65.11,24.31 65.24,24.19 65.24,21.65 65.11,21.52 64.73,21.52 62.83,19.61 62.83,18.47 62.7,18.34 ; 3 cut-outs
1D8V_S3 on TOP: 100.93,18.34 100.8,18.47 100.8,22.15 102.96,24.31 103.21,24.31 103.34,24.19 103.34,21.65 102.2,20.5 102.2,18.47 102.07,18.34 ; 4 cut-outs
1D8V_S3 on TOP: 94.7,18.22 94.2,18.72 94.2,24.19 94.32,24.31 95.34,24.31 96.35,23.3 96.35,18.34 96.23,18.22 ; 3 cut-outs
1D8V_S3 on TOP: 81.75,18.34 81.62,18.47 81.62,22.53 83.4,24.31 84.04,24.31 84.16,24.19 84.16,21.65 83.02,20.5 83.02,18.47 82.89,18.34 ; 2 cut-outs
1D8V_S3 on L3: 44.34,24.16 44.34,30.31 44.35,30.32 44.35,30.95 44.62,31.22 45.48,31.22 45.68,31.02 45.68,30.61 45.35,30.28 45.35,28.28 45.76,27.87 45.76,26.12 45.71,26.07 45.71,24.92 47.94,22.69 57.16,22.69 57.34,22.87 58.18,22.87 58.61,22.43 58.61,21.85 58.05,21.29 47.21,21.29
1D8V_S3 on L5: 114.39,19.74 114.39,18.72 113.12,17.45 94.45,17.45 94.2,17.71 94.2,18.6 94.32,18.72 112.1,18.72 113.25,19.87 114.26,19.87
1D8V_S3 on L6: 89.88,19.11 90.13,18.85 102.07,18.85 102.2,18.72 102.2,17.07 102.15,17.03 59.7,17.03 56.1,20.63 56.1,22.08 56.58,22.56 57.98,22.56 59.02,21.52 60.41,21.52 62.83,19.11
1D8V_S5 on TOP: 25.64,45.12 25.03,45.73 22.6,45.73 22.34,45.46 20.66,45.46 20.03,46.09 19.48,46.09 19.46,46.07 18.15,46.07 17.5,46.72 17.5,47.1 17.5,47.1 17.5,47.37 17.71,47.58 18.2,47.58 18.44,47.34 18.47,47.34 18.85,46.96 20.53,46.96 21.07,46.43 21.62,46.43 21.8,46.61 25.75,46.61 25.76,46.6 27.76,46.6 28.04,46.88 28.04,47.03 28.18,47.17 28.65,47.17 29.01,46.81 29.01,45.69 28.44,45.12
1D8V_S5 on TOP: 166.29,23.33 165.83,23.79 165.83,24.43 165.42,24.84 165.42,25.47 165.54,25.59 166.66,25.59 166.78,25.47 166.78,24.75 166.67,24.65 166.67,24.2 166.85,24.02 166.85,23.45 166.73,23.33 ; 2 cut-outs
1D8V_S5 on TOP: 123.43,49.24 123.22,49.45 123.22,53.55 124.78,55.11 124.78,56.25 124.96,56.44 125.84,56.44 126.2,56.08 126.2,55.56 126.72,55.04 126.72,54.44 126.56,54.27 125.98,54.27 125.92,54.33 125.21,54.33 124.32,53.44 124.32,49.38 124.17,49.24 ; 2 cut-outs
1D8V_S5 on TOP: 162.4,20.75 162.09,21.05 162.09,25.4 162.67,25.97 163,25.97 163.29,25.68 163.29,23.63 163.22,23.55 163.22,23.16 163.24,23.14 163.24,22.9 163.34,22.8 163.34,21.02 163.07,20.75
1D8V_S5 on TOP: 34.9,17.03 33,18.92 33,22.15 32.5,22.65 32.5,26.86 32.99,27.34 33,27.34 33,32.29 32.39,32.9 32.39,34.61 31.49,35.52 31.49,37.23 30.18,38.54 30.18,39.68 31.1,40.6 31.1,41.85 30.62,42.33 30.62,43.71 31.78,44.87 31.78,46.45 32.09,46.76 32.76,46.76 33.14,46.39 33.14,44.21 32.75,43.83 32.75,42.51 32.17,41.93 32.17,40.63 31.89,40.35 31.89,40.03 31.17,39.31 31.17,38.73 32.64,37.26 32.64,36.19 33.14,35.68 33.49,35.68 34.42,34.75 34.42,34.4 35.15,33.68 35.15,24.93 34.85,24.63 34.85,24.63 34.01,23.8 34.01,21.33 33.99,21.31 33.99,19.31 35.13,18.18 36.18,18.18 36.5,17.85 36.5,17.41 36.12,17.03
1D8V_S5 on TOP: 8.12,71.1 8.05,71.17 8.05,72.16 8.5,72.61 8.5,73.08 8.6,73.18 8.94,73.18 9.05,73.08 9.05,72.73 9.29,72.49 9.29,71.75 8.64,71.1
1D8V_S5 on BOTTOM: 123.12,47.69 122.76,48.06 122.76,53.03 122.84,53.12 123.97,53.12 124.52,52.58 124.52,49.29 123.93,48.7 123.93,47.88 123.74,47.69 ; 6 cut-outs
1D8V_S5 on BOTTOM: 193.86,14 193.62,14.23 193.62,14.92 194.52,15.82 195.99,15.82 196.23,15.58 196.23,15.05 195.9,14.72 195.15,14.72 194.43,14
1D8V_S5 on BOTTOM: 35.32,17.35 35.17,17.51 35.17,17.94 35.34,18.12 37.45,18.12 37.58,17.99 37.58,17.45 37.48,17.35
1D8V_S5 on BOTTOM: 30.82,45.28 30.65,45.45 30.65,46.75 30.8,46.89 32.15,46.89 32.55,46.49 32.55,46.14 31.69,45.28
1D8V_S5 on L3: 162.78,26.34 165.9,26.34 167.32,27.76 169.98,27.76 170.71,27.04 170.71,25.38 170.59,25.26 169.96,25.26 169.82,25.4 169.82,26.52 169.57,26.77 168.35,26.77 166.45,24.87 165.49,24.87 165.18,25.18 162.59,25.18 162.31,25.46 162.31,25.87
1D8V_S5 on L5: 170.48,25.15 169.92,25.15 169.8,25.27 169.8,26.12 171.32,27.64 182.66,27.64 183.64,26.66 183.66,26.67 186.44,26.67 187.7,25.42 187.7,24.98 187.55,24.83 184.19,24.83 183.68,25.34 179.25,25.34 178.24,26.35 173.41,26.35 173.24,26.52 171.85,26.52
1D8V_S5 on L5: outline of 86 points within 44.88,13.35 163.25,29.33
1D8V_S5 on L5: 28.03,47.25 28.04,47.25 28.43,47.65 31.96,47.65 31.96,47.64 33.28,47.64 33.65,47.27 34.53,47.27 34.77,47.03 34.77,46.41 34.72,46.36 33.68,46.36 33.22,45.9 31.53,45.9 31.28,46.15 28.22,46.15 27.96,46.41 27.96,47.19
1D8V_S5 on L6: 36.58,17.35 36.42,17.35 36.24,17.17 35.86,17.17 35.53,17.5 35.53,18.31 35.68,18.46 35.69,18.46 35.69,18.62 36.47,19.41 36.47,22.87 34.87,24.47 34.87,32.28 34.22,32.94 34.22,36.47 32.85,37.83 32.85,40.26 35.28,42.68 35.28,45.71 34.8,46.19 34.23,46.19 33.86,46.56 33.86,46.94 33.86,46.94 34.28,47.36 35.36,47.36 36.39,46.32 36.39,42.13 36.17,41.91 36.17,39.08 37.12,38.13 37.12,24.18 39.5,21.8 39.5,19.27 40.31,18.46 45.33,18.46 45.78,18 45.78,17.62 45.54,17.37 36.59,17.37
1D8V_S5 on L6: 9.52,69.76 11,68.28 12.58,68.28 13.63,69.32 15.21,69.32 17.39,67.13 17.39,65.25 16.78,64.64 16.78,64.22 17.63,63.38 17.63,61.7 17.54,61.61 17.54,61.07 18.95,59.66 18.95,57.35 18.44,56.84 18.44,54.68 18.67,54.44 18.67,53.04 17.85,52.22 17.85,51.87 18.43,51.87 20.36,49.94 20.36,48.13 18.89,46.66 17.9,46.66 17.62,46.93 17.62,47.33 18.75,48.46 18.75,49.61 16.93,51.42 16.93,52.56 17.9,53.53 17.9,53.87 17.45,54.32 17.45,58.73 17.45,58.74 17.45,58.88 16.22,60.11 16.22,61.18 15.75,61.65 15.75,64.96 16.5,65.72 16.5,66.27 15.75,67.02 14.42,67.02 14.17,67.27 10.74,67.27 8.56,69.45 8.56,72.3 8.77,72.51 9.28,72.51 9.52,72.28
1D8V_S5 on L8: 132.56,28.42 132.56,28.05 132.78,27.83 133.7,27.83 134.2,28.33 134.2,30.11 132.2,32.11 132.2,36.69 128.56,40.32 128.56,46.56 127.73,47.4 126.64,47.4 125.56,48.47 125.56,48.97 124.5,50.03 123.37,50.03 123.23,49.89 123.23,49.07 124.17,48.12 124.34,48.12 126.54,45.93 126.54,41.01 130.94,36.61 130.94,31.88 132.69,30.14 132.69,28.55
1D8V_S5 on L8: 187.24,25.63 195.39,25.63 196.92,24.09 196.92,15.53 196.18,14.79 195.61,14.79 195.23,15.17 195.23,16.2 195.81,16.78 195.81,23.39 194.59,24.6 187.22,24.6 186.93,24.89 186.93,25.33
1D8V_VCCPRIM on TOP: 106.03,54.12 105.88,54.28 105.88,55.75 105.72,55.9 105.72,56.59 105.77,56.64 106.99,56.64 107.04,56.59 107.04,55.88 107.71,55.21 107.71,54.82 107.78,54.74 110.38,54.74 110.96,55.33 113.17,55.33 113.4,55.1 113.4,54.87 113.14,54.62 111.11,54.62 110.68,54.18 106.65,54.18 106.59,54.12 ; 1 cut-out
1D8V_VGA_PLL on TOP: 159.23,54.84 158.98,55.08 158.98,55.36 159.25,55.62 159.25,56.44 158.96,56.73 158.96,57.01 159.26,57.31 159.49,57.31 159.8,57.62 159.8,58.12 160.11,58.43 160.3,58.43 160.54,58.2 160.54,57.74 160.26,57.46 160.26,56.42 160.15,56.3 160.15,55.98 160.25,55.88 160.25,55.65 159.43,54.84 ; 1 cut-out
1D8V_VGA_PLL on TOP: 154.16,57.18 151.12,60.21 151.12,61.06 152.13,62.06 152.35,62.06 155.9,58.52 155.9,58.16 154.91,57.18 ; 6 cut-outs
1D8V_VGA_PLL on L8: 152.82,59.49 153.89,59.49 155.77,57.61 158.76,57.61 158.89,57.49 158.89,57.46 159.35,57 160.13,57 160.31,56.82 160.31,56.42 160.13,56.24 158.66,56.24 158.38,56.52 154.67,56.52 152.57,58.63 152.57,59.24
1D8V_VGA_S0 on TOP: 160.4,83.24 160.25,83 159.62,82.75 157.24,80.37 157.24,71.83 160.2,68.87 160.2,68.24 159.72,67.76 159.17,67.76 157.38,69.55 157.1,69.55 155.31,71.35 155.31,80.8 154.99,81.12 154.73,81.08 154.35,81.35 154.18,81.89 154.45,82.22 157.02,83.25 157.03,83.5 156.95,83.82 156.96,84 159.84,85.26 160.18,85.21 160.42,84.73 ; 11 cut-outs
1D8V_VGA_S0 on TOP: 150.4,61.08 149.33,62.16 149.33,62.77 149.33,62.78 149.33,63.29 149.69,63.66 149.69,64.51 150.39,65.2 150.69,65.2 151.69,64.2 152.09,64.2 152.73,63.56 152.73,63.3 151.65,62.22 151.65,61.84 150.89,61.08 ; 5 cut-outs
1D8V_VGA_S0 on BOTTOM: 149.62,63.73 149.16,64.19 149.06,64.19 148.96,64.29 148.96,64.5 153.74,69.28 153.74,69.8 153.9,69.95 154.42,69.95 156.68,72.22 156.68,77.37 154.7,79.35 154.7,80.55 156.02,81.87 156.02,83.67 156.38,84.03 159.81,84.03 160.08,83.76 160.08,83.76 160.08,82.94 157.72,80.57 157.72,78.06 157.24,77.58 157.24,72.27 157.49,72.01 157.49,70.9 156.93,70.34 156.04,70.34 154.14,68.43 154.14,67.65 150.23,63.73 ; 4 cut-outs
1D8V_VGA_S0 on L8: 149.84,64.32 151.09,64.32 156.51,69.74 156.51,76.13 158.01,77.63 158.01,81.96 157.58,82.4 152.72,82.4 150.84,80.52 146.74,80.52 145.89,79.67 145.89,79.08 146.3,78.67 147.52,78.67 148.24,79.39 151.34,79.39 152.94,80.99 155.1,80.99 155.26,80.83 155.26,77.91 153.47,76.13 153.47,71.96 148.83,67.33 148.83,65.32
1D35V_PWR on BOTTOM: 182.05,41.03 180.94,42.14 175.86,42.14 175.02,42.98 175.02,44.86 175.04,44.88 175.04,45.28 175.32,45.56 176.08,45.56 176.27,45.36 176.27,44.98 176.36,44.89 182.69,44.89 182.87,45.06 183.4,45.06 183.45,45.01 183.45,41.97 183.63,41.79 183.63,41.24 183.42,41.03 ; 9 cut-outs
1D35V_VGA_S0 on TOP: 183.79,79.1 182.87,80.03 180.77,80.03 179.61,81.19 179.61,83.17 180.43,83.98 180.43,85.17 181.29,86.03 185.38,86.03 187.23,84.19 187.23,81.11 187.56,80.78 187.56,79.39 187.27,79.1 ; 6 cut-outs
1D35V_VGA_S0 on TOP: outline of 118 points within 162.36,42.22 192.96,77.53 ; 22 cut-outs
1D35V_VGA_S0 on TOP: 172.68,79.13 171.89,79.92 171.89,80.92 171.94,80.97 171.94,81.17 168.19,84.91 166.95,84.91 166.52,85.34 166.52,86.26 166.91,86.64 177.48,86.64 177.79,86.33 177.79,84.11 178.41,83.5 178.41,80.29 177.25,79.13 ; 11 cut-outs
1D35V_VGA_S0 on BOTTOM: 187.5,84.3 187.9,81.95 192.29,57.56 192.29,47.53 190.21,45.45 183.3,45.45 183.02,45.17 176.72,45.17 176.31,45.58 175.87,45.58 175.22,46.22 175.22,62.11 176.85,63.73 176.85,67.8 170.76,73.88 170.79,73.91 170.79,74.89 172.3,76.4 172.3,79.05 171.1,80.25 171.09,80.25 167.93,83.41 167.93,86.03 168.24,86.34 185.46,86.34 186.15,86.32 187.37,85.1 187.5,84.3 ; 77 cut-outs
1D35V_VGA_S0 on BOTTOM: 160.24,58.81 160.11,58.93 160.11,59.47 163.11,62.46 163.11,64.55 157.42,70.24 157.42,70.67 157.82,71.07 158.2,71.07 159.12,70.16 159.12,69.6 159.35,69.37 159.91,69.37 160.41,68.86 161.15,68.86 161.91,68.1 161.91,67.72 162.67,66.96 163.41,66.96 163.66,66.71 163.66,66.05 163.84,65.87 164.17,65.87 164.38,65.66 164.38,64.95 164.15,64.72 163.82,64.72 163.61,64.52 163.61,64.29 163.82,64.09 164.02,64.09 164.17,64.24 165.06,64.24 165.47,63.84 165.47,63.58 165.6,63.45 165.87,63.45 165.98,63.35 165.98,63 165.85,62.87 164.48,62.87 164.33,62.72 164.33,62.31 163.69,61.68 163.18,61.68 162.5,60.99 162.5,60.66 162.37,60.53 162.12,60.53 161.96,60.38 161.96,59.03 161.73,58.81
1D35V_VGA_S0 on L5: 176.89,45.27 176.89,45.27 176.01,45.27 175.45,45.84 175.45,46.71 162.91,59.26 161.5,59.26 160.74,60.01 160.74,61.42 162.55,63.22 162.55,65.68 158.25,69.98 157.8,69.98 157.3,70.48 157.3,80.28 165.1,88.08 183.3,88.08 187.3,84.09 193.47,48.04 193.12,47.65 192.5,47.5 190.65,46.31 188.58,45.39 186.01,45.27 ; 1 cut-out
1D35V_VGA_S0 on L6: 186.01,45.27 176.89,45.27 176.89,45.27 176.01,45.27 175.45,45.84 175.45,46.71 162.91,59.26 161.5,59.26 160.74,60.01 160.74,61.42 162.55,63.22 162.55,65.68 158.25,69.98 157.3,69.98 157.3,80.28 165.1,88.08 183.3,88.08 187.61,83.77 193.85,48.14 193.34,47.64 192.04,47.4 190.85,46.63 190,45.58 ; 3 cut-outs
1D35V_VGA_S0 on L8: 162.89,66.54 163.62,66.54 164.72,65.45 164.72,63.52 161.98,60.78 161.98,59.51 161.62,59.15 161.15,59.15 160.71,59.59 160.71,60.57 162.6,62.47 162.6,66.26
3D3V_AUX_S5 on L6: 124.97,65.06 128.76,65.06 134.07,59.76 134.85,59.76 136.02,58.59 136.96,58.59 137.42,59.05 141.27,59.05 141.46,58.85 141.46,58.69 141.25,58.48 137.68,58.48 137.18,57.98 135.76,57.98 134.53,59.2 133.63,59.2 128.39,64.45 124.94,64.45 124.75,64.64 124.75,64.83
3D3V_CARD on BOTTOM: 3.15,9.33 3.15,9.34 2.97,9.52 2.97,9.79 3.14,9.96 3.53,9.96 3.8,10.23 3.8,11.41 4.34,11.95 4.94,11.95 5.37,12.37 5.37,12.83 5.48,12.94 6.62,12.94 6.63,12.94 6.63,12.68 6.53,12.58 5.94,12.58 5.91,12.56 5.91,11.39 3.85,9.33 ; 1 cut-out
3D3V_CARD on L8: 2.39,14.04 3.78,14.04 4.21,13.61 4.21,9.33 3.95,9.07 2.39,9.07 1.77,9.69 1.77,13.41
3D3V_CARD_S5 on BOTTOM: 6.64,13.31 6.64,13.12 6.56,13.05 5.27,13.05 5.15,12.93 5.15,12.21 4.97,12.03 4.26,12.03 3.95,12.34 3.95,13.98 3.73,14.2 3.11,14.2 2.9,14.41 2.9,14.93 3.03,15.07 3.36,15.07 3.38,15.05 4.33,15.05 5.22,14.15 5.22,13.97 5.86,13.34 6.61,13.34 ; 2 cut-outs
3D3V_CARD_S5 on BOTTOM: 9.97,14.65 9.91,14.71 9.91,14.73 9.92,14.74 9.92,14.88 9.95,14.92 9.95,14.92 10.63,14.92 10.74,15.03 10.74,15.42 11.06,15.73 11.14,15.73 11.34,15.93 12.65,15.93 12.66,15.93 14.25,15.93 14.39,15.79 14.39,15.4 14.08,15.1 11.5,15.1 11.06,14.65 ; 2 cut-outs
3D3V_CARD_S5 on L5: 3.66,14.28 2.98,14.28 2.83,14.43 2.83,15.14 4.34,16.65 13.78,16.65 14.46,15.97 14.46,15.47 14.25,15.26 13.65,15.26 13.26,15.65 5.04,15.65
3D3V_ECVBAT on TOP: 18.88,24.59 18.56,24.9 18.56,25.31 18.87,25.61 18.87,25.74 18.65,25.96 18.42,25.96 18.28,26.11 18.28,26.47 18.4,26.59 18.93,26.59 19.12,26.4 19.12,26.12 19.42,25.82 20.1,25.82 20.22,25.7 20.22,25.38 19.98,25.13 19.65,25.13 19.11,24.59
3D3V_FPR_VDD on BOTTOM: 143.85,8.08 143.85,8.09 143.58,8.09 142.92,8.74 142.33,8.74 142.2,8.87 142.2,9.71 142.33,9.83 142.67,9.83 142.67,9.83 142.89,9.83 143.91,8.81 143.91,8.78 144.13,8.56 144.13,8.23 143.98,8.08
3D3V_HINGE_S0 on TOP: 58.14,78.61 57.97,78.77 57.97,79.52 58.71,80.27 59.49,80.27 59.73,80.5 59.73,81.13 59.93,81.33 60.67,81.33 61.08,80.92 61.09,80.93 62.56,80.93 62.92,80.56 62.92,79.66 62.92,79.66 62.92,78.47 62.81,78.36 62.57,78.36 62.54,78.39 62.54,78.75 62.61,78.82 62.61,79.28 62.51,79.39 61.39,79.39 61.03,79.03 59.41,79.03 58.98,78.61 ; 2 cut-outs
3D3V_LCDVDD_R on TOP: 43.72,80.22 43.24,80.7 42.51,80.7 42.38,80.83 42.38,82.16 42.45,82.22 44.16,82.22 44.27,82.11 45.31,82.11 45.38,82.05 45.38,81.79 45.3,81.72 44.97,81.72 44.88,81.62 44.86,81.62 44.8,81.56 44.8,81.01 44.41,80.62 44.37,80.62 44.32,80.57 44.32,80.5 44.04,80.22
3D3V_LCDVDD_R on BOTTOM: 58.28,74.18 57.6,74.86 55.72,74.86 55.5,75.08 55.5,75.67 55.86,76.03 58.48,76.03 59.14,75.37 60.29,75.37 60.41,75.24 60.41,74.48 60.4,74.46 60.4,74.35 60.22,74.18 ; 2 cut-outs
3D3V_LCDVDD_R on L6: 57.92,75.68 60.09,77.85 61.19,77.85 61.19,77.85 61.9,77.85 62.58,78.52 62.58,81.57 63.44,82.43 66.45,82.43 66.63,82.25 66.63,79.26 63.89,76.51 62.7,76.51 60.11,73.92 55.81,73.92 55.37,74.36 55.37,75.53 55.52,75.68
3D3V_LCDVDD_R on L8: 44.78,81.07 44.07,80.36 43.7,80.36 43.32,80.73 43.32,81.78 43.93,82.38 55.75,82.38 55.76,82.39 60.02,82.39 60.5,82.87 62.96,82.87 63.58,82.25 63.58,80.77 63.38,80.57 61.94,80.57 61.43,81.08 56.43,81.08 56.42,81.07
3D3V_LCDVDD_S0 on TOP: 38.88,70.59 38.88,72.06 39.02,72.2 39.02,72.62 39.12,72.72 39.56,72.72 39.67,72.61 39.67,71.71 40.06,71.32 40.87,71.32 40.97,71.22 40.97,70.68 40.71,70.42 40.71,70.15 40.01,69.45 39.53,69.45 39.41,69.57 39.41,70.06
3D3V_LCDVDD_S0 on TOP: 40.36,79.26 40.22,79.39 40.22,80.26 40.09,80.39 40.09,82.07 40.14,82.12 40.73,82.12 40.83,82.22 41.62,82.22 41.62,82.22 41.78,82.22 41.87,82.13 41.87,80.83 41.74,80.7 41.35,80.7 40.93,80.29 40.93,79.38 40.81,79.26 ; 2 cut-outs
3D3V_LCDVDD_S0 on BOTTOM: 40.35,78.49 40.3,78.54 40.3,79.33 40.2,79.43 40.2,80.61 40.37,80.78 40.77,80.78 40.98,80.57 40.98,79.56 40.91,79.5 40.91,78.57 40.83,78.49
3D3V_LCDVDD_S0 on L6: 40.37,80.72 40.79,80.72 40.93,80.59 40.93,79.32 39.35,77.75 38.6,77.75 38.18,77.33 38.18,75.85 38.5,75.53 38.5,74.56 38.48,74.55 38.48,72.63 39.5,71.61 39.5,70.52 39.3,70.32 38.32,70.32 37.12,71.51 37.12,77.47 37.13,77.47 37.13,78.19 38.41,79.47 39.12,79.47 39.49,79.83 39.79,79.83 40.1,80.15 40.1,80.45
3D3V_S0 on TOP: 122.44,35.08 122.24,35.29 122.24,37.44 122.01,37.67 120.05,37.67 119.95,37.77 119.95,38.18 120.03,38.26 122.87,38.26 123.48,37.65 123.48,35.67 122.9,35.08
3D3V_S0 on TOP: 59.71,76.78 59.2,77.29 59.2,78.53 59.39,78.73 62.12,78.73 62.32,78.53 62.32,77.8 61.9,77.38 60.45,77.38 60.4,77.33 60.4,76.93 60.25,76.78 ; 1 cut-out
3D3V_S0 on TOP: 115.98,52.82 115.75,53.05 113.7,53.05 113.65,53 111.79,53 111.66,53.13 111.66,53.65 111.66,53.66 111.66,54.23 111.75,54.31 112.39,54.31 112.65,54.05 116.27,54.05 116.57,53.75 116.57,53.04 116.35,52.82
