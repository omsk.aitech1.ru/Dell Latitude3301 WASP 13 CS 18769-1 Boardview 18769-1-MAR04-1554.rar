# Allegro board 18769-1-MAR04-1554.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
Net_9893 on TOP_-MB (solid shape): 144.89,88.12 144.89,88.12 144.89,86.42 144.88,86.42 142.3,86.42 141.9,86.01 141.26,86.01 141.17,86.1 141.19,86.16 141.2,86.21 141.2,86.27 141.2,86.32 141.18,86.37 141.16,86.42 141.14,86.47 141.1,86.51 141.08,86.53 141.08,86.77 141.1,86.81 141.11,86.86 141.12,86.91 141.12,86.97 141.11,87.01 141.56,87.01 141.85,86.65 143.01,86.65 143.13,86.64 144.29,86.64 144.29,86.9 144.04,86.9 144.04,86.64 143.38,86.64 143.38,86.9 143.13,86.9 143.01,86.9 142.76,86.9 142.76,86.65 142.1,86.65 142.1,86.9 141.82,87.26 141.56,87.26 141.56,87.01 141.11,87.01 141.1,87.07 141.08,87.1 141.08,87.69 141.18,87.78 141.63,87.77 141.64,87.77 141.68,87.78 141.7,87.79 143.98,87.79 144.2,88.01 144.36,88.17 144.85,88.17
Net_11186 on L8_-MB (solid shape): outline of 497 points within 0.51,0.51 136.5,26.3
Net_11187 on L8_-MB (solid shape): 146.91,1.02 158.36,1.02 158.61,1.27 159.55,1.27 159.65,1.19 159.6,1.08 159.32,0.84 159.14,0.51 158.62,0.51 158.62,0.51 146.69,0.51 146.69,0.51 145.21,0.51 145.03,0.84 144.75,1.08 144.7,1.19 144.8,1.27 146.66,1.27
Net_11188 on L8_-MB (solid shape): outline of 5227 points within 2.16,0.51 197.49,89.49
Net_11189 on L8_-MB (solid shape): 93.8,7.47 94,7.42 94.21,7.47 94.22,7.47 94.71,7.47 94.72,7.47 94.89,7.44 95.06,7.47 95.07,7.47 101.38,7.47 101.74,7.12 101.91,7.12 102.07,6.96 117.95,6.96 120.19,4.72 120.19,4.7 120.52,4.36 120.93,4.6 120.94,4.63 122.38,4.63 122.47,4.58 122.47,4.48 122.81,3.91 123.14,4.48 123.14,4.58 123.23,4.63 124.14,4.63 124.42,4.35 124.42,3.36 124.24,3.18 117.84,3.18 116.1,4.92 115.99,5.03 115.94,5.03 115.94,5.04 115.81,5.06 115.68,5.04 115.67,5.03 115.17,5.03 114.94,5.11 114.72,5.03 114.51,5.03 114.3,5.11 114.08,5.04 114.07,5.03 113.9,5.03 113.66,5.12 113.42,5.03 110.12,5.03 108.37,3.28 93.15,3.28 91.83,4.6 91.83,5.87 93.43,7.47 93.79,7.47
Net_11190 on L8_-MB (solid shape): 10.65,16.67 10.65,12.77 10.71,12.72 10.71,8.82 11.52,8.01 11.52,6.28 11.06,5.82 10.62,5.82 9.44,7.01 9.44,8.17 5.79,11.81 5.79,17.85 6.16,18.22 9.11,18.22
Net_11191 on L8_-MB (solid shape): outline of 190 points within 1.77,9.07 4.21,14.04
Net_11192 on L8_-MB (solid shape): 196.92,24.09 196.92,17.88 196.86,17.66 196.92,17.44 196.92,15.53 196.18,14.79 195.61,14.79 195.23,15.17 195.23,16.2 195.81,16.78 195.81,23.39 194.59,24.6 187.22,24.6 186.93,24.89 186.93,25.33 187.24,25.63 195.39,25.63
Net_11193 on L8_-MB (solid shape): 116.43,33.36 117.29,33.36 117.5,33.16 117.5,32.29 117.47,32.28 117.21,31.92 117.47,31.56 117.5,31.55 117.5,25.79 117.47,25.72 117.4,25.69 117.03,25.31 117.4,24.93 117.47,24.9 117.5,24.83 117.5,24.34 117.39,24.23 117.33,24.08 117.33,24.07 117.04,23.78 117.04,18.93 116.11,18 115.51,18 114.48,19.03 114.48,22.58 114.69,22.79 114.69,27.65 114.73,27.69 114.73,31.23 114.73,31.23 114.73,33.04 115.18,33.48 116.31,33.48
Net_11194 on L8_-MB (solid shape): outline of 744 points within 65.24,19.36 80.35,22.1
Net_11195 on L8_-MB (solid shape): outline of 234 points within 42.8,20.19 60.23,37.88
Net_11196 on L8_-MB (solid shape): outline of 242 points within 180.97,23.88 195.29,38.65
Net_11197 on L8_-MB (solid shape): outline of 139 points within 50.06,24.53 52.85,26.86
Net_11198 on L8_-MB (solid shape): outline of 324 points within 123.23,27.83 134.2,50.03
Net_11199 on L8_-MB (solid shape): outline of 251 points within 7.93,29.73 13.33,34.24
Net_11200 on L8_-MB (solid shape): 147.33,42.02 147.33,33.96 146.7,33.33 143.4,33.33 142.48,34.24 142.48,41.97 143.09,42.58 146.77,42.58
Net_11201 on L8_-MB (solid shape): 9.87,51.16 9.94,51.14 10.06,51.05 10.18,50.99 10.24,50.92 10.22,50.83 9.69,50.43 9.05,50.28 8.12,49.35 8.12,49.35 7.4,48.63 6.53,48.63 4.16,46.27 4.16,41.24 2.88,39.96 2.71,39.96 2.57,39.95 2.43,39.91 2.33,39.92 2.29,40 2.29,41.69 2.29,44.85 1.99,45.57 1.28,45.86 0.51,45.86 0.51,50.79 4.16,50.79 4.16,50.79 9.05,50.79 9.46,50.88 9.8,51.13
Net_11202 on L8_-MB (solid shape): outline of 784 points within 84.85,48.54 99.86,59.49
Net_11203 on L8_-MB (solid shape): outline of 776 points within 49.87,51.11 79.08,60.36
Net_11205 on L8_-MB (solid shape): outline of 170 points within 99.17,52.69 104.4,55.84
Net_11206 on L8_-MB (solid shape): outline of 436 points within 13.52,54.11 23.81,66.88
Net_11207 on L8_-MB (solid shape): 155.77,57.61 155.89,57.61 156.1,57.41 158.93,57.41 159.08,57.25 159.12,57.22 159.17,57.18 159.35,57 160.13,57 160.31,56.82 160.31,56.42 160.13,56.24 158.66,56.24 158.38,56.52 156.88,56.52 156.83,56.57 156.03,56.57 155.97,56.52 154.67,56.52 152.59,58.6 152.59,59.26 152.82,59.49 153.89,59.49
Net_11208 on L8_-MB (solid shape): outline of 691 points within 152.21,59.2 162.36,68.28
Net_11209 on L8_-MB (solid shape): outline of 94 points within 160.71,59.15 164.72,66.54
Net_11210 on L8_-MB (solid shape): outline of 741 points within 26.2,60.44 63.69,76.3
Net_11211 on L8_-MB (solid shape): outline of 969 points within 145.89,64.32 158.01,82.4
Net_11212 on L8_-MB (solid shape): 90.28,85.45 90.28,85.1 90.59,84.79 94.98,84.79 96.25,83.52 96.25,80.27 94.17,78.19 70.6,78.19 66.03,82.76 66.03,84.16 66.34,84.47 66.36,84.47 66.53,84.49 66.66,84.59 67.32,84.59 67.65,84.92 67.65,85.22 67.98,85.55 68.85,85.55 69.28,85.12 69.28,84.84 69.86,84.26 76.01,84.26 76.09,84.33 77.69,84.33 78.8,85.45 85.84,85.45 85.99,85.3 88.35,85.3 88.91,85.86 89.88,85.86
Net_11213 on L8_-MB (solid shape): outline of 84 points within 43.32,80.36 63.58,82.87
Net_11214 on L8_-MB (solid shape): 107.52,87.67 107.6,87.63 107.62,87.54 107.99,87.07 108.36,87.54 108.38,87.63 108.46,87.67 108.76,87.67 109.15,87.28 109.15,86.65 109.14,86.64 109.14,86.57 108.8,86.24 107.86,86.24 107.1,87 105.26,87 105.25,87 105.07,87.04 104.89,87 104.88,87 104.81,87 104.71,86.9 103.67,86.9 103.6,86.83 103.59,86.83 103.47,86.74 103.39,86.62 103.39,86.61 103.29,86.52 103.29,85.37 103.63,85.03 103.63,84.48 103.54,84.39 103.42,84.39 103.41,84.4 103.24,84.44 103.07,84.4 103.06,84.39 102.53,84.39 101.68,85.24 101.68,87.18 102.17,87.67
Net_11215 on L8_-MB (solid shape): 76.39,85.63 76.39,84.82 75.96,84.38 69.91,84.38 69.41,84.89 69.41,85.76 69.51,85.86 76.16,85.86
Net_12499 on L6_-MB (solid shape): outline of 1119 points within 0.51,0.51 136.28,27.74
Net_12500 on L6_-MB (solid shape): 145.75,0.97 158.83,0.97 158.9,0.9 159.17,0.9 159.26,0.85 159.25,0.75 159.19,0.63 159.14,0.51 159.03,0.51 146.7,0.51 146.7,0.51 145.21,0.51 145.11,0.73 144.96,0.92 144.93,1.03 145.03,1.09 145.62,1.09
Net_12501 on L6_-MB (solid shape): outline of 3452 points within 2.16,0.51 197.49,89.49
Net_12502 on L6_-MB (solid shape): outline of 4177 points within 8.26,1.09 71.16,65.18
Net_12503 on L6_-MB (solid shape): outline of 4985 points within 13.23,1.1 196.23,61.07
Net_12504 on L6_-MB (solid shape): 163.36,6.89 163.36,6.15 163.3,6.09 163.29,6.09 162.92,5.77 162.88,5.29 162.88,5.28 162.88,5.01 162.8,4.93 162.14,4.93 162.01,5.06 162.01,5.25 162.02,5.26 162.04,5.39 162.02,5.52 162.01,5.53 162.01,6.38 162.7,7.07 163.18,7.07
Net_12505 on L6_-MB (solid shape): 161.56,7.19 161.56,6.86 161.35,6.66 161.35,5.62 161.28,5.4 161.34,5.17 161.35,5.16 161.35,5.06 161.3,5.01 160.59,5.01 160.31,5.29 160.31,7.14 160.57,7.4 161.35,7.4
Net_12506 on L6_-MB (solid shape): outline of 564 points within 109.84,9.79 131.32,14.39
Net_12507 on L6_-MB (solid shape): outline of 2015 points within 32.25,12.91 136.65,81.64
Net_12508 on L6_-MB (solid shape): outline of 544 points within 56.1,17.03 102.2,22.56
Net_12509 on L6_-MB (solid shape): outline of 671 points within 32.85,17.17 45.78,47.36
Net_12510 on L6_-MB (solid shape): 147.21,42.04 147.21,33.89 146.44,33.13 143.24,33.13 142.23,34.14 142.23,38.41 142.29,38.65 142.23,38.89 142.23,42.55 142.3,42.63 146.62,42.63
Net_12511 on L6_-MB (solid shape): 9.87,51.16 9.94,51.14 10.06,51.05 10.18,50.99 10.24,50.92 10.22,50.83 9.81,50.49 9.31,50.31 9.31,49.6 9.24,49.39 9.31,49.17 9.31,46.24 9.25,46.14 9.14,46.16 5.67,44.5 9.14,42.84 9.25,42.85 9.31,42.76 9.31,40.88 9.28,40.8 9.21,40.77 8.86,40.54 8.94,40.12 8.97,40.05 8.94,39.98 8.83,39.72 8.93,39.44 8.96,39.41 8.01,38.46 7.85,38.46 7.85,38.54 7.87,38.55 8.14,39.43 7.39,39.96 6.4,39.96 5.68,39.48 5.85,38.52 5.76,38.46 4.17,38.46 4.07,38.52 4.25,39.48 3.53,39.96 2.71,39.96 2.57,39.95 2.43,39.91 2.33,39.92 2.29,40 2.29,44.85 1.99,45.57 1.28,45.86 0.51,45.86 0.51,50.79 8.94,50.79 9.05,50.79 9.46,50.88 9.8,51.13
Net_12512 on L6_-MB (solid shape): outline of 3516 points within 135.29,38.87 162.37,68.92
Net_12513 on L6_-MB (solid shape): outline of 15029 points within 157.3,45.27 193.85,88.08
Net_12514 on L6_-MB (solid shape): outline of 508 points within 8.56,46.66 20.34,72.51
Net_12515 on L6_-MB (solid shape): outline of 1058 points within 95.69,48.54 105.22,77.95
Net_12516 on L6_-MB (solid shape): outline of 3884 points within 73.44,48.65 95.52,77.93
Net_12517 on L6_-MB (solid shape): 46.34,57.74 46.37,57.64 46.3,57.57 46.14,56.94 46.77,57.1 46.84,57.17 46.94,57.14 47.18,56.9 47.18,52.81 43.62,49.26 41.62,49.26 40.83,50.04 40.83,55 43.35,57.51 44.95,57.51 45.4,57.97 46.11,57.97
Net_12518 on L6_-MB (solid shape): outline of 1585 points within 93.69,50.5 101.46,78.03
Net_12519 on L6_-MB (solid shape): outline of 1092 points within 49.87,51.11 79.15,60.63
Net_12520 on L6_-MB (solid shape): 40.58,55.4 40.58,51.87 40.4,51.69 39.66,51.69 39.41,51.95 39.41,55.3 39.69,55.58 40.4,55.58
Net_12522 on L6_-MB (solid shape): outline of 4235 points within 101.41,52.53 135.7,87.49
Net_12523 on L6_-MB (solid shape): 107.18,58.91 107.45,58.73 107.76,58.82 107.83,58.84 108.15,58.7 108.42,58.8 108.48,58.82 108.55,58.8 108.81,58.7 109.07,58.82 109.14,58.85 109.21,58.82 109.47,58.71 109.74,58.82 109.81,58.84 110.14,58.72 110.4,58.82 110.43,58.84 110.47,58.82 110.77,58.52 110.77,58.19 110.52,57.93 110.09,57.93 110.02,57.96 109.99,58.04 109.76,58.44 109.31,58.33 109.24,58.29 109.16,58.32 108.89,58.44 108.54,58.31 108.47,58.35 108.19,58.47 107.91,58.35 107.84,58.31 107.77,58.34 107.43,58.44 107.16,58.23 107.09,58.17 107,58.2 106.89,58.31 106.89,58.77 107.02,58.91
Net_12524 on L6_-MB (solid shape): 133.85,59.98 133.85,59.97 133.92,59.86 134.03,59.79 134.04,59.78 134.07,59.76 134.2,59.76 134.85,59.76 135.34,59.27 135.34,59.26 135.46,59.07 135.65,58.96 135.66,58.95 136.02,58.59 136.34,58.59 136.64,58.48 136.94,58.58 136.96,58.59 137.42,59.05 141.27,59.05 141.46,58.85 141.46,58.69 141.25,58.48 137.68,58.48 137.18,57.98 135.76,57.98 134.53,59.2 133.63,59.2 128.39,64.45 125.59,64.45 125.58,64.45 125.42,64.49 125.25,64.45 125.24,64.45 124.94,64.45 124.75,64.64 124.75,64.83 124.97,65.06 128.76,65.06
Net_12525 on L6_-MB (solid shape): outline of 847 points within 126.72,61.93 147.91,87.99
Net_12526 on L6_-MB (solid shape): 40.93,80.59 40.93,79.32 39.41,77.81 39.39,77.81 39.28,77.79 39.18,77.75 38.65,77.75 38.65,77.75 38.16,77.52 38.18,76.98 38.18,76.67 38.09,76.38 38.18,76.09 38.18,75.85 38.5,75.53 38.5,74.56 38.48,74.55 38.48,72.63 39.5,71.61 39.5,70.52 39.3,70.32 38.71,70.32 38.51,70.43 38.28,70.4 38.25,70.39 37.12,71.51 37.12,77.47 37.13,77.47 37.13,78.19 38.41,79.47 38.54,79.47 38.55,79.46 38.96,79.37 39.28,79.62 39.29,79.63 39.43,79.77 39.46,79.76 39.85,79.8 40.08,80.12 40.09,80.14 40.1,80.15 40.1,80.45 40.37,80.72 40.79,80.72
Net_12527 on L6_-MB (solid shape): outline of 321 points within 55.37,73.92 66.63,82.43
Net_12528 on L6_-MB (solid shape): 94.12,83.67 95.49,83.67 95.85,83.32 95.85,82.12 95.16,81.44 73.24,81.44 72.91,81.77 72.91,84.21 73.29,84.59 76.52,84.59 76.64,84.71 93.08,84.71
Net_12529 on L6_-MB (solid shape): outline of 198 points within 73.02,84.88 95.7,87.19
Net_13660 on L5_-MB (solid shape): 15.31,2.68 18.15,2.78 26.39,1.02 32.89,1.02 32.89,1.4 33.07,2.14 33.56,2.71 35.46,2.71 35.95,2.14 36.13,1.4 36.13,1.02 61.8,1.02 61.81,1.01 61.94,0.99 62.07,1.01 62.08,1.02 134.54,1.02 134.6,1.07 136.15,1.07 136.24,1.01 136.22,0.9 136.08,0.72 135.99,0.51 134.56,0.51 134.56,0.51 35.62,0.51 35.62,1.4 34.51,2.51 33.4,1.4 33.4,0.51 26.39,0.51 26.34,0.51 26.28,0.52 18.04,2.28 15.6,2.23 13.44,1.09 13.42,1.08 12.94,1.08 12.84,1.14 12.87,1.25
Net_13661 on L5_-MB (solid shape): 147.03,1.02 158.58,1.02 158.58,1.04 159.06,1.04 159.16,1.14 159.37,1.14 159.46,1.07 159.44,0.96 159.26,0.75 159.14,0.51 158.94,0.51 158.94,0.51 146.8,0.51 146.8,0.51 145.21,0.51 145.09,0.75 144.91,0.96 144.89,1.07 144.98,1.14 146.91,1.14
Net_13662 on L5_-MB (solid shape): 5.18,6.86 5.32,6.76 5.33,6.74 5.46,6.52 5.71,6.43 5.74,6.43 6.01,6.02 6.03,5.88 8.32,4.48 9.22,1.95 9.22,1.02 12.57,1.02 12.57,0.99 12.61,0.95 13.04,0.95 13.13,0.89 13.11,0.78 13.01,0.67 12.84,0.55 12.64,0.51 8.71,0.51 8.71,1.95 7.84,4.27 5.66,5.43 5.6,5.45 5.59,5.52 5.53,5.83 5.31,6.16 4.98,6.38 4.64,6.45 3.95,6.45 3.51,6.33 3.43,6.26 3.33,6.23 3.26,6.3 3.21,6.41 3.12,6.5 3.08,6.57 3.11,6.65 3.25,6.79 3.88,6.96 4.69,6.96
Net_13663 on L5_-MB (solid shape): 187.15,3.02 187.46,2.85 187.78,3.02 190.28,3.02 190.32,3.02 190.71,2.62 190.73,2.5 190.61,2.45 190.45,2.5 190.28,2.51 169.37,2.51 169.37,2.51 168.67,2.51 167.96,2.21 167.66,1.5 167.66,0.51 166.06,0.51 165.95,0.74 165.78,0.94 165.75,1.06 165.85,1.12 166.33,1.12 166.86,1.65 166.94,1.65 168.3,3.02
Net_13664 on L5_-MB (solid shape): outline of 1470 points within 2.16,0.51 197.49,89.49
Net_13665 on L5_-MB (solid shape): outline of 2730 points within 65.24,1.2 173.89,8.1
Net_13666 on L5_-MB (solid shape): outline of 3986 points within 65.96,1.12 195.14,14.03
Net_13667 on L5_-MB (solid shape): 1.29,19.09 1.38,19.03 1.36,18.92 1.33,18.89 1.33,18.58 1.28,18.58 1.02,18.58 1.02,5.97 2.59,5.97 2.75,5.84 2.94,5.81 3.03,5.78 3.05,5.69 3.02,5.58 2.99,5.47 2.95,5.46 0.51,5.46 0.51,19.09
Net_13668 on L5_-MB (solid shape): 191.02,11.54 191.02,10.24 190.89,10.11 190.51,10.11 190.26,10.37 190.26,10.77 190.16,10.88 190.04,10.88 189.79,10.98 189.53,10.89 189.52,10.88 189.5,10.88 188.73,10.11 182.56,10.11 181.81,10.86 181.81,10.88 181.68,11.09 181.47,11.22 181.46,11.22 181.32,11.36 181.32,11.74 181.57,11.99 182.64,11.99 183.6,11.03 186.55,11.03 187.08,11.56 187.11,11.56 187.67,12.12 190.44,12.12
Net_13669 on L5_-MB (solid shape): outline of 1209 points within 44.88,13.35 163.25,29.33
Net_13670 on L5_-MB (solid shape): 9.88,16.65 9.97,16.6 9.96,16.49 10.27,15.88 10.58,16.49 10.57,16.6 10.66,16.65 13.68,16.65 13.76,16.62 13.78,16.53 13.91,16.17 14.29,16.11 14.32,16.12 14.46,15.97 14.46,15.47 14.25,15.26 13.65,15.26 13.26,15.65 5.04,15.65 3.66,14.28 2.98,14.28 2.92,14.33 2.92,14.35 2.89,14.47 2.83,14.58 2.83,14.75 2.83,14.76 2.89,14.94 2.86,15.13 2.85,15.16 4.34,16.65
Net_13671 on L5_-MB (solid shape): 114.39,19.74 114.39,18.72 113.12,17.45 94.45,17.45 94.2,17.71 94.2,18.6 94.32,18.72 99.28,18.72 99.35,18.69 99.38,18.62 99.59,18.25 100.01,18.31 100.08,18.34 100.14,18.31 100.56,18.25 100.77,18.62 100.8,18.69 100.88,18.72 109.1,18.72 109.35,18.63 109.6,18.72 110.06,18.72 110.3,18.63 110.54,18.72 112.1,18.72 113.25,19.87 114.26,19.87
Net_13673 on L5_-MB (solid shape): outline of 216 points within 169.8,24.83 187.7,27.64
Net_13674 on L5_-MB (solid shape): outline of 3383 points within 7.32,31.36 26.82,73.03
Net_13675 on L5_-MB (solid shape): outline of 252 points within 134.05,31.58 156.73,38.31
Net_13676 on L5_-MB (solid shape): 147.36,42.04 147.36,33.89 146.67,33.2 143.57,33.2 142.46,34.32 142.46,42.27 142.74,42.55 146.85,42.55
Net_13677 on L5_-MB (solid shape): outline of 83 points within 0.51,36.02 10.24,51.16
Net_13678 on L5_-MB (solid shape): 30.97,38.24 31.46,38.24 31.71,38.1 31.99,38.17 32.03,38.19 32.32,37.9 34.24,37.9 34.44,37.84 34.65,37.9 35.11,37.9 35.12,37.89 35.29,37.85 35.47,37.89 35.48,37.9 39.24,37.9 39.27,37.93 40.6,37.93 40.92,37.81 41.25,37.93 43.69,37.93 44.07,37.55 44.07,37.18 43.61,36.72 30.9,36.72 30.45,37.17 28.31,37.17 28,37.49 28,38.06 28.31,38.38 30.84,38.38
Net_13679 on L5_-MB (solid shape): outline of 3491 points within 135.3,38.87 162.37,68.92
Net_13680 on L5_-MB (solid shape): outline of 1343 points within 22.3,44.12 35.72,65.73
Net_13681 on L5_-MB (solid shape): outline of 14916 points within 157.3,45.27 193.47,88.08
Net_13682 on L5_-MB (solid shape): 31.96,47.64 33.28,47.64 33.46,47.46 33.46,47.46 33.53,47.36 33.62,47.29 33.65,47.27 33.8,47.25 33.91,47.27 34.53,47.27 34.77,47.03 34.77,46.41 34.72,46.36 33.68,46.36 33.53,46.21 33.53,46.21 33.42,46.13 33.34,46.02 33.22,45.9 31.53,45.9 31.28,46.15 28.22,46.15 27.96,46.41 27.96,47.19 28.03,47.25 28.04,47.25 28.43,47.65 31.96,47.65
Net_13683 on L5_-MB (solid shape): outline of 421 points within 159.22,49.61 165.9,58.15
Net_13684 on L5_-MB (solid shape): 45.83,56.67 46.7,56.67 46.98,56.39 46.98,52.81 43.4,49.23 41.77,49.23 40.93,50.07 40.93,55.5 42.94,57.51 45,57.51
Net_13685 on L5_-MB (solid shape): 40.63,55.4 40.63,51.77 40.45,51.59 39.61,51.59 39.13,52.08 39.13,55.45 39.36,55.68 40.35,55.68
Net_13686 on L5_-MB (solid shape): outline of 685 points within 49.87,50.98 78.98,60.13
Net_13688 on L5_-MB (solid shape): outline of 498 points within 99.23,52.78 106.5,58.48
Net_13689 on L5_-MB (solid shape): outline of 5206 points within 61.92,58.44 139.59,87.8
Net_13690 on L5_-MB (solid shape): 44.53,73.01 51.88,73.01 51.89,73.01 58.58,73.01 59.39,72.19 59.4,72.18 59.48,72.05 59.62,71.96 59.63,71.96 61.47,70.11 62.43,70.11 63.1,69.44 63.1,69.06 62.96,68.92 61.55,68.92 60.96,68.92 57.89,71.99 42.55,71.99 42.25,72.3 42.25,72.87 42.44,73.07 44.48,73.07
Net_13691 on L5_-MB (solid shape): outline of 540 points within 134.09,79.68 161.14,88.63
Net_15043 on L3_-MB (solid shape): outline of 3900 points within 2.16,0.51 197.49,89.49
Net_15044 on L3_-MB (solid shape): 120.84,22.47 120.84,21.07 120.34,20.57 119.68,19.91 119.68,19.09 119.59,18.7 119.89,18.44 119.9,18.44 120.65,17.69 120.65,17.67 120.65,17.58 120.68,17.49 120.68,17.31 120.69,17.23 120.72,17.14 120.72,16.97 120.65,16.75 120.71,16.53 120.72,16.52 120.72,16.36 120.66,15.95 121.02,15.73 121.04,15.73 121.63,15.14 121.63,9.14 121.53,9.03 121.53,6.15 122.87,4.81 122.89,4.81 123.04,4.66 123.04,4.19 122.9,4.05 122.59,4.05 120.73,5.9 120.73,13.35 120.04,14.04 120.04,17.45 118.79,18.69 118.79,20.04 120.05,21.3 120.05,22.28 120.34,22.57 120.75,22.57
Net_15045 on L3_-MB (solid shape): 5.76,27.74 5.85,27.68 5.68,26.72 6.4,26.24 7.39,26.24 7.79,26.35 8.08,26.64 8.19,26.69 8.27,26.59 8.27,25.56 9.36,24.47 9.36,22.28 8.09,21.01 7.82,21.01 7.73,21.09 7.78,21.2 6.8,25.23 5.82,21.2 5.87,21.09 5.78,21.01 3.34,21.01 2.83,20.5 2.8,20.5 2.8,20.1 2.35,19.03 1.28,18.58 1.02,18.58 1.02,7.22 1.13,7.11 1.84,7.11 2.04,6.9 4.46,6.9 4.62,7.07 6.55,7.07 6.88,6.73 6.91,6.62 6.81,6.56 5.57,6.56 5.4,6.72 3.16,6.72 3,6.56 2.97,6.57 2.51,6.21 2.94,5.81 3.03,5.78 3.05,5.69 3.02,5.58 2.99,5.47 2.95,5.46 0.51,5.46 0.51,6.02 0.51,6.02 0.51,19.09 1.28,19.09 1.99,19.39 2.29,20.1 2.29,20.5 2.29,26.2 2.33,26.28 2.43,26.29 2.57,26.25 2.71,26.24 3.53,26.24 4.25,26.72 4.07,27.68 4.17,27.74
Net_15046 on L3_-MB (solid shape): 190.28,10.9 190.28,10.24 190,9.96 189.73,9.96 189.67,10.02 189.67,10.03 189.56,10.23 189.36,10.34 189.35,10.34 188.99,10.7 187.69,10.7 186.45,9.45 182.18,9.45 181.56,10.07 181.5,10.16 181.39,10.24 181.37,10.24 181.23,10.27 181.09,10.24 181.08,10.24 180.96,10.24 180.68,10.52 180.68,10.9 181.09,11.31 181.47,11.31 181.73,11.12 182.05,11.12 182.08,11.13 182.66,10.55 185.92,10.55 187.16,11.79 189.4,11.79
Net_15047 on L3_-MB (solid shape): outline of 738 points within 79.34,19.45 107.98,22.53
Net_15048 on L3_-MB (solid shape): 45.68,31.02 45.68,30.61 45.59,30.52 45.55,30.53 45.1,30.42 45.15,29.96 45.18,29.89 45.15,29.82 45.06,29.46 45.32,29.19 45.35,29.18 45.35,28.28 45.76,27.87 45.76,26.12 45.71,26.07 45.71,24.92 47.94,22.69 57.16,22.69 57.34,22.87 58.18,22.87 58.61,22.43 58.61,21.85 58.05,21.29 47.21,21.29 44.34,24.16 44.34,30.31 44.35,30.32 44.35,30.95 44.62,31.22 45.48,31.22
Net_15049 on L3_-MB (solid shape): outline of 142 points within 135.17,22.88 141.41,62.72
Net_15050 on L3_-MB (solid shape): 168.5,27.76 168.67,27.72 168.83,27.76 168.84,27.76 169.98,27.76 170.71,27.04 170.71,25.38 170.59,25.26 170.08,25.26 170.05,25.29 169.93,25.29 169.82,25.4 169.82,26.52 169.73,26.61 169.73,26.62 169.45,26.89 169.08,26.77 168.35,26.77 166.45,24.87 165.49,24.87 165.18,25.18 162.68,25.18 162.61,25.26 162.58,25.26 162.32,25.51 162.32,25.88 162.78,26.34 165.56,26.34 165.91,26.29 166.13,26.57 166.14,26.58 167.32,27.76 168.49,27.76
Net_15052 on L3_-MB (solid shape): 161.85,31.81 161.85,31.18 161.74,31.06 161.37,31.06 159.94,32.49 159.03,32.49 158.79,32.58 158.54,32.5 158.53,32.49 158.42,32.49 156.7,30.78 156.68,30.78 156.31,30.66 156.27,30.28 156.28,30.25 156.22,30.18 155.85,30.18 155.74,30.29 155.74,30.5 158.2,32.95 160.72,32.95
Net_15053 on L3_-MB (solid shape): 147.1,41.92 147.1,33.89 146.52,33.3 143.85,33.3 142.53,34.63 142.53,42.04 142.76,42.27 146.75,42.27
Net_15054 on L3_-MB (solid shape): 9.87,51.16 9.94,51.14 10.23,50.97 10.56,50.91 10.74,50.91 10.83,50.85 10.81,50.74 10.11,50.04 9.84,50.04 9.82,49.99 9.82,49.86 9.78,49.78 9.7,49.76 9.24,49.39 9.7,49.01 9.78,48.99 9.82,48.91 9.82,48.81 9.8,48.77 9.77,48.76 9.39,48.38 9.77,48 9.8,47.98 9.82,47.94 9.82,45.65 9.74,45.55 9.63,45.6 5.67,44.5 9.63,43.4 9.74,43.45 9.82,43.35 9.82,40.82 9.79,40.81 9.7,40.76 9.64,40.68 9.56,40.64 9.48,40.67 8.95,40.66 8.94,40.12 8.97,40.05 8.94,39.98 8.83,39.75 8.89,39.5 8.91,39.46 8.32,38.87 8.2,38.85 8.15,38.97 8.02,39.65 7.39,39.96 6.4,39.96 5.68,39.48 5.85,38.52 5.76,38.46 4.17,38.46 4.07,38.52 4.25,39.48 3.53,39.96 2.71,39.96 2.57,39.95 2.43,39.91 2.33,39.92 2.29,40 2.29,44.85 1.99,45.57 1.28,45.86 0.51,45.86 0.51,50.79 9.02,50.79 9.05,50.79 9.46,50.88 9.8,51.13
Net_15055 on L3_-MB (solid shape): outline of 199 points within 101.73,46.61 106.53,51.34
Net_15056 on L3_-MB (solid shape): outline of 244 points within 103.01,47.53 113.47,52.61
Net_15057 on L3_-MB (solid shape): outline of 2387 points within 73.18,48.67 95.47,78.54
Net_15058 on L3_-MB (solid shape): 45.73,56.57 46.85,56.57 47.21,56.22 47.21,52.68 45.43,50.91 45.43,49.31 45.28,49.15 41.34,49.15 40.98,49.51 40.98,55.38 42.89,57.28 45.02,57.28
Net_15059 on L3_-MB (solid shape): outline of 1108 points within 49.87,51.17 79.15,60.81
Net_15060 on L3_-MB (solid shape): 40.47,55.61 40.47,51.8 40.2,51.52 39.08,51.52 38.6,52 38.6,55.61 38.87,55.89 40.2,55.89
Net_15061 on L3_-MB (solid shape): 9.83,65.71 9.9,65.68 10.1,65.53 10.34,65.43 10.36,65.43 10.4,65.39 10.3,65.28 10.08,65.28 10.07,65.27 10.07,64.07 9.75,63.66 9.96,63.18 10.01,63.1 9.75,62.6 10.01,62.1 9.75,61.6 10.01,61.1 9.75,60.6 10.01,60.1 9.96,60.02 9.75,59.6 10.01,59.1 9.75,58.6 10.01,58.1 9.75,57.6 10.01,57.1 9.75,56.6 10.01,56.1 9.75,55.6 10.01,55.1 9.96,55.02 9.75,54.54 10.07,54.13 10.07,53.59 10.84,53.59 11.46,52.96 11.49,52.85 11.39,52.79 10.56,52.79 10.2,52.72 9.9,52.52 9.83,52.49 9.76,52.52 9.66,52.6 9.56,52.67 9.56,65.28 9.56,65.28 9.56,65.53 9.66,65.6 9.76,65.68
Net_15062 on L3_-MB (solid shape): 162.89,67.06 162.89,66.02 164.12,64.79 164.12,64.21 164.05,64.11 164.02,63.99 164.02,63.97 162.84,62.79 162.84,61.25 162.8,61.24 162.52,60.89 162.8,60.54 162.84,60.53 162.84,60.25 162.48,59.89 161.91,59.89 161.87,59.92 161.68,60.11 161.68,60.71 161.72,60.72 161.96,60.97 161.88,61.31 161.88,64.85 161.92,64.86 162.18,65.2 161.92,65.55 161.88,65.56 161.88,65.93 161.17,66.64 161.17,67.92 161.42,68.17 161.78,68.17
Net_15063 on L3_-MB (solid shape): 109.37,79.81 109.37,79.04 107.5,77.17 107.48,77.17 107.18,77.06 107.07,76.77 107.07,76.75 106.91,76.58 106.09,76.58 103.29,76.58 102.81,77.06 102.81,77.88 103.12,78.19 103.18,78.19 103.18,78.2 103.82,78.2 103.83,78.21 104.06,78.21 105.74,79.88 109.3,79.88
Net_15064 on L3_-MB (solid shape): 69.23,85.1 69.23,84.59 69.43,84.38 69.76,84.38 69.78,84.36 76.14,84.36 76.57,84.79 76.57,84.79 77.33,85.55 85.61,85.55 87.11,84.05 87.11,81.72 83.58,78.19 71.08,78.19 67.45,81.82 67.45,85.17 67.98,85.7 68.62,85.7
Net_15065 on L3_-MB (solid shape): 76.44,85.68 76.44,84.84 76.09,84.49 69.84,84.49 69.48,84.84 69.48,85.68 69.94,86.14 75.98,86.14
Net_15066 on BOTTOM_-MB (solid shape): 172.56,82.24 172.67,82.17 172.8,82.14 172.83,82.12 172.85,82.09 172.85,82.05 172.83,82.02 172.8,82 172.47,81.69 172.76,81.34 172.78,81.34 172.85,81.27 172.86,81.23 172.84,81.19 172.8,81.18 172.66,81.14 172.55,81.05 172.22,81.05 172.12,81.15 171.84,81.15 171.8,81.21 171.75,81.26 171.71,81.35 171.75,81.43 171.92,81.7 171.81,82.01 171.78,82.04 171.97,82.24
Net_15147 on BOTTOM_-MB (solid shape): 33.34,39.47 32.15,39.47 32.15,40.61 33.34,40.61
Net_15176 on BOTTOM_-MB (solid shape): 112.37,10.23 111.56,10.23 111.56,12.14 112.37,12.14
Net_15177 on BOTTOM_-MB (solid shape): 113.62,10.23 112.81,10.23 112.81,12.14 113.62,12.14
Net_15178 on BOTTOM_-MB (solid shape): 114.87,10.23 114.06,10.23 114.06,12.14 114.87,12.14
Net_15179 on BOTTOM_-MB (solid shape): 106.12,10.23 105.31,10.23 105.31,12.14 106.12,12.14
Net_15180 on BOTTOM_-MB (solid shape): 107.37,10.23 106.56,10.23 106.56,12.14 107.37,12.14
Net_15181 on BOTTOM_-MB (solid shape): 108.62,10.23 107.81,10.23 107.81,12.14 108.62,12.14
Net_15182 on BOTTOM_-MB (solid shape): 109.87,10.23 109.06,10.23 109.06,12.14 109.87,12.14
Net_15183 on BOTTOM_-MB (solid shape): 111.12,10.23 110.31,10.23 110.31,12.14 111.12,12.14
Net_15184 on BOTTOM_-MB (solid shape): 101.12,10.23 100.31,10.23 100.31,12.14 101.12,12.14
Net_15185 on BOTTOM_-MB (solid shape): 102.37,10.23 101.56,10.23 101.56,12.14 102.37,12.14
Net_15186 on BOTTOM_-MB (solid shape): 103.62,10.23 102.81,10.23 102.81,12.14 103.62,12.14
Net_15187 on BOTTOM_-MB (solid shape): 104.87,10.23 104.06,10.23 104.06,12.14 104.87,12.14
Net_15188 on BOTTOM_-MB (solid shape): 35.1,39.48 33.6,39.48 33.6,40.57 35.1,40.57
Net_15219 on BOTTOM_-MB (solid shape): 33.12,42.8 33.32,42.8 33.32,43.2 33.52,43.2 33.52,42.8 33.72,42.8 33.72,43.2 33.92,43.2 33.92,42.8 34.12,42.8 34.12,43.2 34.32,43.2 34.32,42.8 34.52,42.8 34.52,43.2 34.72,43.2 34.72,42.8 34.92,42.8 34.92,43.2 35.12,43.2 35.12,42.65 32.92,42.65 32.92,43.2 33.12,43.2
Net_15755 on BOTTOM_-MB (solid shape): 72.63,9.75 72.63,8.94 72.53,8.84 71.65,8.84 71.55,8.94 71.55,9.75 71.65,9.85 72.53,9.85
Net_15756 on BOTTOM_-MB (solid shape): 180.5,42.14 178.5,42.14 178.5,44.14 180.5,44.14
Net_15757 on BOTTOM_-MB (solid shape): 180.5,38.29 178.5,38.29 178.5,40.3 180.5,40.3
Net_15791 on BOTTOM_-MB (solid shape): 158.48,32.8 157.59,32.8 157.59,34.28 158.48,34.28
Net_15792 on BOTTOM_-MB (solid shape): 156.85,32.8 155.96,32.8 155.96,34.28 156.85,34.28
Net_15793 on BOTTOM_-MB (solid shape): 158.47,34.56 157.58,34.56 157.58,36.03 158.47,36.03
Net_15794 on BOTTOM_-MB (solid shape): 156.85,34.56 155.96,34.56 155.96,36.03 156.85,36.03
Net_15795 on BOTTOM_-MB (solid shape): 155.43,16.58 154.54,16.58 154.54,18.05 155.43,18.05
Net_15796 on BOTTOM_-MB (solid shape): 157.06,16.58 156.17,16.58 156.17,18.05 157.06,18.05
Net_15797 on BOTTOM_-MB (solid shape): 152.18,17.87 151.3,17.87 151.3,19.34 152.18,19.34
Net_15798 on BOTTOM_-MB (solid shape): 153.81,17.87 152.92,17.87 152.92,19.34 153.81,19.34
Net_15799 on BOTTOM_-MB (solid shape): 143.91,15.77 143.02,15.77 143.02,17.24 143.91,17.24
Net_15800 on BOTTOM_-MB (solid shape): 142.29,15.77 141.4,15.77 141.4,17.24 142.29,17.24
Net_15801 on BOTTOM_-MB (solid shape): 143.87,10.38 142.98,10.38 142.98,11.86 143.87,11.86
Net_15802 on BOTTOM_-MB (solid shape): 142.24,10.38 141.35,10.38 141.35,11.86 142.24,11.86
Net_15803 on BOTTOM_-MB (solid shape): 143.89,13.91 143,13.91 143,15.38 143.89,15.38
Net_15804 on BOTTOM_-MB (solid shape): 142.26,13.91 141.37,13.91 141.37,15.38 142.26,15.38
Net_15805 on BOTTOM_-MB (solid shape): 143.85,12.14 142.97,12.14 142.97,13.61 143.85,13.61
Net_15806 on BOTTOM_-MB (solid shape): 142.23,12.14 141.34,12.14 141.34,13.61 142.23,13.61
Net_15807 on BOTTOM_-MB (solid shape): 128.73,45.86 127.84,45.86 127.84,47.33 128.73,47.33
Net_15808 on BOTTOM_-MB (solid shape): 130.36,45.86 129.47,45.86 129.47,47.33 130.36,47.33
Net_15809 on BOTTOM_-MB (solid shape): 128.74,44.09 127.85,44.09 127.85,45.56 128.74,45.56
Net_15810 on BOTTOM_-MB (solid shape): 130.36,44.09 129.47,44.09 129.47,45.56 130.36,45.56
Net_15811 on BOTTOM_-MB (solid shape): 128.7,42.35 127.81,42.35 127.81,43.82 128.7,43.82
Net_15812 on BOTTOM_-MB (solid shape): 130.32,42.35 129.43,42.35 129.43,43.82 130.32,43.82
Net_15813 on BOTTOM_-MB (solid shape): 126.58,17.17 125.7,17.17 125.7,18.65 126.58,18.65
Net_15814 on BOTTOM_-MB (solid shape): 128.21,17.17 127.32,17.17 127.32,18.65 128.21,18.65
Net_15815 on BOTTOM_-MB (solid shape): 127.71,15.39 126.82,15.39 126.82,16.86 127.71,16.86
Net_15816 on BOTTOM_-MB (solid shape): 127.69,13.6 126.8,13.6 126.8,15.07 127.69,15.07
Net_15817 on BOTTOM_-MB (solid shape): 120.44,86.54 119.55,86.54 119.55,88.01 120.44,88.01
Net_15818 on BOTTOM_-MB (solid shape): 122.07,86.54 121.18,86.54 121.18,88.01 122.07,88.01
Net_15819 on BOTTOM_-MB (solid shape): 126.08,15.39 125.19,15.39 125.19,16.86 126.08,16.86
Net_15820 on BOTTOM_-MB (solid shape): 126.07,13.6 125.18,13.6 125.18,15.07 126.07,15.07
Net_15821 on BOTTOM_-MB (solid shape): 101.5,82.7 100.61,82.7 100.61,84.18 101.5,84.18
Net_15822 on BOTTOM_-MB (solid shape): 99.88,82.7 98.99,82.7 98.99,84.18 99.88,84.18
Net_15823 on BOTTOM_-MB (solid shape): 78.84,11.14 77.96,11.14 77.96,12.61 78.84,12.61
Net_15824 on BOTTOM_-MB (solid shape): 78.84,9.41 77.96,9.41 77.96,10.88 78.84,10.88
Net_15825 on BOTTOM_-MB (solid shape): 77.22,11.14 76.33,11.14 76.33,12.61 77.22,12.61
Net_15826 on BOTTOM_-MB (solid shape): 77.22,9.41 76.33,9.41 76.33,10.88 77.22,10.88
Net_15827 on BOTTOM_-MB (solid shape): 41.5,74.1 40.61,74.1 40.61,75.57 41.5,75.57
Net_15828 on BOTTOM_-MB (solid shape): 39.88,74.1 38.99,74.1 38.99,75.57 39.88,75.57
Net_15829 on BOTTOM_-MB (solid shape): 31.67,45.32 30.78,45.32 30.78,46.79 31.67,46.79
Net_15830 on BOTTOM_-MB (solid shape): 30.05,45.32 29.16,45.32 29.16,46.79 30.05,46.79
Net_15831 on BOTTOM_-MB (solid shape): 27.56,69.37 26.67,69.37 26.67,70.84 27.56,70.84
Net_15832 on BOTTOM_-MB (solid shape): 25.93,69.37 25.04,69.37 25.04,70.84 25.93,70.84
Net_15833 on BOTTOM_-MB (solid shape): 17.29,31.96 16.4,31.96 16.4,33.43 17.29,33.43
Net_15834 on BOTTOM_-MB (solid shape): 15.66,31.96 14.77,31.96 14.77,33.43 15.66,33.43
Net_15835 on BOTTOM_-MB (solid shape): 13.89,23.06 12.14,23.06 12.14,24.33 13.89,24.33
Net_15836 on BOTTOM_-MB (solid shape): 13.89,25.52 12.14,25.52 12.14,26.79 13.89,26.79
Net_15837 on BOTTOM_-MB (solid shape): 32.17,3.78 30.37,3.78 30.37,5.78 32.17,5.78
Net_15838 on BOTTOM_-MB (solid shape): 23.75,3.78 21.95,3.78 21.95,5.78 23.75,5.78
Net_15859 on BOTTOM_-MB (solid shape): 35.87,42.25 35.47,42.25 35.47,42.05 35.87,42.05 35.87,41.85 35.47,41.85 35.47,41.65 35.87,41.65 35.87,41.45 35.47,41.45 35.47,41.25 35.87,41.25 35.87,41.05 35.09,41.05 35.09,40.78 33.46,40.78 33.46,40.83 32.14,40.83 32.14,42.43 35.31,42.43 35.31,42.45 35.87,42.45
Net_15863 on BOTTOM_-MB (solid shape): 73.66,9.75 73.66,8.94 73.56,8.84 72.68,8.84 72.58,8.94 72.58,9.75 72.68,9.85 73.56,9.85
Net_15901 on BOTTOM_-MB (solid shape): 98.56,83.08 96.71,83.08 96.71,84.1 98.56,84.1
Net_15902 on BOTTOM_-MB (solid shape): 98.56,85.78 96.71,85.78 96.71,86.79 98.56,86.79
Net_16011 on BOTTOM_-MB (solid shape): 117.96,4.64 116.67,4.64 116.67,7.68 117.96,7.68
Net_16012 on BOTTOM_-MB (solid shape): 98.51,4.64 97.22,4.64 97.22,7.68 98.51,7.68
Net_16277 on BOTTOM_-MB (solid shape): 33.72,30.18 30.72,30.18 30.72,33.69 33.72,33.69
Net_16278 on BOTTOM_-MB (solid shape): 161.07,42.71 161.58,42.21 161.58,42.07 161.16,41.65 161.02,41.65 160.52,42.16 160.52,42.3 160.93,42.71
Net_16279 on BOTTOM_-MB (solid shape): 157.89,45.12 158.4,44.62 158.4,44.47 157.98,44.06 157.84,44.06 157.34,44.56 157.34,44.71 157.75,45.12
Net_16280 on BOTTOM_-MB (solid shape): 160.14,41.78 160.64,41.28 160.64,41.13 160.23,40.72 160.09,40.72 159.58,41.22 159.58,41.37 160,41.78
Net_16281 on BOTTOM_-MB (solid shape): 156.96,44.19 157.46,43.68 157.46,43.54 157.05,43.13 156.9,43.13 156.4,43.63 156.4,43.77 156.82,44.19
Net_16282 on BOTTOM_-MB (solid shape): 19.13,29.37 17.84,29.37 17.84,31.37 19.13,31.37
Net_16283 on BOTTOM_-MB (solid shape): 14.95,29.37 13.65,29.37 13.65,31.37 14.95,31.37
Net_16284 on BOTTOM_-MB (solid shape): 24.69,50.41 23.69,50.41 23.59,50.51 23.59,51.32 23.69,51.42 24.69,51.42
Net_16337 on BOTTOM_-MB (solid shape): 25.7,51.32 25.7,50.51 25.6,50.41 24.61,50.41 24.61,51.42 25.6,51.42
Net_17199 on BOTTOM_-MB (solid shape): 93.18,86.03 92.7,86.03 92.7,85.83 93.18,85.83 93.18,85.53 92.7,85.53 92.7,85.33 93.18,85.33 93.18,85.03 92.52,85.03 92.52,85.04 90.5,85.04 90.5,86.18 92.48,86.18 92.48,86.33 93.18,86.33
Net_17200 on BOTTOM_-MB (solid shape): 72.27,85.7 71.79,85.7 71.79,85.5 72.27,85.5 72.27,85.19 71.79,85.19 71.79,85 72.27,85 72.27,84.7 71.61,84.7 71.61,84.71 69.59,84.71 69.59,85.85 71.57,85.85 71.57,86 72.27,86
Net_17211 on BOTTOM_-MB (solid shape): 87.71,5.9 86.62,5.9 86.62,7 87.71,7
Net_17212 on BOTTOM_-MB (solid shape): 78.26,5.45 77.17,5.45 77.17,6.55 78.26,6.55
Net_17287 on BOTTOM_-MB (solid shape): 103.83,79.67 100.32,79.67 100.32,82.34 103.83,82.34
Net_17288 on BOTTOM_-MB (solid shape): 103.83,74.37 100.32,74.37 100.32,77.03 103.83,77.03
Net_17289 on BOTTOM_-MB (solid shape): 95.27,8.48 91.77,8.48 91.77,11.14 95.27,11.14
Net_17290 on BOTTOM_-MB (solid shape): 95.27,3.17 91.77,3.17 91.77,5.84 95.27,5.84
Net_17298 on BOTTOM_-MB (solid shape): 84.78,82.77 82.87,82.77 82.87,85.19 84.78,85.19
Net_17299 on BOTTOM_-MB (solid shape): 78.86,82.77 76.95,82.77 76.95,85.19 78.86,85.19
Net_17300 on BOTTOM_-MB (solid shape): 53.03,52.93 51.12,52.93 51.12,55.35 53.03,55.35
Net_17301 on BOTTOM_-MB (solid shape): 47.11,52.93 45.2,52.93 45.2,55.35 47.11,55.35
Net_17302 on BOTTOM_-MB (solid shape): 13.6,5.62 11.6,5.62 11.6,6.82 13.6,6.82
Net_17303 on BOTTOM_-MB (solid shape): 13.6,2.02 11.6,2.02 11.6,3.22 13.6,3.22
Net_22967 on BOTTOM_-MB (solid shape): 90.1,85.04 88.67,85.04 88.67,86.18 90.1,86.18
Net_22968 on BOTTOM_-MB (solid shape): 69.19,84.71 67.77,84.71 67.77,85.85 69.19,85.85
Net_22969 on BOTTOM_-MB (solid shape): 184.24,33.44 182.77,33.44 182.77,34.33 184.24,34.33
Net_22970 on BOTTOM_-MB (solid shape): 184.24,35.07 182.77,35.07 182.77,35.96 184.24,35.96
Net_22971 on BOTTOM_-MB (solid shape): 182.49,33.44 181.02,33.44 181.02,34.33 182.49,34.33
Net_22972 on BOTTOM_-MB (solid shape): 182.49,35.07 181.02,35.07 181.02,35.96 182.49,35.96
Net_22973 on BOTTOM_-MB (solid shape): 156.13,37.73 154.66,37.73 154.66,38.62 156.13,38.62
Net_22974 on BOTTOM_-MB (solid shape): 156.13,39.36 154.66,39.36 154.66,40.25 156.13,40.25
Net_22975 on BOTTOM_-MB (solid shape): 134.34,38.1 132.87,38.1 132.87,38.99 134.34,38.99
Net_22976 on BOTTOM_-MB (solid shape): 134.34,36.48 132.87,36.48 132.87,37.37 134.34,37.37
Net_22977 on BOTTOM_-MB (solid shape): 129.53,86.41 128.06,86.41 128.06,87.29 129.53,87.29
Net_22978 on BOTTOM_-MB (solid shape): 131.31,86.41 129.84,86.41 129.84,87.29 131.31,87.29
Net_22979 on BOTTOM_-MB (solid shape): 129.53,84.78 128.06,84.78 128.06,85.67 129.53,85.67
Net_22980 on BOTTOM_-MB (solid shape): 131.31,84.78 129.84,84.78 129.84,85.67 131.31,85.67
Net_22981 on BOTTOM_-MB (solid shape): 132.47,38.1 130.99,38.1 130.99,38.99 132.47,38.99
Net_22982 on BOTTOM_-MB (solid shape): 132.47,36.47 130.99,36.47 130.99,37.36 132.47,37.36
Net_22983 on BOTTOM_-MB (solid shape): 131.05,9.88 129.58,9.88 129.58,10.77 131.05,10.77
Net_22984 on BOTTOM_-MB (solid shape): 132.8,9.89 131.33,9.89 131.33,10.77 132.8,10.77
Net_22985 on BOTTOM_-MB (solid shape): 129.29,9.87 127.82,9.87 127.82,10.76 129.29,10.76
Net_22986 on BOTTOM_-MB (solid shape): 131.05,8.25 129.58,8.25 129.58,9.14 131.05,9.14
Net_22987 on BOTTOM_-MB (solid shape): 132.8,8.26 131.33,8.26 131.33,9.15 132.8,9.15
Net_22988 on BOTTOM_-MB (solid shape): 129.29,8.24 127.82,8.24 127.82,9.13 129.29,9.13
Net_22989 on BOTTOM_-MB (solid shape): 118.43,12.43 116.95,12.43 116.95,13.32 118.43,13.32
Net_22990 on BOTTOM_-MB (solid shape): 118.43,10.81 116.95,10.81 116.95,11.7 118.43,11.7
Net_22991 on BOTTOM_-MB (solid shape): 116.65,12.43 115.18,12.43 115.18,13.32 116.65,13.32
Net_22992 on BOTTOM_-MB (solid shape): 116.65,10.81 115.18,10.81 115.18,11.7 116.65,11.7
Net_22993 on BOTTOM_-MB (solid shape): 97.97,80.13 96.49,80.13 96.49,81.02 97.97,81.02
Net_22994 on BOTTOM_-MB (solid shape): 97.97,81.75 96.49,81.75 96.49,82.64 97.97,82.64
Net_22995 on BOTTOM_-MB (solid shape): 85.4,3 83.92,3 83.92,3.89 85.4,3.89
Net_22996 on BOTTOM_-MB (solid shape): 87.13,3 85.65,3 85.65,3.89 87.13,3.89
Net_22997 on BOTTOM_-MB (solid shape): 85.4,1.38 83.92,1.38 83.92,2.27 85.4,2.27
Net_22998 on BOTTOM_-MB (solid shape): 87.13,1.38 85.65,1.38 85.65,2.27 87.13,2.27
Net_22999 on BOTTOM_-MB (solid shape): 59.25,10.42 57.77,10.42 57.77,11.3 59.25,11.3
Net_23000 on BOTTOM_-MB (solid shape): 59.25,12.04 57.77,12.04 57.77,12.93 59.25,12.93
Net_23001 on BOTTOM_-MB (solid shape): 61.01,10.73 59.54,10.73 59.54,11.62 61.01,11.62
Net_23002 on BOTTOM_-MB (solid shape): 61.01,9.1 59.54,9.1 59.54,9.99 61.01,9.99
Net_23003 on BOTTOM_-MB (solid shape): 37.74,74.8 36.26,74.8 36.26,75.69 37.74,75.69
Net_23004 on BOTTOM_-MB (solid shape): 37.74,76.43 36.26,76.43 36.26,77.32 37.74,77.32
Net_23005 on BOTTOM_-MB (solid shape): 38.33,34.9 36.86,34.9 36.86,35.79 38.33,35.79
Net_23006 on BOTTOM_-MB (solid shape): 38.33,36.53 36.86,36.53 36.86,37.42 38.33,37.42
Net_23007 on BOTTOM_-MB (solid shape): 36.53,34.93 35.06,34.93 35.06,35.82 36.53,35.82
Net_23008 on BOTTOM_-MB (solid shape): 36.53,36.56 35.06,36.56 35.06,37.44 36.53,37.44
Net_23009 on BOTTOM_-MB (solid shape): 37.22,31.89 35.75,31.89 35.75,32.78 37.22,32.78
Net_23010 on BOTTOM_-MB (solid shape): 37.22,30.26 35.75,30.26 35.75,31.15 37.22,31.15
Net_23011 on BOTTOM_-MB (solid shape): 21.65,59.1 20.18,59.1 20.18,59.99 21.65,59.99
Net_23012 on BOTTOM_-MB (solid shape): 19.87,59.13 18.4,59.13 18.4,60.02 19.87,60.02
Net_23013 on BOTTOM_-MB (solid shape): 21.65,57.47 20.18,57.47 20.18,58.36 21.65,58.36
Net_23014 on BOTTOM_-MB (solid shape): 19.87,57.51 18.4,57.51 18.4,58.4 19.87,58.4
Net_23170 on BOTTOM_-MB (solid shape): 162.06,31.8 159.32,31.8 159.32,33 162.06,33
Net_23171 on BOTTOM_-MB (solid shape): 162.06,11.1 159.32,11.1 159.32,12.3 162.06,12.3
Net_23172 on BOTTOM_-MB (solid shape): 123.21,34.89 120.47,34.89 120.47,36.09 123.21,36.09
Net_23173 on BOTTOM_-MB (solid shape): 123.21,14.19 120.47,14.19 120.47,15.39 123.21,15.39
Net_23206 on BOTTOM_-MB (solid shape): 41.72,70.28 40.09,70.28 40.09,73.79 41.72,73.79
Net_23207 on BOTTOM_-MB (solid shape): 38.05,70.28 36.42,70.28 36.42,73.79 38.05,73.79
Net_23329 on BOTTOM_-MB (solid shape): 152.65,44.25 149.15,44.25 149.15,46.94 152.65,46.94
Net_23330 on BOTTOM_-MB (solid shape): 152.65,38.62 149.15,38.62 149.15,41.31 152.65,41.31
Net_23331 on BOTTOM_-MB (solid shape): 140.68,44.59 137.18,44.59 137.18,47.28 140.68,47.28
Net_23332 on BOTTOM_-MB (solid shape): 140.68,38.96 137.18,38.96 137.18,41.65 140.68,41.65
Net_23405 on BOTTOM_-MB (solid shape): 165.99,4.06 164.8,4.06 164.8,5.86 165.99,5.86
Net_23406 on BOTTOM_-MB (solid shape): 160.4,4.06 159.21,4.06 159.21,5.86 160.4,5.86
Net_23407 on BOTTOM_-MB (solid shape): 5.44,66.95 3.06,66.95 3.06,68.5 5.44,68.5
Net_23408 on BOTTOM_-MB (solid shape): 5.44,49.7 3.06,49.7 3.06,51.25 5.44,51.25
Net_23409 on BOTTOM_-MB (solid shape): 44.04,52.68 43.78,52.68 43.78,52.48 44.04,52.48 44.04,52.18 43.78,52.18 43.78,51.98 44.04,51.98 44.04,51.68 43.78,51.68 43.78,51.48 44.04,51.48 44.04,51.18 43.78,51.18 43.78,50.98 44.04,50.98 44.04,50.68 43.78,50.68 43.78,50.48 44.04,50.48 44.04,50.18 43.78,50.18 43.78,49.98 44.04,49.98 44.04,49.68 43.78,49.68 43.78,49.48 44.04,49.48 44.04,49.18 43.38,49.18 43.38,52.98 44.04,52.98
Net_24623 on BOTTOM_-MB (solid shape): 146.29,28.01 144.53,28.01 144.53,29.76 146.29,29.76
Net_24625 on BOTTOM_-MB (solid shape): 92.7,84.33 93.18,84.33 93.18,84.03 92.7,84.03 92.7,83.83 93.18,83.83 93.18,83.53 92.7,83.53 92.7,83.33 93.18,83.33 93.18,83.03 92.7,83.03 92.7,82.83 93.18,82.83 93.18,82.53 92.48,82.53 92.48,82.68 88.67,82.68 88.67,83.68 89.49,83.68 89.49,84.69 92.7,84.69
Net_24626 on BOTTOM_-MB (solid shape): 71.79,84 72.27,84 72.27,83.7 71.79,83.7 71.79,83.5 72.27,83.5 72.27,83.19 71.79,83.19 71.79,83 72.27,83 72.27,82.7 71.79,82.7 71.79,82.5 72.27,82.5 72.27,82.19 71.57,82.19 71.57,82.35 67.77,82.35 67.77,83.35 68.58,83.35 68.58,84.36 71.79,84.36
Net_24680 on BOTTOM_-MB (solid shape): 87.05,76.24 84.36,76.24 84.36,79.74 87.05,79.74
Net_24681 on BOTTOM_-MB (solid shape): 92.68,76.24 89.99,76.24 89.99,79.74 92.68,79.74
Net_24682 on BOTTOM_-MB (solid shape): 74.38,75.84 71.69,75.84 71.69,79.34 74.38,79.34
Net_24683 on BOTTOM_-MB (solid shape): 68.75,75.84 66.06,75.84 66.06,79.34 68.75,79.34
Net_24684 on BOTTOM_-MB (solid shape): 52.79,46.44 50.09,46.44 50.09,49.95 52.79,49.95
Net_24685 on BOTTOM_-MB (solid shape): 47.16,46.44 44.46,46.44 44.46,49.95 47.16,49.95
Net_24743 on BOTTOM_-MB (solid shape): 40.67,49.33 39.53,49.33 39.53,50.75 40.67,50.75
Net_24761 on BOTTOM_-MB (solid shape): 152.8,33.14 152.02,33.14 152.02,38.35 152.8,38.35
Net_24762 on BOTTOM_-MB (solid shape): 137.59,33.14 136.81,33.14 136.81,38.35 137.59,38.35
Net_25022 on BOTTOM_-MB (solid shape): 21.3,6.78 19.7,6.78 19.7,7.67 21.3,7.67
Net_25023 on BOTTOM_-MB (solid shape): 21.3,8.51 19.7,8.51 19.7,9.4 21.3,9.4
Net_25034 on BOTTOM_-MB (solid shape): 190.65,5.05 189.25,5.05 189.25,6.95 190.65,6.95
Net_25035 on BOTTOM_-MB (solid shape): 169.95,5.05 168.55,5.05 168.55,6.95 169.95,6.95
Net_25036 on BOTTOM_-MB (solid shape): 48.37,63.07 44.77,63.07 44.77,66.68 48.37,66.68
Net_25037 on BOTTOM_-MB (solid shape): 136.96,83.47 134.7,83.47 134.7,84.59 136.96,84.59
Net_25038 on BOTTOM_-MB (solid shape): 136.96,85.38 134.7,85.38 134.7,86.5 136.96,86.5
Net_25039 on BOTTOM_-MB (solid shape): 138.05,79.34 135.79,79.34 135.79,80.45 138.05,80.45
Net_25040 on BOTTOM_-MB (solid shape): 138.05,81.24 135.79,81.24 135.79,82.36 138.05,82.36
Net_25061 on BOTTOM_-MB (solid shape): 41.68,53.35 41.88,53.35 41.88,53.83 42.18,53.83 42.18,53.35 42.38,53.35 42.38,53.83 42.68,53.83 42.68,53.35 42.88,53.35 42.88,53.83 43.18,53.83 43.18,53.13 43.03,53.13 43.03,49.33 42.03,49.33 42.03,50.14 41.02,50.14 41.02,53.35 41.38,53.35 41.38,53.83 41.68,53.83
Net_25125 on BOTTOM_-MB (solid shape): 151.51,33.14 148.61,33.14 148.61,38.35 151.51,38.35
Net_25126 on BOTTOM_-MB (solid shape): 141,33.14 138.1,33.14 138.1,38.35 141,38.35
Net_25142 on BOTTOM_-MB (solid shape): 141.01,14.56 137.71,14.56 137.71,18.06 141.01,18.06
Net_25143 on BOTTOM_-MB (solid shape): 132.47,14.56 129.17,14.56 129.17,18.06 132.47,18.06
Net_25261 on BOTTOM_-MB (solid shape): 65.76,9.97 64.87,9.97 64.87,12.56 65.76,12.56
Net_25578 on BOTTOM_-MB (solid shape): 152.47,12.86 149.62,12.86 149.62,15.7 152.47,15.7
Net_25579 on BOTTOM_-MB (solid shape): 9.69,12.38 6.84,12.38 6.84,15.22 9.69,15.22
Net_25580 on BOTTOM_-MB (solid shape): 92.32,81.67 92.02,81.67 92.02,81.93 91.82,81.93 91.82,81.67 91.52,81.67 91.52,81.93 91.32,81.93 91.32,81.67 91.02,81.67 91.02,81.93 90.82,81.93 90.82,81.67 90.52,81.67 90.52,81.93 90.32,81.93 90.32,81.67 90.02,81.67 90.02,81.93 89.82,81.93 89.82,81.67 89.52,81.67 89.52,81.93 89.32,81.93 89.32,81.67 89.02,81.67 89.02,81.93 88.82,81.93 88.82,81.67 88.52,81.67 88.52,82.33 92.32,82.33
Net_25581 on BOTTOM_-MB (solid shape): 71.42,81.34 71.12,81.34 71.12,81.6 70.92,81.6 70.92,81.34 70.62,81.34 70.62,81.6 70.42,81.6 70.42,81.34 70.12,81.34 70.12,81.6 69.92,81.6 69.92,81.34 69.62,81.34 69.62,81.6 69.42,81.6 69.42,81.34 69.12,81.34 69.12,81.6 68.92,81.6 68.92,81.34 68.62,81.34 68.62,81.6 68.42,81.6 68.42,81.34 68.12,81.34 68.12,81.6 67.92,81.6 67.92,81.34 67.62,81.34 67.62,82 71.42,82
Net_25582 on BOTTOM_-MB (solid shape): 119.92,2.73 118.77,2.73 118.77,3.98 119.92,3.98
Net_25583 on BOTTOM_-MB (solid shape): 119.92,5.99 118.77,5.99 118.77,7.24 119.92,7.24
Net_25587 on BOTTOM_-MB (solid shape): 126.86,81.02 126.55,81.02 126.55,81.28 126.36,81.28 126.36,81.02 126.05,81.02 126.05,81.28 125.86,81.28 125.86,81.02 125.55,81.02 125.55,81.28 125.36,81.28 125.36,81.02 125.05,81.02 125.05,81.68 126.86,81.68
Net_25662 on BOTTOM_-MB (solid shape): 122.17,7.66 118.81,7.66 118.81,10.1 122.17,10.1
Net_25663 on BOTTOM_-MB (solid shape): 127.71,84.37 127.18,84.37 127.18,84.18 127.71,84.18 127.71,83.87 127.18,83.87 127.18,83.68 127.71,83.68 127.71,83.37 124.08,83.37 124.08,84.6 127.18,84.6 127.18,84.68 127.71,84.68
Net_25810 on BOTTOM_-MB (solid shape): 192.5,38.7 190.7,38.7 190.7,39.89 192.5,39.89
Net_25811 on BOTTOM_-MB (solid shape): 192.5,33.11 190.7,33.11 190.7,34.3 192.5,34.3
Net_25812 on BOTTOM_-MB (solid shape): 32,80.8 30.2,80.8 30.2,81.99 32,81.99
Net_25813 on BOTTOM_-MB (solid shape): 32,71.21 30.2,71.21 30.2,72.4 32,72.4
Net_25994 on BOTTOM_-MB (solid shape): 39.68,53.35 39.88,53.35 39.88,53.83 40.18,53.83 40.18,53.35 40.38,53.35 40.38,53.83 40.68,53.83 40.68,53.17 40.67,53.17 40.67,51.15 39.53,51.15 39.53,53.13 39.38,53.13 39.38,53.83 39.68,53.83
Net_25995 on BOTTOM_-MB (solid shape): 127.18,82.68 127.71,82.68 127.71,82.37 127.18,82.37 127.18,82.18 127.71,82.18 127.71,81.87 127.18,81.87 127.18,81.95 124.08,81.95 124.08,82.8 127.18,82.8
Net_25998 on BOTTOM_-MB (solid shape): 117.53,73.89 116.26,73.89 116.26,74.81 117.53,74.81
Net_25999 on BOTTOM_-MB (solid shape): 115.31,73.89 114.04,73.89 114.04,74.81 115.31,74.81
Net_26000 on BOTTOM_-MB (solid shape): 117.53,75.54 116.26,75.54 116.26,76.46 117.53,76.46
Net_26001 on BOTTOM_-MB (solid shape): 115.31,75.54 114.04,75.54 114.04,76.46 115.31,76.46
Net_26035 on BOTTOM_-MB (solid shape): 144.46,5.1 143.64,5.1 143.64,7.1 144.46,7.1
Net_26036 on BOTTOM_-MB (solid shape): 137.56,5.1 136.74,5.1 136.74,7.1 137.56,7.1
Net_26111 on BOTTOM_-MB (solid shape): 74.71,87.43 73.37,87.43 73.37,88.37 74.71,88.37
Net_26112 on BOTTOM_-MB (solid shape): 76.33,87.43 74.98,87.43 74.98,88.37 76.33,88.37
Net_26113 on BOTTOM_-MB (solid shape): 74.71,85.75 73.37,85.75 73.37,86.69 74.71,86.69
Net_26114 on BOTTOM_-MB (solid shape): 76.33,85.75 74.98,85.75 74.98,86.69 76.33,86.69
Net_26115 on BOTTOM_-MB (solid shape): 38.28,56.21 36.93,56.21 36.93,57.15 38.28,57.15
Net_26116 on BOTTOM_-MB (solid shape): 38.28,57.89 36.93,57.89 36.93,58.83 38.28,58.83
Net_26117 on BOTTOM_-MB (solid shape): 39.92,55.71 38.58,55.71 38.58,56.65 39.92,56.65
Net_26118 on BOTTOM_-MB (solid shape): 39.92,57.39 38.58,57.39 38.58,58.33 39.92,58.33
Net_26125 on BOTTOM_-MB (solid shape): 146.14,45.03 143.73,45.03 143.73,46.94 146.14,46.94
Net_26126 on BOTTOM_-MB (solid shape): 146.14,39.11 143.73,39.11 143.73,41.02 146.14,41.02
Net_26127 on BOTTOM_-MB (solid shape): 134.16,45.26 131.74,45.26 131.74,47.17 134.16,47.17
Net_26128 on BOTTOM_-MB (solid shape): 134.16,39.34 131.74,39.34 131.74,41.25 134.16,41.25
Net_26129 on BOTTOM_-MB (solid shape): 82.94,79.22 80.53,79.22 80.53,81.13 82.94,81.13
Net_26130 on BOTTOM_-MB (solid shape): 82.94,73.3 80.53,73.3 80.53,75.21 82.94,75.21
Net_26131 on BOTTOM_-MB (solid shape): 78.14,79.2 75.73,79.2 75.73,81.1 78.14,81.1
Net_26132 on BOTTOM_-MB (solid shape): 78.14,73.28 75.73,73.28 75.73,75.18 78.14,75.18
Net_26133 on BOTTOM_-MB (solid shape): 37.12,54.01 34.71,54.01 34.71,55.91 37.12,55.91
Net_26134 on BOTTOM_-MB (solid shape): 37.12,48.09 34.71,48.09 34.71,49.99 37.12,49.99
Net_26240 on BOTTOM_-MB (solid shape): 39.73,36.98 38.71,36.98 38.71,38.83 39.73,38.83
Net_26241 on BOTTOM_-MB (solid shape): 42.42,36.98 41.41,36.98 41.41,38.83 42.42,38.83
Net_26259 on BOTTOM_-MB (solid shape): 121.91,81.09 119.25,81.09 119.25,84.59 121.91,84.59
Net_26260 on BOTTOM_-MB (solid shape): 116.61,81.09 113.94,81.09 113.94,84.59 116.61,84.59
Net_26261 on BOTTOM_-MB (solid shape): 73.71,3.34 71.04,3.34 71.04,6.85 73.71,6.85
Net_26262 on BOTTOM_-MB (solid shape): 68.4,3.34 65.74,3.34 65.74,6.85 68.4,6.85
Net_26263 on BOTTOM_-MB (solid shape): 44.17,40.78 41.51,40.78 41.51,44.29 44.17,44.29
Net_26264 on BOTTOM_-MB (solid shape): 38.87,40.78 36.2,40.78 36.2,44.29 38.87,44.29
Net_26265 on BOTTOM_-MB (solid shape): 28.82,47.14 27.7,47.14 27.7,49.41 28.82,49.41
Net_26266 on BOTTOM_-MB (solid shape): 30.73,47.14 29.61,47.14 29.61,49.41 30.73,49.41
Net_26299 on BOTTOM_-MB (solid shape): outline of 980 points within 3.26,0.51 136.24,12.86
Net_26300 on BOTTOM_-MB (solid shape): outline of 1334 points within 136.6,0.51 197.49,89.49
Net_26301 on BOTTOM_-MB (solid shape): 196.91,2.14 196.91,1.35 196.71,1.15 192.34,1.15 192.09,1.4 192.09,2.01 192.32,2.24 193.61,2.24 193.97,1.88 194.06,1.88 194.35,1.76 194.63,1.88 195.06,1.88 195.44,2.27 196.79,2.27
Net_26302 on BOTTOM_-MB (solid shape): outline of 217 points within 77.1,2.22 89.75,12.88
Net_26303 on BOTTOM_-MB (solid shape): 67.34,10.22 68.61,10.22 68.87,9.96 68.87,9.86 68.88,9.82 68.89,9.79 68.91,9.76 68.94,9.73 68.97,9.71 69.01,9.69 69.04,9.69 69.06,9.69 69.44,9.69 69.48,9.69 69.56,9.61 69.56,7.93 70.38,7.1 70.41,7.1 70.74,6.78 70.74,2.59 70.46,2.32 65.6,2.32 65.41,2.5 65.41,4.09 64.17,5.33 64.17,6.11 65.37,6.11 65.37,6.37 65.11,6.37 65.11,6.11 64.17,6.11 64.17,6.99 64.38,7.19 65.2,7.19 65.56,7.55 65.56,8.87 65.61,8.92 69.13,8.92 69.13,9.18 68.87,9.18 68.87,8.92 65.61,8.92 65.94,9.26 65.94,10.4 66.09,10.55 67.01,10.55
Net_26304 on BOTTOM_-MB (solid shape): outline of 212 points within 118.73,2.56 135.73,9.32
Net_26305 on BOTTOM_-MB (solid shape): 32.79,7.98 32.89,7.91 32.86,7.8 32.8,6.09 34.51,6.15 34.6,6.19 34.68,6.13 35.36,6.16 34.92,6.68 34.82,6.7 34.79,6.79 34.72,7.34 34.4,7.8 34.37,7.91 34.46,7.98 36.16,7.98 37.66,6.48 37.66,4.6 37.51,4.45 36.92,4.45 36.89,4.48 34.63,4.48 32.85,2.7 30.09,2.7 30.09,5.77 30.49,6.18 30.54,6.18 32.35,7.98
Net_26306 on BOTTOM_-MB (solid shape): 71.34,9.07 71.34,8.56 71.86,8.04 75.61,8.04 76.93,6.73 76.93,6.46 76.74,6.28 75.96,6.28 75.83,6.41 74.84,6.41 74.76,6.41 74.26,5.9 74.26,3.87 72.99,2.6 71.59,2.6 71.08,3.1 71.08,6.91 70.19,7.8 70.19,8.66 70.78,8.66 70.78,8.92 70.53,8.92 70.53,8.66 70.19,8.66 70.19,8.82 70.57,9.2 71.21,9.2
Net_26307 on BOTTOM_-MB (solid shape): 91.25,6.13 95.22,6.13 95.54,5.8 95.54,3.28 95.2,2.93 90.83,2.93 88.95,4.81 88.95,4.82 88.85,4.97 88.7,5.07 88.69,5.07 87.93,5.83 87.93,5.93 88.03,6.02 90.44,6.02 90.58,6.16 91.21,6.16
