# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_B1: length 40.5
  TOP w0.152: RN1207.4 74.48,16.94 74.48,18.25 73.74,18.99 v3(73.74,19.99) 73.74,20 73.74,20.64 73.51,20.87 RAM2.P2
  L3 w0.114: v3(79.64,39.76) 80.06,39.35 80.06,32.54 80.17,32.43 80.71,32.43 80.82,32.31 80.82,32.09 80.71,31.97 80.17,31.97 80.06,31.86 80.06,31.63 80.17,31.51 80.71,31.51 80.82,31.4 80.82,31.17 80.71,31.06 80.17,31.06 80.06,30.94 80.06,30.71 80.17,30.6 80.71,30.6 80.82,30.49 80.82,30.26 80.71,30.14 80.17,30.14 80.06,30.03 80.06,29.66 80.77,28.94 80.77,26.8 79.95,25.98 79.95,23.72 76.63,20.4 74.14,20.4 v3(73.74,19.99)
  BOTTOM w0.076: 80.48,40.73 80.48,43.01 80.5,43.08 80.5,43.36 80.46,43.46 80.46,44.46 80.44,44.49 80.44,44.95 80.62,45.12 80.85,45.12 81.01,45.29 81.01,45.44 80.78,45.68 80.2,45.68 80.12,45.75 CPU1.AB32
  BOTTOM w0.114: v3(79.64,39.76) 79.91,39.76 80.02,39.86 80.02,40.27 80.48,40.73
M_A_B2: length 41.3
  TOP w0.152: RAM2.N2 72.86,20.87 v3(72.86,19.97) 72.86,18 72.93,17.93 RN1203.4
  L3 w0.114: v3(80.57,46.72) 80.98,46.32 80.98,44.1 81.09,43.99 81.73,43.99 81.83,43.89 81.83,43.63 81.73,43.53 81.09,43.53 80.98,43.42 80.98,41.9 81.09,41.79 81.38,41.79 81.49,41.67 81.49,41.44 81.38,41.33 81.09,41.33 80.98,41.22 80.98,40.99 81.09,40.87 81.38,40.87 81.49,40.76 81.49,40.53 81.38,40.42 81.09,40.42 80.98,40.3 80.98,34.1 81.66,33.42 81.66,24.17 77.05,19.56 73.27,19.56 v3(72.86,19.97)
  BOTTOM w0.152: v3(80.57,46.72) 80.58,46.72 CPU1.AC31
M_A_B3: length 39.2
  TOP w0.076: 73.3,19.79 73.3,20.05 73.16,20.19 v3(73.16,21.27)
  TOP w0.152: v3(73.16,21.27) 72.92,21.58 72.86,21.67 RAM2.N3 ; RN1203.3 73.58,18.02 73.3,18.29 73.3,19.79
  L3 w0.114: v3(78.74,45.67) 78.22,45.67 77.93,45.37 77.93,44.18 77.81,44.07 77.34,44.07 77.23,43.96 77.23,43.73 77.34,43.61 78.42,43.61 78.53,43.5 78.53,43.28 78.41,43.16 77.34,43.16 77.23,43.04 77.23,42.81 77.34,42.7 77.81,42.7 77.93,42.58 77.93,41.43 78.44,40.91 78.44,34.64 78.44,34.34 78.44,34.03 78.75,33.72 78.75,25.14 77.14,23.52 77.14,23.36 77.35,23.16 77.35,22.99 77.18,22.83 77.02,22.83 76.82,23.04 76.66,23.04 76.49,22.88 76.49,22.71 76.7,22.51 76.7,22.35 76.54,22.19 76.38,22.19 76.17,22.39 76.01,22.39 75.29,21.68 73.56,21.68 v3(73.16,21.27)
  BOTTOM w0.152: v3(78.74,45.67) CPU1.Y32
M_A_B4: length 36.7
  TOP w0.076: 72.36,19.56 72.36,19.99 72.53,20.16 72.53,20.52 72.51,20.55 v3(72.51,21.27)
  TOP w0.152: 72.36,19.56 72.36,17.21 R1208.2 ; RAM2.M3 72.21,21.67 v3(72.51,21.27)
  L3 w0.114: v3(78.76,46.27) 78.71,46.32 77.9,46.32 77.59,46.01 77.59,45.1 76.89,44.4 76.89,41.26 77.13,41.02 77.74,41.02 78.08,40.69 78.08,34.79 78.08,34.49 78.08,33.88 78.38,33.57 78.38,25.6 75.25,22.47 73.04,22.47 72.51,21.94 v3(72.51,21.27)
  BOTTOM w0.152: CPU1.W32 v3(78.76,46.27)
M_A_B5: length 40.9
  TOP w0.127: 68.19,20.32 68.19,20.54 67.99,20.74 67.99,21.06 RAM2.F3
  TOP w0.152: 68.19,20.32 68.19,19.89 v3(68.03,18.36) R1207.2
  L6 w0.152: v3(68.03,18.36) 68.37,18.68 68.64,18.78 69.06,18.83 70.42,18.95 74.74,18.95 77.84,20.94 79.88,22.98 80.16,23.52 80.72,27.08 81.6,33.62 v3(81.6,34.63)
  BOTTOM w0.076: CPU1.AC34 80.91,44.53 81.02,44.24 81.05,43.88 81.05,43.25 81.15,43.07 81.15,42.66 81.1,42.61 81,42.34 81,40.53 80.58,40.11 80.58,36.31 81.24,35.05 v3(81.6,34.63)
M_A_B6: length 43.1
  TOP w0.127: v3(67.34,21.25) 67.34,21 67.34,19.55 66.22,18.42 66.22,17.09 RN1205.6
  TOP w0.152: v3(67.34,21.25) 67.34,21.35 RAM2.E3
  L3 w0.114: v3(79.69,46.15) 79.71,46.13 79.71,43.42 79.57,42.68 79.26,41.61 79.21,41.34 79.18,40.73 79.18,34.34 79.49,34.03 79.49,23.85 76.37,20.74 76.02,20.63 74.06,20.63 72.88,20.4 72.75,20.37 72.61,20.27 72.41,20.07 72.2,19.93 67.6,19.93 67.36,20.17 67.35,20.2 67.35,21.24 67.34,21.25 67.34,21.25 v3(67.34,21.25)
  BOTTOM w0.152: v3(79.69,46.15) CPU1.AB31
M_A_B7: length 41.2
  TOP w0.152: RN1205.5 66.76,18.49 67.65,19.39 67.65,20.23 v3(67.77,20.35) 67.66,20.46 67.66,20.87 RAM2.E2
  L3 w0.114: v3(67.77,20.35) 68.24,20.81 72.02,20.81 72.06,20.85 75.81,20.85 79.12,24.16 79.12,33.87 78.81,34.18 78.81,34.49 78.81,41.54 78.36,41.99 78.36,42.33 79.21,43.18 79.21,46.28 v3(79.69,46.75)
  BOTTOM w0.152: CPU1.Y31 v3(79.69,46.75)
M_A_B8: length 42.7
  TOP w0.152: RAM2.D2 67.01,20.87 67.01,20.54 v3(66.87,20.39) 66.87,19.47 65.67,18.27 RN1205.7
  L6 w0.152: v3(66.87,20.39) 67.28,20.8 75.3,20.8 77.46,22.97 77.99,22.97 78.85,23.83 78.85,31.13 78.88,31.15 78.88,31.8 80.25,33.17 80.25,37.15 80.05,37.35 v3(79.59,37.35)
  BOTTOM w0.076: CPU1.AC36 80.73,43.49 80.99,43.03 80.99,42.73 80.83,42.57 80.83,40.58 80.4,40.16 80.4,39.87
  BOTTOM w0.114: 80.4,39.87 80.4,38.53 80.3,38.43 80.13,38.43 80.03,38.33 80.03,37.93 80.11,37.85 80.27,37.85 80.35,37.76 80.35,37.23 80.04,36.92 80.04,36.13 79.94,36.03 79.56,36.03 79.46,36.13 79.46,37.22 v3(79.59,37.35)
M_A_B9: length 40.8
  TOP w0.152: RN1205.8 65.08,18.09 66.22,19.23 v3(66.22,20.39) 66.36,20.53 66.36,20.87 RAM2.C2
  L6 w0.152: v3(79.64,38.58) 79.64,38.55 80.24,37.96 80.3,37.96 80.86,37.4 80.86,32.92 79.51,31.58 79.51,23.63 78.24,22.36 77.71,22.36 75.55,20.2 75.17,20.2 74.53,19.56 72.69,19.56 72.41,19.84 67.17,19.84 67.12,19.78 66.61,19.78 66.26,20.14 66.26,20.36 v3(66.22,20.39)
  BOTTOM w0.076: CPU1.AC37 80.66,42.82 80.66,40.65 80.2,40.19 80.2,38.88 79.9,38.58 v3(79.64,38.58)
M_A_CKE0: length 54.8
  TOP w0.152: v3(51.47,25.8) 51.78,25.41 RAM1.K3 ; R1220.2 52.44,20.96 52.44,22.93 v2(52.67,23.15)
  L3 w0.114: v3(51.47,25.8) 51.47,24.44 52.67,23.25 v2(52.67,23.15)
  L5 w0.152: v3(75.45,40.21) 75.78,40.54 75.78,42.01 74.58,43.21 68.7,43.21 68.23,42.74 68.21,42.74 67.94,42.47 67.94,42.46 66.05,40.57 61.88,40.57 59.46,38.15 59.46,37.94 60.59,36.81 60.59,36.59 60.38,36.37 60.16,36.37 59.03,37.5 58.82,37.5 58.39,37.07 58.39,36.86 59.53,35.72 59.53,35.5 59.31,35.29 59.09,35.29 57.95,36.43 57.74,36.43 57.3,35.99 57.3,31.89 55.76,30.35 55.76,29.64 55.51,29.38 53.89,29.38 52.99,28.49 52.57,28.49 51.47,27.39 v3(51.47,25.8)
  BOTTOM w0.152: v3(75.45,40.21) 75.45,40.46 76.41,41.43 76.41,41.8 76.72,42.11 76.72,42.63 76.6,42.75 76.6,43.23 CPU1.U36
M_A_CKE1: length 52.9
  TOP w0.102: 51.78,26.21 RAM1.K4 52.09,25.9 52.09,23.74 52.16,23.68 52.16,23.2 51.86,22.91
  TOP w0.152: R1221.2 51.47,20.84 51.47,22.44 51.86,22.84 51.86,22.91 ; v3(52.1,26.59) 51.78,26.27 51.78,26.21
  L5 w0.152: v3(75.45,39.63) 75.42,39.63 75.02,40.03 75.02,41.27 75.16,41.41 75.16,41.77 74.32,42.6 70.12,42.6 68.55,41.04 68.34,41.04 68.06,41.32 67.84,41.32 67.63,41.1 67.63,40.89 67.91,40.61 67.91,40.39 67.47,39.96 64.94,39.96 64.41,39.43 64.19,39.43 63.89,39.73 63.67,39.73 63.46,39.52 63.46,39.3 63.76,39 63.76,38.79 63.33,38.35 63.11,38.35 62.11,39.36 61.89,39.36 61.68,39.14 61.68,38.93 62.65,37.95 62.65,37.67 62.44,37.46 62.22,37.46 61.2,38.48 60.94,38.48 60.75,38.28 60.75,38.07 61.79,37.03 61.79,36.81 57.91,32.93 57.91,30.04 56.02,28.15 53.55,28.15 52.1,26.69 v3(52.1,26.59)
  BOTTOM w0.152: CPU1.U37 77.01,42.8 77.01,42.06 76.65,41.7 76.65,41.33 76.16,40.83 76.16,40.82 76.14,40.8 76.14,40.32 75.45,39.63 v3(75.45,39.63)
M_A_CKE2: length 51.6
  TOP w0.076: v3(71.24,21.27) 71.24,20.78 71,20.54 71,19.66
  TOP w0.152: v3(71.24,21.27) 71.24,21.27 71.23,21.29 70.91,21.67 RAM2.K3 ; R1249.2 70.83,19.49 71,19.66
  L6 w0.152: v3(71.24,21.27) 71.27,21.27 71.66,21.67 72.08,21.67 72.89,22.47 75.94,22.47 77.28,23.81 77.28,24.03 76.35,24.95 76.35,25.17 76.57,25.38 76.79,25.38 77.71,24.46 77.92,24.46 78.22,24.76 78.22,26.83 78.07,26.99 76.77,26.99 76.62,27.14 76.62,27.44 76.77,27.6 78.07,27.6 78.22,27.75 78.22,28.05 78.07,28.2 76.62,28.2 76.46,28.36 76.46,28.66 76.62,28.81 78.09,28.81 78.24,28.97 78.24,29.27 78.09,29.42 76.26,29.42 76.11,29.58 76.11,29.86 76.28,30.03 78.09,30.03 78.24,30.19 78.24,30.49 78.09,30.64 76.93,30.64 76.78,30.8 76.78,31.1 76.93,31.25 78.12,31.25 78.27,31.41 78.27,32.06 79.64,33.43 79.64,36.68 78.99,37.34 78.99,37.56 78.76,37.79 78.76,39.98 78.75,39.99 78.34,40.4 78.34,44.01 v3(77,45.36)
  BOTTOM w0.152: CPU1.U34 v3(77,45.36)
M_A_CKE3: length 54.7
  TOP w0.152: R1252.2 68.65,17.1 v3(68.65,18.31) ; RAM2.K4 70.91,22.47 71.21,22.1 71.22,22.09 71.22,22.09 v3(71.22,22.09)
  L5 w0.076: v3(71.22,22.09) 71.22,22.09 71.22,22.09 71.19,22.09 70.79,22.49 70.44,22.49 69.21,21.27
  L5 w0.152: v3(68.65,18.31) 68.65,19.62 68.23,20.04 68.23,20.55 68.48,20.8 68.75,20.8 69.21,21.26 69.21,21.27
  L6 w0.152: v3(71.22,22.09) 71.22,22.09 71.22,22.09 71.19,22.09 70.8,22.48 70.41,22.48 70.17,22.72 70.17,22.73 70.15,22.74 70.15,23.85 70.77,24.46 74.78,24.46 75.42,25.09 75.42,25.45 75.43,25.46 75.43,26.62 75.28,26.77 74.52,26.77 74.37,26.93 74.37,27.23 74.52,27.38 75.28,27.38 75.43,27.54 75.43,27.84 75.28,27.99 74.52,27.99 74.37,28.14 74.37,28.45 74.52,28.6 75.28,28.6 75.43,28.75 75.43,29.44 75.29,29.58 74.36,29.58 74.12,29.82 73.11,29.82 72.19,30.74 69.66,30.74 69.25,31.16 69.25,31.49 69.4,31.65 76.46,31.65 76.68,31.86 77.21,31.86 79.03,33.68 79.03,36.43 78.38,37.08 78.38,37.31 78.15,37.53 78.15,39.73 77.73,40.14 77.73,41.79 76.45,43.07 v3(76.45,44.51)
  BOTTOM w0.152: CPU1.U35 v3(76.45,44.51)
M_A_CLK0: length 50.2
  TOP w0.14: RAM1.J3 51.13,25.41 51.4,24.89 51.44,24.77 51.45,24.75 51.45,24.48 51.26,24.28 51.19,24.11 51.19,23.54 v3(51.17,23.52) 51.02,23.38 51.01,23.19 51.01,22.85 50.32,22.16 50.32,20.98 R1246.2
  L5 w0.14: v3(76.92,46.81) 77.13,46.81 77.69,46.25 77.69,42.65 76.78,41.74 76.78,35.35 75.69,34.26 72.07,34.26 71.69,34.64 63.67,34.64 60.08,31.04 60.08,28.76 57.14,25.82 56.34,25.02 56.12,25.02 54.3,25.02 53.46,24.19 51.84,24.19 v3(51.17,23.52)
  BOTTOM w0.14: CPU1.V31 v3(76.92,46.81)
M_A_CLK1: length 38.1
  TOP w0.14: R1215.2 69.54,17.23 69.54,17.98 69.26,18.25 v2(69.26,18.25) ; v3(69.91,21.27) 70.23,21.67 RAM2.J3
  L3 w0.114: v3(69.91,21.27) 69.91,23.84 70.48,24.41 75.53,24.41 77.71,26.59 77.71,33.29 76.65,34.36 76.65,40.03 75.52,41.15 75.52,45.73 75.76,45.98 75.77,45.98 v3(75.97,46.17)
  L5 w0.14: v2(69.26,18.25) 69.26,20.66 69.67,21.06 69.7,21.06 v3(69.91,21.27)
  BOTTOM w0.14: CPU1.T31 v3(75.97,46.17)
M_A_CLK#0: length 50.3
  TOP w0.14: RAM1.J2 51.01,24.61 50.9,24.5 50.9,24.1 50.77,23.97 50.67,23.97 50.53,23.83 50.53,23.61 v3(50.59,23.55) 50.73,23.39 50.72,23.2 50.72,22.97 50.02,22.28 50.02,21.16 R1214.2
  L5 w0.14: v3(76.94,46.08) 77.09,46.22 77.29,46.22 77.43,46.08 77.43,42.76 76.51,41.85 76.51,35.46 75.58,34.53 72.18,34.53 71.81,34.91 63.56,34.91 59.81,31.15 59.81,28.87 56.88,25.93 56.88,25.93 56.23,25.29 54.19,25.29 53.35,24.45 51.73,24.45 51.55,24.28 50.56,24.28 50.39,24.1 50.39,23.69 50.53,23.55 v3(50.59,23.55)
  BOTTOM w0.14: CPU1.V32 77.39,46.12 77.26,46.25 77.12,46.25 v3(76.94,46.08)
M_A_CLK#1: length 38.7
  TOP w0.14: v3(70.59,21.27) 70.6,20.97 70.59,20.96 70.48,20.85 70.28,20.85 RAM2.J2 ; v2(69.99,18.25) 69.99,18.24 69.83,18.08 69.83,17.23 R1216.2
  L3 w0.114: v3(70.59,21.27) 70.59,21.5 70.13,21.96 70.13,23.75 70.57,24.19 75.62,24.19 77.93,26.5 77.93,33.38 76.86,34.45 76.86,40.11 75.74,41.24 75.74,45.37 v3(75.93,45.56)
  L5 w0.14: v3(70.59,21.27) 70.59,21.17 70.22,20.8 69.78,20.8 69.53,20.54 69.53,18.93 69.99,18.47 v2(69.99,18.25)
  BOTTOM w0.14: CPU1.T32 76.58,45.74 76.56,45.6 76.39,45.48 v3(75.93,45.56)
M_A_CS#0: length 62.8
  TOP w0.152: v3(71.88,21.25) 71.87,21.25 71.88,21.28 71.56,21.67 RAM2.L3 ; v2(62.16,24.95) 61.56,24.35 R1217.2 ; v3(52.75,25.79) 52.74,25.79 52.74,25.79 52.43,25.41 RAM1.L3
  L5 w0.152: v3(81.5,45.72) 81.5,45.29 80.72,44.52 80.72,37.43 80.51,36.87 80.51,33.99 76.29,29.77 74.52,29.77 74,30.28 74,30.3 73.75,30.55 73.73,30.55 73.25,31.04 69.96,31.04 69.4,31.6 66.22,31.6 63.12,28.5 63.12,26.57 63.1,26.22 62.16,25.28 v2(62.16,24.95)
  L8 w0.114: v3(71.88,21.25) 71.87,21.25 71.87,21.24 71.86,21.38 71.5,21.7 70.76,21.7 70.75,21.69 70.43,21.69 70.35,21.77 70.32,21.77 70.2,21.89 70.2,22.15 69.88,22.46 65.34,22.46 64.9,22.65 64.28,22.96 62.99,23.71 62.85,23.82 62.16,24.51 v2(62.16,24.95) 62.16,25.47 61.36,26.27 59.95,26.27 59.46,25.79 58.49,25.79 58.38,25.91 58.38,26.06 58.26,26.18 58.04,26.18 57.92,26.06 57.92,25.91 57.81,25.79 57.58,25.79 57.46,25.91 57.46,26.07 57.35,26.19 57.12,26.19 57.01,26.07 57.01,25.91 56.89,25.79 52.75,25.79 52.74,25.79 52.74,25.79 v3(52.75,25.79)
  BOTTOM w0.152: CPU1.AE32 81.67,45.89 v3(81.5,45.72)
M_A_CS#1: length 63.6
  TOP w0.127: v2(62.86,24.78) R1218.2
  TOP w0.152: v3(71.91,22.07) 71.91,22.07 71.9,22.08 71.56,22.47 RAM2.L4 ; RAM1.L4 52.43,26.21 v3(52.73,26.62)
  L5 w0.152: v2(62.86,24.78) 63.46,25.71 63.73,25.98 63.73,28.25 66.47,30.99 69.15,30.99 69.71,30.43 72.09,30.43 72.66,29.86 72.66,29.47 73.21,28.92 73.57,28.92 73.57,28.92 76.31,28.92 81.13,33.75 81.13,40.01 81.69,41.51 82.28,43.47 82.75,45.28 82.98,45.92 v3(83.25,46.19)
  L8 w0.114: v3(71.91,22.07) 71.48,22.5 71.07,22.5 71.07,22.5 70.41,22.5 70.35,22.57 70.12,22.79 70.12,23.91 69.95,24.09 66.88,24.09 66.77,24.2 66.77,24.28 66.65,24.39 66.42,24.39 66.31,24.28 66.31,24.2 66.19,24.09 65.97,24.09 65.85,24.2 65.85,24.28 65.74,24.39 65.51,24.39 65.39,24.28 65.39,24.2 65.28,24.09 64.45,24.09 63.76,24.78 v2(62.86,24.78) 62.86,25.29 61.51,26.64 55.98,26.64 55.52,26.18 53.17,26.18 52.74,26.62 v3(52.73,26.62)
  BOTTOM w0.152: CPU1.AF32 83.25,46.19 v3(83.25,46.19)
M_A_DQ0: length 32.8
  TOP w0.152: v3(52.71,28.94) 53.08,29.41 RAM1.M8
  L3 w0.114: v3(65.45,48.74) 64.71,48.74 63.93,47.96 62.62,47.96 61.75,47.08 61.75,45.46 62.14,45.07 62.14,40.96 59.2,38.02 55.79,38.02 55.77,38 51.94,34.17 51.94,29.71 v3(52.71,28.94)
  BOTTOM w0.076: v3(65.45,48.74) 65.45,48.97 65.68,49.4 65.93,49.59 66.28,49.75 66.51,49.81 CPU1.A26
M_A_DQ1: length 33.9
  TOP w0.152: v3(52.73,29.81) 52.75,29.81 53.08,30.21 RAM1.M9
  L3 w0.114: v3(52.73,29.81) 52.15,30.39 52.15,33.85 55.71,37.42 55.93,37.64 59.34,37.64 62.51,40.8 62.51,45.22 62.15,45.58 62.15,45.59 62.12,45.62 62.12,46.89 62.77,47.54 v3(64.07,47.54)
  BOTTOM w0.076: v3(64.07,47.54) 64.07,48.31 65.73,49.97 65.91,50.1 66.19,50.17 67.12,50.17 67.18,50.23 68.02,50.23 68.06,50.21 68.17,50.15 68.58,50.15 69.44,50.08 CPU1.D26
M_A_DQ2: length 31.4
  TOP w0.152: v3(54.04,29.83) 54.04,29.88 54.38,30.21 RAM1.P9
  L3 w0.114: v3(67.1,49.25) 67.74,48.61 67.74,41.48 60.16,33.9 60.16,32.73 57.77,30.33 57.39,30.33 57.37,30.35 57.03,30.35 57.02,30.34 56.99,30.34 56.99,30.33 56.38,30.33 56.28,30.24 54.55,30.24 54.14,29.83 54.05,29.83 v3(54.04,29.83)
  BOTTOM w0.076: CPU1.D28 69.78,49.23 69.58,49.44 69.12,49.44 68.7,49.41 68.64,49.4 68.62,49.39 68.32,49.39 68.27,49.41 68.05,49.41 67.92,49.37 67.22,49.37 v3(67.1,49.25)
M_A_DQ3: length 28.4
  TOP w0.152: RAM1.M10 53.4,30.7 v3(53.4,30.61)
  L3 w0.114: v3(67.22,47.78) 67.35,47.65 67.35,41.61 59.78,34.04 59.78,32.87 57.63,30.71 57.53,30.71 57.52,30.72 56.88,30.72 56.87,30.71 55.79,30.71 55.68,30.6 54.62,30.6 54.24,30.22 53.78,30.22 v3(53.4,30.61)
  BOTTOM w0.076: v3(67.22,47.78) 67.66,47.78 67.94,48.06 67.99,48.09 67.99,48.09 68.01,48.09 68.31,48.25 68.78,48.25 68.9,48.37 CPU1.C28
M_A_DQ4: length 32.2
  TOP w0.152: v3(53.39,29.82) 53.39,29.87 53.73,30.21 RAM1.N9
  L3 w0.114: v3(53.39,29.82) 53.38,29.83 52.35,31.2 52.35,33.54 56.08,37.27 59.49,37.27 62.88,40.65 62.88,45.37 62.48,45.77 62.48,46.75 62.86,47.13 64.21,47.13 64.5,47.43 v3(64.63,47.92)
  BOTTOM w0.076: CPU1.B26 68.13,49.98 68.13,49.98 68.11,49.99 67.96,50.06 67.25,50.06 67.19,50.01 66.45,50.01 66.24,49.95 65.96,49.86 65.58,49.57 64.69,48.53 64.64,48.35 v3(64.63,47.92)
M_A_DQ5: length 29.6
  TOP w0.152: RAM1.N11 54.03,32.12 v3(54.03,32.21)
  L3 w0.114: v3(65.95,49.04) 65.95,47.47 64.99,46.5 64.99,44.33 64.73,44.07 64.7,44.07 64.46,43.83 64.46,43.8 64.45,43.8 64.45,40.62 58.25,34.43 58.09,34.43 57.99,34.33 57.67,34.33 57.25,34.75 57.09,34.75 56.93,34.59 56.93,34.43 57.35,34.01 57.35,33.85 57.01,33.51 53.92,33.51 53.69,33.28 53.69,32.54 v3(54.03,32.21)
  BOTTOM w0.076: v3(65.95,49.04) 65.95,49.32 66.04,49.43 66.63,49.63 67.29,49.63 67.37,49.56 67.94,49.56 67.96,49.56 68.02,49.58 68.31,49.58 68.36,49.56 68.57,49.56 68.66,49.58 CPU1.C26
M_A_DQ6: length 30.2
  TOP w0.152: RAM1.N10 53.73,31.01 54.08,30.66 v3(54.08,30.61)
  L3 w0.114: v3(66.24,47.16) 66.6,47.16 66.84,46.92 66.84,46.11 66.13,45.4 66.13,41.1 59.04,34.01 59.04,33.85 59.25,33.64 59.25,33.47 59.09,33.31 58.93,33.31 58.55,33.69 58.39,33.69 58.23,33.53 58.23,33.37 58.77,32.82 58.77,32.66 58.61,32.5 58.45,32.5 57.91,33.04 57.75,33.04 57.28,32.58 57.28,31.9 56.94,31.55 56.34,31.55 55.6,30.8 54.28,30.8 v3(54.08,30.61)
  BOTTOM w0.076: v3(66.24,47.16) 66.07,47.16 65.97,47.26 65.97,47.44 66.68,48.15 67.75,48.15 67.92,48.24 68.26,48.42 CPU1.B28
M_A_DQ7: length 27.3
  TOP w0.152: RAM1.M11 53.08,31.81 53.4,31.5 53.4,31.44 v3(53.4,31.44)
  L3 w0.114: v3(53.4,31.44) 53.4,31.44 53.4,31.44 53.83,31.01 55.51,31.01 56.06,31.55 56.06,31.7 56.46,32.1 56.46,32.24 56.91,32.7 56.91,32.73 58.24,34.06 58.56,34.06 65.4,40.9 65.4,45.2 66.16,45.97 66.16,46.39 v3(65.81,46.74)
  BOTTOM w0.076: v3(65.81,46.74) 65.35,46.74 65.25,46.84 65.25,47 66.56,48.32 67.65,48.32 CPU1.A28
M_A_DQ8: length 22.5
  TOP w0.152: v3(56,32.2) 55.68,31.81 RAM1.T11
  L8 w0.114: v3(56,32.2) 56.41,32.2 57.1,32.89 57.1,35.7 62.4,41 62.4,43.8 63.27,44.66 v3(64.46,44.66)
  BOTTOM w0.076: CPU1.B30 68.42,47.23 68.13,47.12 67.89,47.02 67.87,47.02 67.21,47.02 65.77,45.57 65.68,45.57 65.67,45.56 65.67,45.56 65.51,45.4
  BOTTOM w0.152: v3(64.46,44.66) 64.77,44.66 65.51,45.4
M_A_DQ9: length 25.2
  TOP w0.152: RAM1.R10 55.03,31.01 55.35,31.34 v3(55.35,31.4)
  L8 w0.114: v3(55.35,31.4) 55.61,31.66 57.04,31.66 57.47,32.08 57.47,35.55 62.81,40.89 62.81,43.62 v3(63.34,44.15)
  BOTTOM w0.076: CPU1.D30 69.61,47.29 69.37,47.05 68.91,46.96 68.16,46.95 67.96,46.87 67.93,46.84 67.29,46.84 65.61,45.16
  BOTTOM w0.152: v3(63.34,44.15) 64.82,44.15 65.24,44.57 65.24,44.79 65.61,45.16
M_A_DQ10: length 25.2
  TOP w0.152: RAM1.R8 55.31,29.13 55.31,29.04 v3(55.4,28.95)
  L8 w0.114: v3(66.64,43.35) 66.99,42.99 66.99,41.65 66.49,41.15 66.49,40.02 63.63,37.16 63.63,36.24 61.38,33.98 61.38,33.33 60.16,32.11 60.16,30.03 58.43,28.29 56.05,28.29 v3(55.4,28.95)
  BOTTOM w0.076: CPU1.B33 68.08,45.31 67.6,44.83 67.41,44.35 67.15,44.09 67.15,43.85 v3(66.64,43.35)
M_A_DQ11: length 25.5
  TOP w0.152: v3(56.04,29.01) 56.04,29.05 55.68,29.41 RAM1.T8
  L8 w0.114: v3(66.6,42.76) 66.06,42.22 66.06,40.11 59.79,33.84 59.79,30.18 58.27,28.66 56.39,28.66 v3(56.04,29.01)
  BOTTOM w0.076: CPU1.D32 69.51,45.72 68.92,45.72 68.76,45.63 68.62,45.5 68.54,45.37 68.21,44.86 68.21,44.64 67.9,44.32 67.74,44.32 67.35,43.93 67.35,43.46 67.18,43.29
  BOTTOM w0.152: 67.18,43.29 66.65,42.76 v3(66.6,42.76)
M_A_DQ12: length 22.5
  TOP w0.152: RAM1.R11 55.03,31.81 55.33,32.2 v3(55.33,32.2)
  L8 w0.114: v3(64.5,45.27) 63.35,45.27 61.95,43.87 61.95,41.12 56.41,35.58 56.41,32.77 56.25,32.61 55.83,32.61 55.82,32.6 55.74,32.6 v3(55.33,32.2)
  BOTTOM w0.076: CPU1.A30 67.76,47.19 67.09,47.19 65.99,46.08
  BOTTOM w0.152: v3(64.5,45.27) 65.04,45.27 65.85,46.08 65.99,46.08
M_A_DQ13: length 25
  TOP w0.152: v3(57.46,31.13) 57.46,31.15 57.04,31.57 56.7,31.57 56.48,31.34 56.01,31.34 RAM1.T10
  L8 w0.114: v3(65.41,46.32) 65.41,44.88 63.18,42.65 63.18,40.74 57.84,35.39 57.84,31.51 v3(57.46,31.13)
  BOTTOM w0.076: v3(65.41,46.32) 65.97,46.32 66.52,46.87 66.52,46.9 67.01,47.39 67.5,47.39 67.66,47.55 68.62,47.55 CPU1.C30
M_A_DQ14: length 23.4
  TOP w0.152: RAM1.T9 56.01,30.54 56.59,30.54 v3(57.2,29.93)
  L8 w0.114: v3(57.2,29.93) 58.05,29.93 58.97,30.85 58.97,34.05 65.3,40.39 65.3,43.18 v3(66.72,44.59)
  BOTTOM w0.076: v3(66.72,44.59) 66.95,44.59 67.27,44.91 67.38,45.22 67.69,45.53 68.01,45.76 68.05,45.79 68.17,45.81 68.25,45.88 CPU1.B32
M_A_DQ15: length 25.5
  TOP w0.152: v3(55.33,29.82) 55.03,30.21 RAM1.R9
  L8 w0.114: v3(66.7,43.95) 66.66,43.95 65.67,42.96 65.67,40.24 59.33,33.9 59.33,30.24 58.12,29.03 56.6,29.03 55.82,29.82 v3(55.33,29.82)
  BOTTOM w0.076: v3(66.7,43.95) 67.32,44.58 67.38,44.73 67.52,45.13 67.8,45.4 68.11,45.63 68.11,45.63 68.58,45.71 68.85,45.89 CPU1.C32
M_A_DQ16: length 39.8
  TOP w0.152: v3(46.92,31.42) 47.23,31.01 RAM1.C10
  L8 w0.114: v3(46.92,31.42) 46.52,31.82 46.29,32.38 46.19,32.62 46.19,32.82 46.14,32.87 46.14,34.8 53.77,42.43 53.77,44.73 56.2,47.16 58.58,47.16 63.61,52.19 64.83,52.19 64.87,52.15 71.8,52.15 72.29,51.65 72.29,51.57 v3(72.29,51.57)
  BOTTOM w0.152: CPU1.J22 72.38,51.8 72.29,51.71 72.29,51.57 v3(72.29,51.57)
M_A_DQ17: length 38.3
  TOP w0.152: RAM1.C8 47.23,29.41 v3(46.92,28.81)
  L8 w0.114: v3(71.37,49.66) 70.73,49.02 68.14,49.02 67.4,48.28 66.41,48.28 63.96,45.83 63.24,45.83 61.43,44.03 61.43,41.74 53.51,33.81 51.4,33.81 51.03,33.44 51.03,29.39 50.72,29.09 50.72,29.07 50.14,28.49 47.23,28.49 v3(46.92,28.81)
  BOTTOM w0.152: CPU1.H25 v3(71.37,49.66)
M_A_DQ18: length 36.3
  TOP w0.152: v3(46.91,32.22) 47.23,31.81 RAM1.C11
  L8 w0.114: v3(46.91,32.22) 46.64,32.48 46.55,32.7 46.55,32.98 46.53,33.01 46.53,34.67 54.14,42.28 54.14,44.58 56.35,46.79 58.73,46.79 63.76,51.82 64.68,51.82 64.77,51.73 70.6,51.73 v3(70.62,51.71)
  BOTTOM w0.152: CPU1.G22 70.64,51.71 70.63,51.71 v3(70.62,51.71)
M_A_DQ19: length 40.1
  TOP w0.152: RAM1.B11 46.58,31.81 46.08,32.13 45.86,32.26 v3(45.41,32.5)
  L8 w0.114: v3(71.45,52.56) 70.25,53.76 70.02,53.76 70.01,53.76 69.67,53.76 69.67,53.76 68.75,53.76 68.74,53.77 64.14,53.77 58.27,47.89 55.9,47.89 53.04,45.03 53.04,42.83 45.41,35.2 v3(45.41,32.5)
  BOTTOM w0.152: v3(71.45,52.56) 71.45,52.54 CPU1.H22
M_A_DQ20: length 38.2
  TOP w0.152: v3(46.23,28.8) 46.58,29.41 RAM1.B8
  L8 w0.114: v3(46.23,28.8) 46.81,29.38 50.28,29.38 50.57,29.67 50.57,30.65 50.79,30.86 50.79,33.49 52.24,34.95 54.12,34.95 61.06,41.89 61.06,44.92 63.28,47.13 64.69,47.13 66.21,48.65 67.25,48.65 68.12,49.52 v3(70.63,49.52)
  BOTTOM w0.152: CPU1.F25 v3(70.63,49.52)
M_A_DQ21: length 38.2
  TOP w0.152: v3(46.92,29.81) 47.23,30.21 RAM1.C9
  L8 w0.114: v3(46.92,29.81) 48.5,30.22 49.03,30.22 50.24,30.97 50.58,31.31 50.58,33.57 50.73,33.72 50.73,34.85 51.2,35.32 52.09,35.32 53.97,35.32 60.7,42.04 60.7,45.07 65.3,49.68 67.22,49.68 67.59,50.05 71.71,50.05 v3(72.03,49.73)
  BOTTOM w0.152: CPU1.J25 v3(72.03,49.73)
M_A_DQ22: length 38.1
  TOP w0.152: RAM1.B9 46.58,30.21 46.23,29.87 v3(46.23,29.82)
  L8 w0.114: v3(46.23,29.82) 47.42,31.01 47.79,31.01 48.44,31.66 48.44,32.36 48.8,32.71 49.95,32.71 50.28,33.04 50.28,35.33 55.27,40.33 55.27,44.11 56.82,45.66 60.76,45.66 65.24,50.14 67.16,50.14 67.5,50.49 v3(70.74,50.49)
  BOTTOM w0.152: v3(70.74,50.49) 70.76,50.48 70.77,50.48 70.87,50.45 CPU1.G25
M_A_DQ23: length 38.5
  TOP w0.152: RAM1.B10 46.58,31.01 v3(46.28,31.41)
  L8 w0.114: v3(46.28,31.41) 45.82,32.29 45.82,32.67 45.77,32.72 45.77,34.95 53.41,42.59 53.41,44.88 56.05,47.52 58.42,47.52 63.48,52.58 v3(70.83,52.58)
  BOTTOM w0.152: CPU1.F22 70.79,52.51 70.79,52.54 v3(70.83,52.58)
M_A_DQ24: length 36.3
  TOP w0.152: v3(50.13,32.21) 49.57,32.21 49.18,31.81 RAM1.F11
  L3 w0.114: v3(50.13,32.21) 50.3,32.37 50.3,34.78 50.48,34.97 50.48,35.23 55.36,40.11 58.76,40.11 59.01,40.36 59.02,40.36 60.57,41.91 60.57,44.11 60.13,44.54 60.13,47.72 62.26,49.85 63.84,49.85 65.34,51.35 67.9,51.35 69.84,53.3 69.84,53.35 v3(69.84,53.35)
  BOTTOM w0.152: v3(69.84,53.35) 69.84,53.35 69.84,53.38 69.87,53.34 69.87,52.8 69.78,52.72 CPU1.D22
M_A_DQ25: length 37.1
  TOP w0.152: RAM1.E10 48.53,31.01 48.85,30.69 48.85,30.65 48.86,30.64 v3(48.86,30.63)
  L3 w0.114: v3(66.83,53.26) 66.83,53.25 66.38,52.8 61.77,52.8 48.15,39.17 48.15,34.04 47.99,33.87 47.99,32.96 48.28,32.67 48.28,31.2 48.85,30.63 v3(48.86,30.63)
  BOTTOM w0.076: CPU1.C22 68.89,52.33 68.65,52.09 68.62,52.07 68.4,52.07 68.34,52.08 68.33,52.1 68.01,52.1 67.93,52.07 67.69,52.07 67.42,52.34 67.33,52.52
  BOTTOM w0.152: 67.33,52.52 66.97,52.88 66.85,53.16 66.85,53.24 v3(66.83,53.26)
M_A_DQ26: length 35.9
  TOP w0.152: v3(49.43,28.96) 49.18,29.21 49.18,29.41 RAM1.F8
  L3 w0.114: v3(66.99,50.56) 66.99,50.27 66.42,49.7 65.52,49.7 64.93,49.12 64.8,49.12 64.5,48.81 62.79,48.81 61.24,47.26 61.24,45.15 61.67,44.71 61.67,41.45 59.47,39.26 59.47,39.26 58.89,38.67 55.49,38.67 51.05,34.24 51.05,30.19 50.27,29.41 49.89,29.41 v3(49.43,28.96)
  BOTTOM w0.076: v3(66.99,50.56) 66.99,50.56 66.99,50.56 67.04,50.61 68.01,50.61 68.1,50.65 68.15,50.67 68.22,50.7 68.54,50.74 68.6,50.75 68.74,50.79 CPU1.C24
M_A_DQ27: length 38.9
  TOP w0.152: v3(48.21,30.59) 48.21,30.54 RAM1.D9
  L3 w0.114: v3(65.6,53.21) 65.17,53.64 62.09,53.64 47.46,39 47.46,34.47 47.76,34.17 47.76,32.97 47.92,32.43 47.95,32.21 48.09,31.11 v3(48.21,30.59)
  BOTTOM w0.076: CPU1.D24 69.78,51.75 69.58,51.96 68.76,51.96 68.65,51.91 68.33,51.91 68.32,51.92 68.31,51.92 68.26,51.93 68.03,51.93 67.96,51.91 67.95,51.91 67.62,51.91 67.28,52.24 67.06,52.34 66.85,52.47 66.03,52.87
  BOTTOM w0.152: 66.03,52.87 v3(65.6,53.21)
M_A_DQ28: length 34.4
  TOP w0.152: v3(48.85,31.41) 48.89,31.41 49.18,31.12 49.18,31.01 RAM1.F10
  L3 w0.114: v3(67.41,53.27) 67.41,53.26 66.79,52.63 66.74,52.63 66.53,52.43 61.93,52.43 48.52,39.02 48.52,34.11 48.76,33.87 48.76,32.64 48.49,32.37 48.49,31.78 v3(48.85,31.41)
  BOTTOM w0.152: CPU1.A22 67.84,52.7 67.41,53.13 v3(67.41,53.27)
M_A_DQ29: length 34.1
  TOP w0.152: v3(48.87,32.21) 48.87,32.16 RAM1.E11
  L3 w0.114: v3(48.87,32.21) 48.99,32.32 48.99,38.97 61.84,51.82 67.24,51.82 68.59,53.18 68.59,53.36 68.6,53.36 v3(68.6,53.35)
  BOTTOM w0.076: CPU1.B22 68.62,52.46 68.62,53.28 68.59,53.3 68.59,53.36 68.6,53.36 v3(68.6,53.35)
M_A_DQ30: length 34.6
  TOP w0.152: v3(48.84,29.8) 48.84,29.8 48.84,29.91 48.53,30.21 RAM1.E9
  L3 w0.114: v3(48.84,29.8) 49.8,30.76 50.03,30.76 50.55,31.28 50.55,34.64 50.85,34.94 50.85,35.08 55.35,39.57 58.74,39.57 59.17,39.99 59.17,39.99 60.94,41.76 60.94,44.26 60.5,44.7 60.5,47.57 62.42,49.48 64.06,49.48 v3(65.22,50.64)
  BOTTOM w0.076: v3(65.22,50.64) 65.81,51.24 67.28,51.24 67.49,51.03 CPU1.A24
M_A_DQ31: length 34.5
  TOP w0.152: RAM1.F9 49.48,29.91 49.48,29.84 v3(49.5,29.82)
  L3 w0.114: v3(49.5,29.82) 49.5,29.84 50.78,31.12 50.78,34.48 55.34,39.04 58.73,39.04 59.32,39.63 59.32,39.63 61.3,41.61 61.3,44.56 60.87,45 60.87,47.11 60.87,47.41 62.53,49.08 64.26,49.08 v3(65.8,50.62)
  BOTTOM w0.076: v3(65.8,50.62) 66.26,51.07 67.19,51.07 67.49,50.77 67.97,50.77 68.05,50.81 68.42,51.03 CPU1.B24
M_A_DQ32: length 19.3
  TOP w0.152: v3(68.66,26.87) 68.66,26.91 68.31,27.27 RAM2.F10
  L3 w0.114: v3(68.66,26.87) 67.78,27.75 67.78,28.88 67.27,29.39 67.27,34.91 68.72,36.36 68.72,38.58 69.97,39.82 v3(70.3,39.82)
  BOTTOM w0.076: CPU1.H37 71.88,42.3 71.05,41.47 71.05,41.28 71.05,41.28 71.05,40.52 70.87,40.35
  BOTTOM w0.152: 70.87,40.35 70.35,39.82 v3(70.3,39.82)
M_A_DQ33: length 23.1
  TOP w0.152: RAM2.D9 67.01,26.47 67.01,26.36 67.3,26.08 v3(67.33,26.08)
  L3 w0.114: v3(70.36,42.17) 67.43,39.25 67.43,36.82 65.8,35.19 65.8,29.44 66.4,28.84 66.84,28.84 67.07,28.61 67.07,28.17 67.11,28.13 67.11,26.29 67.3,26.08 v3(67.33,26.08)
  BOTTOM w0.076: CPU1.H34 71.64,44.84 70.98,44.19 70.98,43.08 71.06,43.01 71.06,42.64 70.59,42.17 v3(70.36,42.17)
M_A_DQ34: length 20.1
  TOP w0.14: RAM2.F11 67.99,28.39 67.99,29.53 68.42,29.96 v3(68.42,29.97)
  L3 w0.114: v3(68.42,29.97) 69.25,29.97 69.63,30.36 69.63,35.11 71.15,36.63 71.15,38.41 71.15,38.41 71.15,38.87 71.8,39.52 v3(72.21,39.52)
  BOTTOM w0.076: CPU1.K34 73.5,44.3 73.5,43.25 73.6,43.06 73.6,42.27 73.28,41.95 73.28,41.36 72.64,40.72 72.64,39.94 v3(72.21,39.52)
M_A_DQ35: length 22.8
  TOP w0.152: v3(68.61,25.17) 68.31,25.67 RAM2.F8
  L3 w0.114: v3(68.61,25.17) 69.05,25.61 70.02,25.61 70.74,26.33 70.74,35.18 71.89,36.33 71.89,37.52 v3(72.13,37.76)
  BOTTOM w0.076: 71.67,38.42 71.67,39.35 71.67,39.36 71.67,39.88 71.67,39.88 71.67,40.46 71.67,40.46 71.67,40.91 71.67,40.91 71.67,41.01 71.88,41.22 72.4,41.22 72.78,41.61 72.78,42.16 72.91,42.28 72.91,42.94 72.95,43.05 72.95,43.37 72.93,43.43 72.93,43.66 72.96,43.74 73.18,43.97 CPU1.K35
  BOTTOM w0.152: 71.67,38.42 71.67,38.25 72.13,37.78 v3(72.13,37.76)
M_A_DQ36: length 19.9
  TOP w0.152: v3(67.99,26.89) 67.99,26.94 67.66,27.27 RAM2.E10
  L3 w0.114: v3(67.99,26.89) 67.58,27.3 67.58,28.8 67.07,29.3 67.07,30.36 66.9,30.52 66.9,35.06 68.35,36.51 68.35,38.73 70.03,40.41 v3(70.3,40.41)
  BOTTOM w0.076: 70.82,40.84 70.88,40.91 70.88,41.35 70.88,41.35 70.88,41.54 71.62,42.27 71.62,43.01 71.7,43.16 71.73,43.21 71.73,43.26 CPU1.H36
  BOTTOM w0.152: 70.82,40.84 70.38,40.41 v3(70.3,40.41)
M_A_DQ37: length 21.5
  TOP w0.152: RAM2.E9 67.66,26.47 67.98,26.14 v3(67.98,26.06)
  L3 w0.114: v3(67.98,26.06) 67.37,26.67 67.37,28.71 66.87,29.22 66.87,30.18 66.54,30.51 66.54,35.21 67.98,36.66 67.98,38.88 70.09,40.99 v3(70.32,40.99)
  BOTTOM w0.076: CPU1.H35 71.63,43.74 71.54,43.22 71.52,43.17 71.46,43.05 71.46,42.34 71.46,42.34 70.72,41.6 70.72,41.42 70.72,41.42 70.72,41.39 v3(70.32,40.99)
M_A_DQ38: length 19.4
  TOP w0.14: RAM2.E11 67.66,28.07 67.31,28.42 67.31,28.71 67.33,28.74 67.33,29 67.32,29.02 67.32,29.59 67.31,29.6 67.31,30.02 68.24,30.96 68.58,30.96 68.99,30.54 v3(68.99,30.53)
  L3 w0.114: v3(72.2,40.68) 70.77,39.25 70.77,36.77 68.99,35 v3(68.99,30.53)
  BOTTOM w0.076: CPU1.K36 73.33,43.26 73.33,43.21 73.44,43.02 73.44,42.34 73.12,42.02 73.12,41.47 72.33,40.68 v3(72.2,40.68)
M_A_DQ39: length 20.4
  TOP w0.152: RAM2.F9 68.31,26.47 68.64,26.14 v3(68.64,26.06)
  L3 w0.114: v3(72.19,38.93) 71.54,38.28 71.54,37.7 71.52,37.68 71.52,36.48 70.36,35.32 70.36,26.72 70.11,26.47 69.04,26.47 v3(68.64,26.06)
  BOTTOM w0.076: v3(72.19,38.93) 71.85,39.28 71.85,39.89 71.84,39.9 71.84,39.95 71.83,39.95 71.83,40.53 71.83,40.53 71.83,40.84 71.84,40.84 72.05,41.05 72.46,41.05 72.95,41.54 72.95,42.09 73.18,42.32 CPU1.K37
M_A_DQ40: length 19.9
  TOP w0.14: v3(74.33,30.61) 74.99,30.61 75.62,29.98 75.62,29.97 75.78,29.8 75.78,29.3 75.78,28.73 75.59,28.54 75.43,28.54 75.13,28.25 75.13,27.93 74.94,27.74 74.64,27.74 74.4,27.51
  TOP w0.152: 74.4,27.51 74.16,27.27 RAM2.R10
  L3 w0.114: v3(74.33,30.61) 72.79,32.16 72.79,35.39 73.01,35.61 73.01,38.09 v3(73.63,38.71)
  BOTTOM w0.076: v3(73.63,38.71) 73.09,39.25 73.09,40.71 73.61,41.23 73.61,41.81 74.08,42.29 74.08,42.92 74.4,43.49 CPU1.N36
M_A_DQ41: length 21.2
  TOP w0.14: RAM2.T10 74.81,27.27 75.14,27.6 76.14,27.6 76.38,27.83 76.38,29.55 74.89,31.04 v3(74.74,31.04)
  L3 w0.114: v3(73.61,37.47) 73.21,37.07 73.21,35.33 73.16,35.27 73.16,32.62 v3(74.74,31.04)
  BOTTOM w0.076: 72.93,38.87 72.93,40.78 73.45,41.3 73.45,41.88 73.92,42.36 73.92,42.97 74.05,43.21 74.1,43.3 74.1,44.23 CPU1.N34
  BOTTOM w0.152: 72.93,38.87 72.93,38.16 v3(73.61,37.47)
M_A_DQ42: length 21.4
  TOP w0.152: v3(73.79,25.14) 74.16,25.51 74.16,25.67 RAM2.R8
  L3 w0.114: v3(75.4,34.96) 75.4,33.8 76.58,32.62 76.58,29.04 75.93,28.39 75.82,28.39 75.47,28.04 75.47,26.47 74.55,25.55 74.2,25.55 v3(73.79,25.14)
  BOTTOM w0.076: 74.63,35.85 74.63,40.4 75.57,41.34 75.57,42.77 CPU1.R37
  BOTTOM w0.152: v3(75.4,34.96) 74.97,34.96 74.63,35.29 74.63,35.85
M_A_DQ43: length 21.9
  TOP w0.152: v3(73.84,26.05) 73.84,26.05 73.84,26.05 73.84,26.05 73.84,26.15 74.16,26.47 RAM2.R9
  L3 w0.114: v3(74.31,41.17) 74.66,40.82 74.66,33.31 75.84,32.13 75.84,29.55 74.93,28.64 74.93,27.14 73.84,26.05 73.84,26.05 v3(73.84,26.05)
  BOTTOM w0.076: v3(74.31,41.17) 74.31,41.73 74.82,42.24 74.82,43.04 74.79,43.1 74.79,43.34 74.8,43.36 74.82,43.38 74.82,43.69 74.79,43.75 74.79,44.38 74.77,44.4 74.77,44.66 74.95,44.84 CPU1.R34
M_A_DQ44: length 17.6
  TOP w0.14: RAM2.T11 74.81,28.41 75.13,28.73 75.13,29.82 v3(74.76,30.2)
  L3 w0.114: v3(74.76,30.2) 74.08,30.2 72.42,31.86 72.42,35.56 72.81,35.94 72.81,38.48 v3(73.62,39.29)
  BOTTOM w0.076: v3(73.62,39.29) 73.26,39.65 73.26,40.64 73.78,41.16 73.78,41.74 74.4,42.37 CPU1.N37
M_A_DQ45: length 18.9
  TOP w0.14: v3(73.98,29.35) 73.98,29.35 74.2,29.35 74.48,29.06 74.48,28.62 74.33,28.23 74.16,28.07 RAM2.R11
  L3 w0.114: v3(73.65,40.46) 72.6,39.42 72.6,36.26 72.05,35.71 72.05,30.76 73.04,29.77 73.63,29.77 73.98,29.43 v3(73.98,29.35)
  BOTTOM w0.076: CPU1.N35 74.62,43.92 74.62,43.75 74.65,43.66 74.65,43.43 74.63,43.37 74.63,43.07 74.65,43.01 74.65,42.31 73.94,41.6 73.94,41.09 73.65,40.8 v3(73.65,40.46)
M_A_DQ46: length 20.2
  TOP w0.152: v3(74.49,26.05) 74.49,26.05 74.49,26.05 74.81,26.36 74.81,26.47 RAM2.T9
  L3 w0.114: v3(75.35,36.13) 74.99,35.77 74.99,33.5 76.21,32.28 76.21,29.19 75.14,28.11 75.14,26.69 74.49,26.05 74.49,26.05 v3(74.49,26.05)
  BOTTOM w0.076: CPU1.R36 75.7,43.49 75.95,43.03 75.95,42.73 75.74,42.52 75.74,41.27 74.84,40.38 74.84,36.63 v3(75.35,36.13)
M_A_DQ47: length 22.3
  TOP w0.152: v3(74.45,25.12) 74.81,25.48 74.81,25.67 RAM2.T8
  L3 w0.114: v3(75.4,36.71) 75.88,36.23 75.88,33.86 76.95,32.79 76.95,27.53 76.01,26.6 75.81,26.52 75.48,26.19 75.45,26.12 v3(74.45,25.12)
  BOTTOM w0.076: CPU1.R35 75.99,43.9 75.99,43.3 76.12,43.07 76.12,42.66 75.92,42.46 75.92,41.22 75.01,40.31 75.01,37.1 v3(75.4,36.71)
M_A_DQ48: length 22.5
  TOP w0.152: RAM2.B11 65.71,28.07 66.05,27.73 66.05,27.65 v3(66.04,27.65)
  L8 w0.114: v3(70.47,46.32) 69.99,46.32 68.01,44.34 68.01,41.07 67.89,40.95 67.89,36.48 65.49,34.08 65.49,30.02 65.78,29.73 65.78,28.73 65.68,28.63 65.68,28.41 65.66,28.4 65.66,28.03 66.06,27.64 66.06,27.65 v3(66.04,27.65)
  BOTTOM w0.152: CPU1.G31 v3(70.47,46.32)
M_A_DQ49: length 22.8
  TOP w0.152: v3(66.07,28.47) 66.05,28.47 66.05,28.38 66.36,28.07 RAM2.C11
  L8 w0.114: v3(66.07,28.47) 66.05,28.47 66.05,28.48 65.98,28.55 65.98,29.84 65.86,29.96 65.86,33.92 68.26,36.32 68.26,40.37 68.24,40.39 68.24,42.86 68.77,43.39 68.77,43.55 68.37,43.94 68.37,44.1 68.54,44.26 68.7,44.26 69.07,43.89 69.23,43.89 69.39,44.05 69.39,44.09 69.38,44.1 69.38,44.23 69.02,44.59 69.02,44.75 69.18,44.91 69.34,44.91 69.61,44.65 69.93,44.65 70.5,45.22 v3(70.5,45.73)
  BOTTOM w0.152: CPU1.G32 v3(70.5,45.73)
M_A_DQ50: length 26.7
  TOP w0.152: v3(65.39,26.06) 65.39,26.05 65.71,25.67 RAM2.B8
  L8 w0.114: v3(71.49,48.13) 71.88,47.75 72.07,46 72.08,45.99 72.08,44.48 70.74,41.4 70.74,35.48 67.74,32.44 67.74,27.56 67.4,27.22 67.4,27.08 66.49,26.16 66.49,26 66.18,25.69 65.75,25.69 v3(65.39,26.06)
  BOTTOM w0.152: CPU1.H29 v3(71.49,48.13)
M_A_DQ51: length 27.2
  TOP w0.152: v3(66.04,25.22) 66.36,25.67 RAM2.C8
  L8 w0.114: v3(71.47,48.74) 72,48.22 72,48 72.06,47.93 72.29,46.24 72.29,44.29 71.11,41.47 71.11,40.37 71.11,40.37 71.11,35.33 70.98,35.21 68.18,32.37 68.18,30.88 68.02,30.72 68.02,27.54 67.97,27.48 67.61,27.12 67.61,26.99 66.75,26.14 66.75,25.93 v3(66.04,25.22)
  BOTTOM w0.152: CPU1.H28 v3(71.47,48.74)
M_A_DQ52: length 24.7
  TOP w0.152: v3(64.75,27.67) 65.31,27.67 65.71,27.27 RAM2.B10
  L8 w0.114: v3(64.75,27.67) 64.75,28.41 64.63,28.52 64.63,34.56 66.43,36.36 66.43,38.45 66.95,38.97 66.95,40.8 67.53,41.38 67.53,45.15 v3(70.55,48.18)
  BOTTOM w0.152: CPU1.G28 v3(70.55,48.18)
M_A_DQ53: length 24.5
  TOP w0.152: v3(66.04,26.87) 66.04,26.95 66.36,27.27 RAM2.C10
  L8 w0.114: v3(66.04,26.87) 65.25,27.66 65.25,27.86 65,28.11 65,34.29 67.44,36.72 67.44,40.81 67.73,41.1 67.73,44.76 70.55,47.58 v3(70.59,47.58)
  BOTTOM w0.152: CPU1.G29 v3(70.59,47.58)
M_A_DQ54: length 23.9
  TOP w0.152: v3(66.02,26.08) 66.02,26.13 66.36,26.47 RAM2.C9
  L8 w0.114: v3(71.51,46.27) 71.88,45.9 71.88,44.52 71.72,44.15 69.93,42.36 69.93,40.58 69.88,40.54 69.88,35.14 67.37,32.59 67.37,30.82 67.47,30.72 67.47,27.59 67.2,27.31 67.2,27.2 66.08,26.08 v3(66.02,26.08)
  BOTTOM w0.152: CPU1.H31 v3(71.51,46.27)
M_A_DQ55: length 23.6
  TOP w0.152: RAM2.B9 65.71,26.55 v3(65.4,26.87)
  L8 w0.114: v3(71.49,45.65) 71.49,44.31 69.72,42.54 69.72,40.66 69.51,40.45 69.51,40.45 69.51,35.33 67,32.81 67,30.81 67.27,30.54 67.27,27.67 67,27.4 67,27.28 66.2,26.49 65.78,26.49 v3(65.4,26.87)
  BOTTOM w0.152: CPU1.H32 71.51,45.65 v3(71.49,45.65)
M_A_DQ56: length 22.9
  TOP w0.152: RAM2.M10 72.21,27.27 72.21,27.18 71.95,26.92 71.95,26.9 71.92,26.87 71.92,26.87 v3(71.92,26.87)
  L8 w0.114: v3(71.92,26.87) 71.92,26.87 71.92,26.86 71.89,26.86 71.88,26.88 71.77,26.88 70.94,27.71 70.94,32.43 73.16,34.66 73.16,41.85 73.85,42.53 73.85,46.24 v3(73.3,46.78)
  BOTTOM w0.152: CPU1.L31 v3(73.3,46.78)
M_A_DQ57: length 24
  TOP w0.152: RAM2.M8 72.51,25.97 v3(72.51,26.07)
  L8 w0.114: v3(73.29,46.12) 73.64,45.77 73.64,42.74 72.77,41.86 72.77,34.79 71.98,34 70.66,32.67 70.55,32.56 70.55,30.09 70.59,30.05 70.59,29.65 70.59,26.9 71.03,26.46 72.12,26.46 v3(72.51,26.07)
  BOTTOM w0.152: CPU1.L32 v3(73.29,46.12)
M_A_DQ58: length 26.9
  TOP w0.152: v3(73.18,26.05) 73.17,26.05 73.17,26.08 73.19,26.1 73.19,26.15 73.51,26.47 RAM2.P9
  L8 w0.114: v3(75.07,48.1) 75.11,48.1 76.56,46.65 76.56,45.25 77.1,44.71 77.1,41.86 76.91,41.67 76.91,31.8 75.56,30.45 75.56,27.46 75.36,26.86 74.87,25.84 74.66,25.63 74.01,25.63 74.01,25.63 73.67,25.63 73.57,25.65 73.18,26.04 73.17,26.04 73.17,26.05 v3(73.18,26.05)
  BOTTOM w0.152: CPU1.N29 v3(75.07,48.1)
M_A_DQ59: length 24.2
  TOP w0.152: RAM2.N11 72.86,28.07 72.86,27.99 73.15,27.7 73.17,27.7 v3(73.18,27.69)
  L8 w0.114: v3(73.18,27.69) 73.18,27.94 72.99,28.13 72.99,30.41 76.17,33.59 76.17,34.6 76.21,34.64 76.21,41.57 76.7,42.06 76.7,43.63 75.54,44.79 75.54,46.57 74.75,47.36 74.75,47.6 v3(74.21,48.15)
  BOTTOM w0.152: CPU1.N28 v3(74.21,48.15)
M_A_DQ60: length 24.4
  TOP w0.152: v3(72.56,26.86) 72.57,26.86 72.57,26.86 72.86,26.47 RAM2.N9
  L8 w0.114: v3(73.35,48.14) 73.53,47.93 73.71,47.5 73.71,46.79 73.78,46.62 74.05,46.35 74.05,42.19 73.88,41.64 73.88,41.2 74.09,40.65 74.09,34.81 71.41,32.14 71.37,32.01 71.37,27.63 71.72,27.28 72.02,27.28 72.52,26.9 72.52,26.9 72.57,26.86 72.57,26.86 v3(72.56,26.86)
  BOTTOM w0.152: CPU1.L28 v3(73.35,48.14)
M_A_DQ61: length 25.7
  TOP w0.152: v3(71.88,26.05) 71.87,26.05 71.87,26.04 71.88,26.05 71.88,26.05 72.21,26.38 72.21,26.47 RAM2.M9
  L8 w0.114: v3(71.88,26.05) 71.87,26.05 71.87,26.04 71.46,25.63 71.04,25.63 70.39,26.29 70.39,29.73 70.14,29.98 70.14,32.67 71.1,33.65 71.69,34.24 71.69,40.9 71.89,41.1 71.89,41.82 72.74,42.66 72.74,46.92 v3(73.29,47.47)
  BOTTOM w0.152: CPU1.L29 v3(73.29,47.47)
M_A_DQ62: length 25.7
  TOP w0.152: v3(73.21,26.87) 72.88,27.2 RAM2.N10
  L8 w0.114: v3(73.21,26.87) 73.62,26.46 74.01,26.46 75.17,27.62 75.17,31.85 76.54,33.22 76.54,41.59 76.9,41.96 76.9,44.62 76.35,45.17 76.35,46.33 75.17,47.52 v3(75.15,47.52)
  BOTTOM w0.152: CPU1.N31 75.15,47.03 v3(75.15,47.52)
M_A_DQ63: length 24.2
  TOP w0.152: v3(72.56,27.68) 72.55,27.68 72.55,27.68 72.53,27.7 72.5,27.7 72.21,27.99 72.21,28.07 RAM2.M11
  L8 w0.114: v3(75.1,45.66) 75.1,44.94 75.84,44.2 75.84,40.02 75.84,39.83 75.86,39.8 75.86,39.46 75.84,39.43 75.84,34.79 75.16,34.11 75.16,33.95 75.5,33.61 75.5,33.44 75.34,33.28 75.18,33.28 74.83,33.63 74.67,33.63 74.51,33.47 74.51,33.3 74.85,32.96 74.85,32.8 74.69,32.64 74.53,32.64 74.19,32.98 74.03,32.98 73.86,32.82 73.86,32.66 74.21,32.31 74.21,32.15 74.05,31.99 73.88,31.99 73.54,32.33 73.38,32.33 73.04,32 73.04,30.85 73.01,30.83 73.01,30.81 72.79,30.58 72.79,28.18 72.56,27.94 v3(72.56,27.68)
  BOTTOM w0.152: CPU1.N32 v3(75.1,45.66)
M_A_DQS_DN0: length 34
  TOP w0.14: v3(52.74,32.21) 52.72,32.21 52.43,31.92 52.43,31.81 RAM1.L11
  L3 w0.114: v3(63.37,46.64) 63.33,46.59 63.33,46.41 63.72,46.02 63.72,45.79 63.51,45.58 63.51,44.72 63.78,44.45 63.78,42.95 63.66,42.83 63.61,42.83 63.37,42.59 63.37,42.18 63.61,41.94 63.66,41.94 63.78,41.83 63.78,40.9 63.18,40.31 63.12,40.25 63.12,40.25 61.4,38.53 59.68,36.81 58.17,36.81 57.93,36.57 57.93,35.9 57.82,35.78 57.59,35.78 57.47,35.9 57.47,36.57 57.23,36.81 56.58,36.81 56.2,36.43 56.2,34.2 56.08,34.08 55.85,34.08 55.74,34.2 55.74,35.16 55.5,35.4 54.86,35.4 53.24,33.78 53.24,32.18 53.04,31.98 52.88,31.98 52.74,32.12 52.74,32.2 52.72,32.21 v3(52.74,32.21)
  BOTTOM w0.076: CPU1.C27 68.54,49.02 68.51,49 68.37,48.95 68.25,48.91 68.05,48.91 67.96,48.94 67.61,48.94 67.34,48.67 66.21,48.67 65.99,48.45 65.89,48.45 65.81,48.37
  BOTTOM w0.14: 65.81,48.37 65.39,47.95 65.39,47.95 64.33,46.89 63.62,46.89 v3(63.37,46.64)
M_A_DQS_DN1: length 28.3
  TOP w0.14: RAM1.P11 54.38,31.81 v3(54.06,31.42)
  L8 w0.114: v3(54.06,31.42) 54.29,31.01 54.9,30.39 55.88,30.39 56.12,30.64 56.12,30.85 56.23,30.97 56.46,30.97 56.57,30.85 56.57,30.64 56.81,30.39 57.86,30.39 58.51,31.04 58.51,34.24 59.17,34.9 59.17,35.24 58.98,35.43 58.98,35.59 59.15,35.75 59.31,35.75 59.49,35.57 59.83,35.57 63.85,39.59 63.85,41.41 v3(64.86,42.42)
  BOTTOM w0.076: 67.52,46.26 67.53,46.27 67.88,46.27 68.05,46.19 68.25,46.19 68.28,46.2 68.38,46.25 68.73,46.25 68.87,46.28 68.98,46.33 CPU1.D31
  BOTTOM w0.102: 67.52,46.26 66.89,45.63 66.28,45.03 66.28,43.84 v3(64.86,42.42)
M_A_DQS_DN2: length 39.4
  TOP w0.14: v3(47.55,32.21) 47.88,31.88 47.88,31.81 RAM1.D11
  L8 w0.114: v3(71.46,51.46) 71.46,51.44 71.46,51.14 71.36,51.04 71.05,51.04 70.81,51.27 64.96,51.27 64.59,50.9 64.59,50.46 60.46,46.33 56.54,46.33 54.6,44.39 54.6,40.76 52.95,39.11 52.79,39.11 52.47,39.43 52.13,39.43 51.85,39.14 51.85,38.8 52.16,38.48 52.16,38.32 50.45,36.61 50.29,36.61 49.87,37.02 49.53,37.02 49.24,36.73 49.24,36.39 49.66,35.98 49.66,35.82 48.18,34.34 48.11,34.34 47.75,33.97 47.75,32.4 v3(47.55,32.21)
  BOTTOM w0.14: v3(71.46,51.46) 71.46,51.44 71.46,51.44 71.41,51.19 71.49,51.07 CPU1.H24
M_A_DQS_DN3: length 37.1
  TOP w0.14: v3(50.13,31.41) 50.13,31.44 50.12,31.45 50.12,31.52 RAM1.G11
  L3 w0.114: v3(63.62,50.54) 63.47,50.68 63.47,50.98 63.37,51.08 62.05,51.08 50.03,39.05 50.03,38.54 50.14,38.43 51.33,38.43 51.57,38.18 51.57,37.78 51.33,37.54 50.14,37.54 50.03,37.43 50.03,34.47 49.43,33.87 49.43,32.64 49.74,32.32 49.74,32.02 49.93,31.83 49.93,31.61 v3(50.13,31.41)
  BOTTOM w0.076: v3(63.62,50.54) 63.4,50.76 63.4,51 63.79,51.39 63.79,51.67 64.08,51.95 64.75,51.95 64.83,51.88 67.13,51.88 67.49,51.52 67.79,51.52 67.81,51.51 67.85,51.51 67.88,51.49 68.05,51.42 68.25,51.42 68.4,51.47 68.54,51.54 68.68,51.61 CPU1.C23
M_A_DQS_DN4: length 21.1
  TOP w0.14: RAM2.G11 68.96,28.07 68.64,28.45 68.64,28.49 v3(68.64,28.49)
  L3 w0.114: v3(70.33,38.07) 69.98,38.07 69.87,38.17 69.87,38.32 69.76,38.44 69.53,38.44 69.39,38.3 69.39,37.3 69.39,36.08 67.94,34.63 67.94,34.1 68.06,33.98 68.3,33.98 68.54,33.74 68.54,33.33 68.3,33.09 68.06,33.09 67.94,32.98 67.94,29.31 68.2,29.05 68.2,28.18 68.3,28.08 68.53,28.08 68.64,28.19 v3(68.64,28.49)
  BOTTOM w0.076: CPU1.J35 72.53,43.79 72.31,43.57 72.31,43.47 72.31,43.4 72.28,43.32 72.28,43.12 72.28,43.11 72.31,43.03 72.31,42.25 71.5,41.44 71.5,40.98 71.5,40.97 71.5,40.39 71.5,40.39 71.5,40.25 71.5,40.25 71.5,39.63 71.22,39.34 71.22,39.17 71.21,39.17 71.14,39.1 71.14,39.08 71.14,38.99 71.14,38.99 71.14,38.97 71.13,38.96
  BOTTOM w0.14: 71.13,38.96 70.8,38.63 70.8,38.22 70.64,38.07 v3(70.33,38.07)
M_A_DQS_DN5: length 20.3
  TOP w0.14: v3(73.84,27.69) 73.84,27.7 73.84,27.97 73.74,28.07 73.51,28.07 RAM2.P11
  L3 w0.114: v3(73.84,27.69) 74.14,27.39 74.3,27.39 74.41,27.5 74.41,29.07 75.17,29.83 75.17,31.72 73.98,32.91 73.98,35.3 v3(73.6,35.69)
  BOTTOM w0.076: v3(73.6,35.69) 73.91,35.84 73.95,35.86 74.27,36.18 74.27,40.3 75.41,41.44 75.41,42.82 75.48,43.12 75.48,43.35 75.45,43.42 75.42,43.5 75.42,43.91 CPU1.P34
M_A_DQS_DN6: length 24.9
  TOP w0.14: v3(66.68,28.45) 66.68,28.21 66.82,28.07 RAM2.D11
  L8 w0.114: v3(66.68,28.45) 66.85,28.62 66.85,30.14 66.32,30.68 66.32,33.73 66.77,34.19 67.11,34.19 67.19,34.12 67.35,34.12 67.51,34.28 67.51,34.44 67.44,34.52 67.44,34.86 67.73,35.14 68.07,35.14 68.14,35.07 68.3,35.07 68.47,35.23 68.47,35.39 68.39,35.47 68.39,35.81 68.72,36.13 68.72,41.37 68.96,41.61 69.09,41.61 69.2,41.72 69.2,41.95 69.09,42.07 68.96,42.07 68.72,42.31 68.72,42.94 69.58,43.81 69.93,43.81 70.01,43.73 70.17,43.73 70.33,43.89 70.33,44.05 70.25,44.14 70.25,44.48 70.89,45.12 70.89,47.11 71.32,47.53 v3(71.47,47.53)
  BOTTOM w0.14: CPU1.G30 v3(71.47,47.53)
M_A_DQS_DN7: length 24.1
  TOP w0.14: v3(71.91,28.47) 71.85,28.54 71.51,28.54 71.28,28.31 71.28,28.19 71.4,28.07 RAM2.L11
  L8 w0.114: v3(74.13,46.86) 74.25,46.86 74.36,46.74 74.36,44.71 74.74,44.33 75.01,44.33 75.01,44.33 75.08,44.33 75.2,44.22 75.2,43.96 75.1,43.86 74.67,43.86 74.46,43.65 74.46,43.12 74.69,42.9 75.1,42.9 75.2,42.79 75.2,41.22 74.54,40.57 74.54,34.62 74.36,34.44 74.36,34.42 72.37,32.43 72.37,28.35 72.24,28.22 72.17,28.15 72.03,28.15 71.91,28.27 v3(71.91,28.47)
  BOTTOM w0.14: v3(74.13,46.86) 73.87,46.84 73.76,46.93 CPU1.L30
M_A_DQS_DP0: length 34
  TOP w0.14: v3(52.76,31.4) 52.76,31.35 52.43,31.01 RAM1.L10
  L3 w0.114: v3(52.76,31.4) 53.46,32.09 53.46,33.7 54.95,35.19 55.41,35.19 55.52,35.07 55.52,34.11 55.76,33.87 56.17,33.87 56.41,34.11 56.41,36.34 56.67,36.59 57.14,36.59 57.26,36.48 57.26,35.81 57.5,35.56 57.91,35.56 58.15,35.81 58.15,36.48 58.26,36.59 59.77,36.59 61.55,38.38 63.21,40.03 63.34,40.16 63.99,40.81 63.99,41.92 63.75,42.16 63.7,42.16 63.59,42.27 63.59,42.5 63.7,42.62 63.75,42.62 63.99,42.86 63.99,44.54 63.73,44.81 63.73,45.49 63.93,45.7 63.93,46.37 63.96,46.4 63.96,46.41 v3(63.96,46.41)
  BOTTOM w0.076: CPU1.D27 69.03,48.93 68.74,48.85 68.54,48.8 68.45,48.79 68.45,48.79 68.28,48.73 68.02,48.73 67.92,48.76 67.68,48.76 67.41,48.5 66.29,48.5 66.11,48.32 66.11,48.26 66.02,48.17
  BOTTOM w0.14: 66.02,48.17 65.69,47.83 64.26,46.4 63.96,46.4 63.96,46.41 v3(63.96,46.41)
M_A_DQS_DP1: length 28.2
  TOP w0.14: RAM1.P10 54.59,31.01 54.69,31.12 54.69,31.28 v3(54.69,31.42)
  L8 w0.114: v3(64.86,43.01) 64.74,43.13 64.43,43.13 64.28,42.98 64.28,42.64 64.29,42.63 64.29,42.15 63.64,41.5 63.64,39.68 59.74,35.78 59.58,35.78 59.4,35.97 59.06,35.97 58.77,35.68 58.77,35.34 58.95,35.15 58.95,34.99 58.29,34.33 58.29,31.13 57.77,30.61 56.9,30.61 56.79,30.73 56.79,30.94 56.55,31.18 56.14,31.18 55.9,30.94 55.9,30.73 55.79,30.61 54.99,30.61 54.47,31.14 54.47,31.32 54.57,31.42 v3(54.69,31.42)
  BOTTOM w0.076: 67.38,46.42 67.42,46.45 67.93,46.45 68.09,46.36 68.2,46.36 68.34,46.42 68.71,46.42 68.81,46.52 CPU1.C31
  BOTTOM w0.102: v3(64.86,43.01) 65.16,43.01 66.08,43.92 66.08,45.11 66.81,45.84 67.38,46.42
M_A_DQS_DP2: length 39.5
  TOP w0.14: RAM1.D10 47.88,31.01 47.88,31.09 v3(47.55,31.42)
  L8 w0.114: v3(47.55,31.42) 47.81,31.81 47.97,32.09 47.97,32.38 47.96,32.38 47.96,33.88 48.2,34.12 48.26,34.12 49.87,35.73 49.87,36.07 49.46,36.48 49.46,36.64 49.62,36.81 49.78,36.81 50.2,36.39 50.54,36.39 52.38,38.23 52.38,38.57 52.06,38.89 52.06,39.05 52.22,39.21 52.38,39.21 52.7,38.9 53.04,38.9 54.81,40.67 54.81,44.3 56.63,46.11 60.55,46.11 64.81,50.37 64.81,50.82 65.05,51.06 70.72,51.06 70.93,50.85 v3(71.46,50.62)
  BOTTOM w0.14: CPU1.G24 v3(71.46,50.62)
M_A_DQS_DP3: length 37.1
  TOP w0.14: RAM1.G10 49.83,31.01 49.51,31.33 v3(49.51,31.42)
  L3 w0.114: v3(49.51,31.42) 49.71,31.62 49.71,31.74 49.53,31.93 49.53,32.23 49.22,32.55 49.22,33.96 49.81,34.56 49.81,37.52 50.05,37.76 51.24,37.76 51.36,37.87 51.36,38.09 51.24,38.21 50.05,38.21 49.81,38.45 49.81,39.14 61.96,51.3 63.45,51.3 v3(63.97,51.05)
  BOTTOM w0.076: v3(63.97,51.05) 63.97,51.6 64.15,51.78 64.68,51.78 64.76,51.7 67.05,51.7 67.41,51.34 67.76,51.34 67.78,51.33 68.02,51.24 68.28,51.24 68.45,51.3 68.8,51.38 69.1,51.46 69.34,51.6 CPU1.D23
M_A_DQS_DP4: length 21.1
  TOP w0.14: v3(68.64,27.66) 68.96,27.27 RAM2.G10
  L3 w0.114: v3(68.64,27.66) 68.24,27.83 68.05,28.02 67.98,28.09 67.98,28.96 67.73,29.22 67.73,33.07 67.97,33.31 68.21,33.31 68.32,33.42 68.32,33.65 68.21,33.77 67.97,33.77 67.73,34.01 67.73,34.72 69.18,36.17 69.18,37.21 69.18,38.39 69.44,38.65 v3(70.3,38.65)
  BOTTOM w0.076: CPU1.J34 72.36,44.22 72.2,43.83 72.15,43.67 72.15,43.66 72.13,43.65 72.13,43.44 72.1,43.36 72.1,43.08 72.13,43 72.13,42.32 71.33,41.51 71.33,41.05 71.32,41.05 71.32,40.32 71.32,40.18 71.32,39.7 71.04,39.42 71.04,39.29 70.93,39.18 70.93,39.17
  BOTTOM w0.14: v3(70.3,38.65) 70.49,38.73 70.93,39.17
M_A_DQS_DP5: length 20.2
  TOP w0.14: RAM2.P10 73.51,27.27 73.84,26.94 v3(73.84,26.87)
  L3 w0.114: v3(73.62,36.3) 74.2,35.72 74.2,33 75.39,31.81 75.39,29.74 74.63,28.98 74.63,27.41 74.39,27.17 74.14,27.17 v3(73.84,26.87)
  BOTTOM w0.076: v3(73.62,36.3) 73.75,36.17 74.01,36.17 74.1,36.26 74.1,40.38 75.23,41.51 75.23,42.84 75.3,43.14 75.3,43.32 75.24,43.47 75.24,43.67 CPU1.P35
M_A_DQS_DP6: length 24.9
  TOP w0.14: RAM2.D10 67.01,27.36 v3(66.68,27.69)
  L8 w0.114: v3(71.47,46.9) 71.1,46.54 71.1,45.03 70.47,44.39 70.47,44.23 70.55,44.14 70.55,43.8 70.26,43.51 69.92,43.51 69.84,43.6 69.67,43.6 68.93,42.85 68.93,42.4 69.05,42.28 69.18,42.28 69.42,42.04 69.42,41.63 69.18,41.39 69.05,41.39 68.93,41.28 68.93,36.04 68.61,35.72 68.61,35.56 68.68,35.48 68.68,35.14 68.39,34.85 68.05,34.85 67.98,34.93 67.82,34.93 67.65,34.77 67.65,34.6 67.73,34.53 67.73,34.19 67.44,33.9 67.1,33.9 67.03,33.98 66.86,33.98 66.53,33.64 66.53,30.77 67.07,30.23 67.07,28.28 v3(66.68,27.69)
  BOTTOM w0.14: v3(71.47,46.9) 71.82,46.9 71.92,47 CPU1.H30
M_A_DQS_DP7: length 24.2
  TOP w0.14: RAM2.L10 71.56,27.27 v3(71.89,27.69)
  L8 w0.114: v3(71.89,27.69) 72.29,27.97 72.33,28 72.58,28.26 72.58,32.34 74.57,34.33 74.57,34.35 74.76,34.53 74.76,40.48 75.41,41.13 75.41,42.88 75.19,43.11 74.78,43.11 74.68,43.21 74.68,43.57 74.76,43.65 75.19,43.65 75.41,43.87 75.41,44.31 75.17,44.55 74.92,44.55 74.92,44.55 74.83,44.55 74.58,44.8 74.58,47.16 v3(74.24,47.5)
  BOTTOM w0.14: v3(74.24,47.5) CPU1.N30
M_A_ODT0: length 64.8
  TOP w0.152: v3(51.13,28.92) 51.13,28.93 51.13,28.95 51.13,29.41 RAM1.J8 ; v3(69.88,25.2) 70.26,25.58 70.26,25.67 RAM2.J8 ; v2(62.45,26.73) 62.45,26.37 60.79,24.72 R1219.2
  L5 w0.152: v2(62.45,26.73) 62.45,27.08 62.51,27.14 62.51,28.75 65.97,32.21 69.66,32.21 70.03,31.83 75.09,31.83 75.25,31.67 75.25,31.2 75.4,31.04 75.88,31.04 76.28,31.45 77.11,31.45 79.88,34.22 79.88,37.02 80.11,37.26 80.11,43.73 79.95,43.9 79.95,44.78 81.48,46.31 v3(81.5,46.31)
  L8 w0.114: v3(69.88,25.2) 69.44,24.76 64.85,24.76 64.31,25.3 64.31,26.11 64.2,26.23 63.52,26.23 63.41,26.34 63.41,26.57 63.52,26.68 64.2,26.68 64.31,26.8 64.31,27.25 63.84,27.72 63.31,27.72 62.45,26.85 v2(62.45,26.73) 61.25,27.93 52.75,27.93 51.51,28.55 v3(51.13,28.92)
  BOTTOM w0.152: CPU1.AE31 81.52,46.36 v3(81.5,46.31)
M_B_A0: length 43.8
  TOP w0.152: RN1301.5 94.3,18.95 93.21,20.05 93.21,20.74 RAM3.R2 93.08,20.97 v3(93.4,21.28)
  L8 w0.114: v3(81.57,39.12) 82,38.68 82,34.8 82.01,34.8 82.01,34.45 82,34.45 82,34.37 81.55,33.92 81.55,26.41 83.15,24.82 85.51,24.82 85.62,24.71 94.96,24.71 95.37,24.3 95.37,21.5 94.73,20.85 93.83,20.85 v3(93.4,21.28)
  BOTTOM w0.076: 82.1,39.74 82.1,39.98 82.23,40.11 82.23,41.4 82.77,41.95 82.77,42.89 82.85,43.11 82.85,43.33 82.82,43.42 82.82,43.5 82.74,43.73 CPU1.AF35
  BOTTOM w0.152: v3(81.57,39.12) 81.78,38.91 82,38.91 82.1,39.01 82.1,39.74
M_B_A1: length 41.1
  TOP w0.152: RN1301.6 93.71,19.18 92.72,20.17 v3(92.72,20.4) 92.72,20.58 92.43,20.87 RAM3.P2
  L6 w0.152: v3(92.72,20.4) 92.72,20.2 92.46,19.94 90.61,19.94 90.23,20.33 90.23,20.56 89.56,21.23 89.56,21.96 88.66,22.86 88.66,23.82 88.26,24.23 87.36,24.49 86.69,24.69 85.4,24.69 83.62,25.29 82.82,26.1 82.82,35.84 82.43,36.23 82.43,40.45 81.17,41.7 80.12,44.32 80.12,47.17 v3(79.68,47.62)
  BOTTOM w0.152: CPU1.AB29 v3(79.68,47.62)
