# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
U3301_GPIO1: length 13.8
  TOP w0.102: AFTP3302.1 16.7,4.8 15.79,5.71 v2(15.79,5.71)
  BOTTOM w0.102: U3301.30 11.54,13.2 12.16,12.58 12.78,12.58 13.21,12.15 13.21,10.87 14.14,9.94 14.14,9.94 14.26,9.82 14.26,9.82 14.9,9.18 14.9,8.03 15.12,7.81 15.75,7.81 16.4,7.16 16.4,6.32 v2(15.79,5.71)
UART_2_CRXD_DTXD: length 158.1
  TOP w0.089: R6803.1 31.88,23.15 32.88,22.15 32.88,18.79 37.1,14.57 v2(37.1,14.55)
  L5 w0.089: v2(117.54,60.84) 118.68,60.84 122.28,57.23 122.28,55.48 123.69,54.07 123.69,50.82 124.45,50.05 124.45,48.86 124.94,48.37 124.94,46.1 123.59,44.74 123.59,41.54 121.84,39.8 121.84,31.72 121.26,31.14 121.26,28.25 121.26,27.92 121.26,27.92 121.26,25.18 119.56,23.48 119.36,23.48 119.36,23.48 v2(119.37,23.48)
  L8 w0.076: v2(119.37,23.48) 120.11,22.74 120.11,21.88 121.45,20.53 121.45,15.89 117.55,11.99 108.53,11.99 108.2,12.32 92.82,12.32 91.31,13.84 72.78,13.84 71.94,14.67 53.02,14.67 51.87,13.53 43.85,13.53 43.67,13.35 37.79,13.35 37.1,14.04 v2(37.1,14.55)
  BOTTOM w0.089: CPU1.CR12 112.62,58.45 113.43,58.45 113.48,58.49 114.26,58.49 114.48,58.72 114.53,58.72 114.76,58.95 114.76,58.99 114.91,59.14 115.75,59.14 v1(116.28,59.67) 116.66,60.04 117.34,60.04 117.35,60.05 ; v2(117.54,60.84) 117.54,60.24 117.35,60.05 ; R2048.2 117.35,60.05
UART_2_CRXD_DTXD_CON: length 4.7
  TOP w0.089: R6803.2 32.18,24.71 v1(32.18,25.82) 31.72,25.82 31.62,25.72 29.15,25.72 DB1.14
UART_2_CTXD_DRXD: length 148.8
  TOP w0.089: v2(36.02,14.74) 35.69,15.07 35.69,15.5 32.49,18.7 v1(32.49,20.18) 32.49,21.77 32.49,22.06 31.06,23.49 R6802.1
  L5 w0.089: v2(118.87,24.25) 118.85,24.25 119.62,25.02 119.62,28.55 119.74,28.68 119.74,29.32 119.74,29.33 119.74,30.68 121.14,32.08 121.14,40.46 122.16,41.49 122.16,54.44 121.33,55.27 121.33,56.85 119.1,59.08 v2(116.55,59.08)
  L8 w0.076: v2(36.02,14.74) 36.7,15.41 39.51,15.41 39.98,15.87 72.5,15.87 73.34,15.03 95.16,15.03 95.89,14.3 107.59,14.3 108.34,15.04 114.97,15.04 118.54,18.62 118.54,23.92 v2(118.87,24.25)
  BOTTOM w0.076: CPU1.CP12 112.06,58.6 112.25,58.41 arc(112.5,58.25) 112.79,58.19
  BOTTOM w0.089: 112.79,58.19 114.15,58.19 114.28,58.32 114.34,58.32 114.56,58.54 114.6,58.54 114.84,58.77 116.25,58.77 v2(116.55,59.08) 116.73,59.25 R2049.2
UART_2_CTXD_DRXD_CON: length 3.6
  TOP w0.089: DB1.13 29.93,24.67 30.53,25.28 30.99,25.28 v1(31.19,25.08) 31.19,24.89 30.66,24.35 R6802.2
UPD1_ALERT_R: length 2.8
  BOTTOM w0.127: U7201.B6 26.82,64.39 26.82,65.77 27.35,66.3 R7235.2
UPD1_SMBINT#: length 49.4
  TOP w0.127: v1(30.84,28.3) 30.33,28.8 v2(30.18,28.8)
  L6 w0.127: v2(27.88,68.89) 31,65.76 31,65.66 31.04,65.62 31.04,64.82 31.33,64.53 31.33,59.37 34.22,56.48 34.22,53.34 31.25,50.38 31.25,44.36 29.76,42.87 29.76,38.45 30.79,37.42 30.79,34.73 30.32,34.26 30.32,28.95 v2(30.18,28.8)
  BOTTOM w0.127: v2(30.18,28.8) 30.47,28.51 30.75,28.51 30.97,28.29 U2401.32 ; R7235.1 27.35,68.06 R7215.2 27.88,68.59 v2(27.88,68.89)
USB1_CC1: length 40.6
  TOP w0.254: ED7304.1 ED7304.10
  TOP w0.305: 15.15,41.43 15.15,42.5 15.47,42.82 ED7304.1 ; v2(14.54,43.97) 14.61,43.9 ED7304.10
  TOP w0.381: 15.15,41.43 15.15,39.62 15.14,39.61 15.14,39.14 15.15,39.13 15.15,39.02 15.63,38.53 v2(15.64,38.53)
  L5 w0.381: v2(14.54,43.97) 14.54,45.09 15.58,46.13 15.58,47.78 17.11,49.31 17.89,49.31 19.82,51.23 19.82,56.03 19.85,56.06 v3(19.85,56.15)
  BOTTOM w0.089: 24.22,58.09 25.08,58.95 U7201.L9
  BOTTOM w0.229: USB1.A5 9.06,32.35 9.28,32.57 10.01,32.57 10.17,32.41 10.63,32.41 10.64,32.42
  BOTTOM w0.381: 10.64,32.42 12.36,34.14 12.36,34.16 12.43,34.24 12.43,35.5 12.36,35.58 12.36,37.57 v1(12.74,37.95) 13.02,38.23 15.34,38.23 v2(15.64,38.53) ; v3(19.85,56.15) 20.04,55.96 21.58,55.96 C7217.1 22.21,56.11 R7211.2 22.52,56.77 22.93,57.17 23.3,57.17 24.22,58.09
USB1_CC2: length 44
  TOP w0.102: 7.68,35.06 7.3,34.75 7.19,34.48 USB1.B5
  TOP w0.203: v2(15.58,44.68) 15.97,44.3 ED7304.9 ED7304.2 15.97,42.71 15.63,42.37 15.63,41.69
  TOP w0.381: 15.63,41.69 15.71,41.61 v2(15.71,39.3) ; 7.68,35.06 9.24,35.76 9.27,35.79 9.37,35.85 9.5,35.97 9.56,36.07 9.56,36.08 10.5,37.02 10.5,38.64 v2(10.07,39.07) ; v2(16.93,58.65) 17.82,57.76 20.25,57.76 21.27,56.75 C7218.1 21.91,56.77 R7212.2 21.91,57.83 23,58.92 23.08,58.92 23.14,58.98 v2(23.55,58.98)
  L3 w0.381: v2(16.93,58.65) 16.34,58.65 15.96,58.27 15.96,56.77 15.98,56.76 15.98,53.53 15.96,53.51 15.96,52.72 15.98,52.71 15.98,51.55 15.54,51.12 15.54,50.23 14.81,49.5 14.81,45.78 15.58,45.01 v2(15.58,44.68)
  BOTTOM w0.381: v2(10.07,39.07) 10.07,39.2 11.05,40.18 12.81,40.18 12.85,40.17 13.12,40.17 13.16,40.18 13.97,40.18 v1(14.47,39.68) 14.84,39.3 v2(15.71,39.3)
USB1_SBU1: length 26.7
  TOP w0.127: v1(18.28,44.79) v2(18.28,44.23) 18.09,44.41 17.18,44.41 16.97,44.2 ED7304.7 ED7304.4 16.97,42.34 R7153.2 ; v2(11.06,31.17) 11.2,31.31 11.2,33.01 R7330.1 9.94,33.51 v2(9.91,33.55)
  L5 w0.127: v2(11.06,31.17) 11.34,30.89 13.58,30.89 14.92,32.24 14.92,40.03 16.87,41.97 16.87,42.82 18.27,44.23 v2(18.28,44.23)
  BOTTOM w0.127: v2(9.91,33.55) 9.39,33.55 9.08,33.85 USB1.A8
USB1_SBU1_R: length 3.8
  TOP w0.127: U7101.27 18.97,39.61 18.61,39.97 17.74,39.97 17.11,40.6 17.11,41.01 R7153.1
USB1_SBU2: length 27.2
  TOP w0.127: v2(18.27,43.59) 18.22,43.59 17.91,43.9 ED7304.6 ED7304.5 17.47,42.29 R7151.2
  L5 w0.102: USB1.B8 7.21,31.83 7.21,31.68 7.28,31.53 7.55,31.26 8.01,31.09
  L5 w0.127: 8.01,31.09 8.42,31.09 9.23,30.28 9.26,30.27 9.37,30.17 9.45,30.1 11.8,30.1 11.82,30.11 13.16,30.11 15.18,32.13 15.18,39.81 18.27,42.9 v2(18.27,43.59)
  BOTTOM w0.127: v2(18.27,43.59) 18.36,43.68 v1(18.82,43.68) 18.9,43.6 R7331.1
USB1_SBU2_R: length 4.1
  TOP w0.127: 18.18,40.23 18.72,40.23 19.37,39.57 U7101.26 ; 18.18,40.23 v1(18.18,40.44) ; 18.18,40.23 17.84,40.23 17.36,40.71 17.36,41.08 R7151.1
USB1_SSRX_CON_N1: length 12.8
  TOP w0.102: C7121.2 12.48,37.57 12.4,37.49 R7120.1 11.34,37.49 v2(11.17,37.31)
  L3 w0.089: USB1.B10 7.12,31.07 8.11,31.07 10.59,33.54 10.59,35.35 11.95,36.72 11.95,37.74 11.87,37.83 11.7,37.83 11.59,37.73 11.59,37.22 11.5,37.14 11.34,37.14 v2(11.17,37.31)
USB1_SSRX_CON_N2: length 10.3
  TOP w0.102: C7123.2 11.89,30.7 R7122.1 11.35,30.82 11.22,30.69 11.22,30.4 11.12,30.3 10.73,30.3 10.55,30.48 10.55,31.35 10.78,31.58 10.78,32.37 10.28,32.87 9.76,32.87 9.21,33.43 9.21,34.79 9.4,34.98 9.44,35 9.62,35 v2(9.93,34.69)
  BOTTOM w0.102: USB1.A10 9.07,34.85 9.34,35.12 9.59,35.12 9.71,35 9.71,34.91 v2(9.93,34.69)
USB1_SSRX_CON_P1: length 12.8
  TOP w0.102: v2(11.16,38.02) 11.34,38.2 R7119.1 12.35,38.2 12.48,38.33 C7120.2
  L3 w0.089: v2(11.16,38.02) 11.97,38.02 12.14,37.85 12.14,36.64 10.78,35.27 10.78,33.46 8.19,30.88 7.08,30.88 USB1.B11
USB1_SSRX_CON_P2: length 10.4
  TOP w0.102: C7122.2 11.93,29.93 R7123.1 11.36,30.07 10.63,30.07 10.33,30.38 10.33,30.52 10.32,30.52 10.32,30.57 10.33,30.57 10.33,31.45 10.55,31.68 10.55,32.28 10.19,32.64 9.67,32.64 8.98,33.34 8.98,34.89 9.27,35.17 9.39,35.23 9.61,35.23 v2(10,35.32)
  BOTTOM w0.102: USB1.A11 9.71,35.35 v2(10,35.32)
USB1_SSRX_MUX_N1: length 5.1
  TOP w0.102: C7121.1 13.28,37.63 ED7301.7 ED7301.4 15.29,37.63 15.41,37.76 16.66,37.76 16.91,37.51 17.41,37.51 17.55,37.38 U7101.31
USB1_SSRX_MUX_N2: length 7.6
  TOP w0.102: U7101.39 17.72,34.18 17.64,34.09 17.47,34.09 17.23,33.85 17.23,31.89 15.84,30.5 15.54,30.5 15.53,30.5 15.41,30.62 ED7302.2 ED7302.9 13.25,30.62 C7123.1
USB1_SSRX_MUX_P1: length 5.1
  TOP w0.102: U7101.30 17.45,37.78 17.41,37.74 17.01,37.74 16.76,37.99 15.41,37.99 15.26,38.13 ED7301.5 ED7301.6 13.59,38.13 13.39,38.33 C7120.1
USB1_SSRX_MUX_P2: length 7.7
  TOP w0.102: C7122.1 13.37,30.12 ED7302.10 ED7302.1 15.39,30.12 15.54,30.27 15.93,30.27 17.46,31.79 17.46,33.76 17.56,33.86 17.72,33.86 17.8,33.78 U7101.40
USB1_SSTX_CON_N1: length 13.7
  TOP w0.102: C7163.2 15.56,35.95 15.38,36.13 ED7301.1 ED7301.10 13.14,36.13 12.91,35.91 12.91,35.09 12.57,34.75 12.14,34.75 v2(11.86,34.47)
  L3 w0.089: v2(9.69,31.31) 10.18,30.82 10.32,30.82 10.43,30.94 10.43,31.52 10.55,31.64 10.55,32.73 11.67,33.85 12.18,33.85 12.58,34.25 12.58,34.97 12.47,35.07 12.3,35.07 12.22,34.98 12.22,34.56 12.13,34.47 v2(11.86,34.47)
  BOTTOM w0.102: v2(9.69,31.31) 9.52,31.13 9.28,31.13 9.07,31.35 USB1.A3
USB1_SSTX_CON_N2: length 15.2
  TOP w0.102: v2(12.28,32.92) 12.5,33.14 12.69,33.14 12.79,33.04 12.79,32.31 12.98,32.12 13.23,32.12 13.23,32.12 ED7302.6 ED7302.5 15.37,32.12 15.53,31.96 16.18,31.96 16.28,32.06 16.28,32.35 C7162.2
  L8 w0.089: v2(12.28,32.92) 12.44,32.65 12.54,32.55 12.67,32.55 12.75,32.64 12.75,33.39 12.59,33.56 11.34,33.56 10.54,32.76 9.57,32.76 8.82,33.51 8.82,34.15 7.79,35.18 7.38,35.18 7.29,35.09 7.29,34.89 7.2,34.8 USB1.B3
USB1_SSTX_CON_P1: length 13.7
  TOP w0.102: C7164.2 15.49,36.71 15.41,36.63 ED7301.2 ED7301.9 13.92,36.63 13.65,36.36 13.04,36.36 12.68,36 12.68,35.19 12.48,34.98 12.14,34.98 v2(11.86,35.26)
  L3 w0.089: v2(9.7,30.54) 10.07,30.54 10.16,30.63 10.4,30.63 10.62,30.86 10.62,31.44 10.74,31.56 10.74,32.65 11.75,33.66 12.26,33.66 12.77,34.17 12.77,35.05 12.55,35.26 v2(11.86,35.26)
  BOTTOM w0.102: USB1.A2 9.39,30.85 v2(9.7,30.54)
USB1_SSTX_CON_P2: length 15.2
  TOP w0.102: C7161.2 16.51,32.35 16.51,31.96 16.27,31.73 15.45,31.73 15.35,31.62 ED7302.4 ED7302.7 13.62,31.62 13.34,31.89 13.13,31.89 12.89,31.89 12.53,32.24 v2(12.24,32.24)
  L8 w0.089: v2(12.24,32.24) 12.74,32.36 12.94,32.56 12.94,33.47 12.66,33.75 11.26,33.75 10.46,32.95 9.65,32.95 9.01,33.58 9.01,34.23 7.87,35.37 7.25,35.37 USB1.B2
USB1_SSTX_MUX_N1: length 1.5
  TOP w0.102: C7163.1 16.95,36.23 17.56,36.23 17.61,36.18 U7101.34
USB1_SSTX_MUX_N2: length 3.2
  TOP w0.102: U7101.36 17.09,35.38 16.28,34.57 16.28,34.43 16.07,34.22 16.07,33.87 16.01,33.8 C7162.1
USB1_SSTX_MUX_P1: length 1.5
  TOP w0.102: U7101.33 17.68,36.58 17.56,36.46 16.93,36.46 C7164.1
USB1_SSTX_MUX_P2: length 3.3
  TOP w0.102: C7161.1 16.77,33.74 16.66,33.86 16.4,33.86 16.3,33.96 16.3,34.13 16.51,34.34 16.51,34.47 17.18,35.15 17.38,35.15 17.55,34.98 U7101.37
USB1_USB20_CON_N: length 6.4
  TOP w0.102: v1(178.96,5.87) 178.81,5.87 ; 178.81,5.87 178.81,7.45 179.03,7.68 v2(179.03,7.8) ; 178.81,5.87 178.81,5.35 178.36,4.91 177.67,4.91 177.39,5.18 177.39,5.58 177.25,5.72 R6609.2
  BOTTOM w0.102: v2(179.03,7.8) 179.03,7.87 178.85,8.05 IO1.14
USB1_USB20_CON_P: length 5.5
  TOP w0.102: 178.58,7.07 178.58,7.58 v2(178.35,7.8) ; 178.58,7.07 v1(178.42,7.07) ; 178.58,7.07 178.58,5.44 178.27,5.14 177.76,5.14 177.62,5.28 177.62,5.58 177.76,5.72 R6608.2
  BOTTOM w0.102: IO1.13 v2(178.35,7.8)
USB1_USB20_N: length 136.8
  TOP w0.102: R6609.1 177.38,6.69 177.38,6.84 177.1,7.12 177.1,7.61 177.48,7.99 v3(177.48,8.02)
  L3 w0.089: v2(107.84,67.54) 108.16,67.22 114.16,67.22 119.53,61.85 122.26,61.85 126.35,57.77 126.51,57.77 127.11,57.17 127.11,55.69 128.04,54.76 128.04,53.23 129.4,51.86 129.4,48.31 129.97,47.74 129.97,36.52 128.93,35.48 128.93,26.08 126.47,23.62 126.47,14.69 125.17,13.38 125.17,9.74 127.01,7.9 129.98,7.9 130.67,8.59 137.19,8.59 137.88,7.9 139.89,7.9 140.64,7.14 149.18,7.14 151.51,9.47 154.25,9.47 155.71,8.01 155.71,7.92 156.34,7.29 166.01,7.29 167.3,8.58 167.75,8.58 170.14,8.58 170.58,9.02 174.23,9.02 174.3,8.94 176.56,8.94 v3(177.48,8.02)
  BOTTOM w0.076: 106.69,64.46 106.83,64.77 106.83,64.93 106.82,65.13 106.82,65.28 106.83,65.38 106.83,65.43 107.04,65.78
  BOTTOM w0.083: CPU1.CE3 106.69,64.46
  BOTTOM w0.102: v2(107.84,67.54) 107.84,67.44 107.68,67.28 107.62,67.28 107.38,67.05 107.38,66.49 107.38,66.19 107.36,66.17 107.04,65.78
USB1_USB20_P: length 137.6
  TOP w0.102: R6608.1 177.61,6.71 177.61,6.93 177.51,7.04 v3(177.51,7.29)
  L3 w0.089: v3(177.51,7.29) 177.26,7.04 176.71,7.04 176.62,7.13 176.62,7.45 176.71,7.54 176.99,7.54 177.08,7.63 177.08,8.15 176.48,8.75 174.23,8.75 174.15,8.83 170.66,8.83 170.22,8.39 167.68,8.39 167.67,8.39 167.38,8.39 166.09,7.1 156.27,7.1 155.52,7.84 155.52,7.93 154.17,9.28 151.59,9.28 149.26,6.95 140.57,6.95 139.81,7.71 137.8,7.71 137.11,8.4 130.75,8.4 130.06,7.71 126.93,7.71 124.98,9.66 124.98,13.46 126.28,14.77 126.28,23.7 128.74,26.16 128.74,35.55 129.78,36.6 129.78,47.66 129.21,48.24 129.21,51.78 127.85,53.15 127.85,54.68 126.92,55.61 126.92,57.09 126.43,57.58 126.27,57.58 122.18,61.66 119.45,61.66 114.08,67.03 107.94,67.03 v2(107.79,66.88)
  BOTTOM w0.076: 107.21,65.63 107,65.37 106.98,65.26 106.98,65.14 107,64.94 107,64.75 106.84,64.16
  BOTTOM w0.083: CPU1.CE4 106.59,63.61 106.62,63.62 106.84,64.07 106.84,64.16
  BOTTOM w0.102: v2(107.79,66.88) 107.71,66.88 107.61,66.78 107.61,66.49 107.61,66.12 107.55,66.04 107.54,66.03 107.21,65.63
USB1_USB30_RX_N: length 129.8
  L3 w0.089: v2(104.49,62.45) 105.4,62.45 106.7,63.75 110.56,63.75 116.31,58.01 120.5,58.01 124.11,54.39 124.11,52.04 125.97,50.18 125.97,49.56 126.45,49.08 126.45,44.75 126.26,44.56 126.26,41.97 127.21,41.03 127.21,36.88 126.7,36.37 126.7,31.11 125.79,30.21 125.79,29.36 125.74,29.31 125.74,27.34 125.18,26.78 125.18,25.59 123.93,24.33 123.93,20.29 125.45,18.77 125.45,14.45 124.62,13.62 124.62,9.51 126.78,7.35 139.66,7.35 140.42,6.59 149.69,6.59 151.87,4.42 154.33,4.42 156.63,6.72 166.21,6.72 167.53,8.03 170.49,8.03 170.93,8.47 174,8.47 174.08,8.39 175.44,8.39 175.64,8.18 175.73,8.18 175.86,8.06 175.86,7.8 v3(175.86,7.8)
  BOTTOM w0.102: IO1.8 175.85,8.38 175.72,8.25 175.72,7.99 175.86,7.85 175.86,7.8 v3(175.86,7.8) ; v2(104.49,62.45) 104.68,62.64 CPU1.CB5
USB1_USB30_RX_P: length 129.8
  L3 w0.089: v2(104.46,61.82) 104.91,62.26 105.48,62.26 106.78,63.56 110.48,63.56 116.23,57.82 120.42,57.82 123.92,54.31 123.92,51.96 125.78,50.11 125.78,49.48 126.26,49 126.26,44.83 126.07,44.64 126.07,41.89 127.02,40.95 127.02,36.96 126.51,36.45 126.51,31.19 125.6,30.28 125.6,29.44 125.55,29.38 125.55,27.42 124.99,26.86 124.99,25.67 123.74,24.41 123.74,20.21 125.25,18.69 125.25,14.53 124.43,13.7 124.43,9.43 126.7,7.16 139.58,7.16 140.34,6.4 149.61,6.4 151.79,4.23 154.41,4.23 156.71,6.53 166.29,6.53 167.61,7.84 170.57,7.84 171.01,8.28 173.92,8.28 174,8.2 175.36,8.2 175.45,8.1 175.45,7.96 v3(175.26,7.77)
  BOTTOM w0.102: v3(175.26,7.77) 175.49,8 175.49,8.24 175.35,8.38 IO1.7 ; v2(104.46,61.82) 104.46,61.83 104.52,61.83 CPU1.CB6
USB1_USB30_TX_N: length 137.2
  L3 w0.089: v2(177.47,9.94) 177.24,9.71 177.24,9.45 177.08,9.29 174.45,9.29 174.37,9.37 170.4,9.37 169.97,8.94 167.16,8.94 165.9,7.68 156.46,7.68 156.07,8.07 156.07,8.2 154.44,9.82 151.26,9.82 148.93,7.5 146.45,7.5 144.92,9.02 129.97,9.02 126.97,12.02 126.97,13.7 127.45,14.18 127.45,23.22 130.01,25.78 130.01,30.51 130.59,31.09 130.59,33.58 130.9,33.9 130.9,33.9 131.16,34.15 131.16,40.38 131.98,41.2 131.98,43 130.33,44.65 130.33,47.89 129.76,48.46 129.76,54.05 127.46,56.35 127.46,57.32 126.66,58.12 126.58,58.12 122.08,62.63 121.99,62.72 119.2,62.72 113.84,68.07 107.48,68.07 106.48,67.08 105.23,67.08 105.07,66.92 v2(104.85,66.92)
  BOTTOM w0.083: CPU1.CA4 104.17,63.58 104.39,64.07 104.39,64.17 104.5,64.54 104.51,64.59 104.51,64.62 104.55,64.7 104.57,64.73 104.57,65.01 104.56,65.03 104.54,65.13 104.54,65.27 104.56,65.41 104.57,65.42 104.57,65.75 104.51,65.8 104.4,66.14 104.4,66.5 104.82,66.92 v2(104.85,66.92)
  BOTTOM w0.102: IO1.11 177.35,9.23 177.21,9.37 177.21,9.69 v2(177.47,9.94)
USB1_USB30_TX_P: length 137.2
  L3 w0.089: v2(104.85,67.56) 105.14,67.27 106.4,67.27 107.4,68.26 113.92,68.26 119.27,62.91 122.07,62.91 122.16,62.82 126.66,58.31 126.74,58.31 127.65,57.4 127.65,56.43 129.95,54.13 129.95,48.54 130.52,47.97 130.52,44.73 132.17,43.08 132.17,41.12 131.35,40.3 131.35,34.07 130.98,33.71 130.78,33.5 130.78,31.01 130.2,30.43 130.2,25.7 127.64,23.14 127.64,14.1 127.16,13.62 127.16,12.1 130.05,9.21 145,9.21 146.52,7.69 148.85,7.69 151.18,10.01 154.52,10.01 156.26,8.28 156.26,8.15 156.54,7.87 165.82,7.87 167.08,9.13 169.89,9.13 170.33,9.56 174.45,9.56 174.53,9.48 177,9.48 177.05,9.53 177.05,9.85 176.96,9.94 v2(176.68,9.94)
  BOTTOM w0.083: v2(104.85,67.56) 104.46,67.16 104.46,66.8 104.23,66.57 104.23,66.11 104.24,66.08 104.36,65.71 104.39,65.68 104.39,65.45 104.38,65.36 104.37,65.35 104.37,65.34 104.37,65.12 104.39,64.94 104.39,64.77 104.39,64.77 CPU1.CA3
  BOTTOM w0.102: v2(176.68,9.94) 176.68,9.94 176.99,9.64 176.99,9.36 176.85,9.23 IO1.10
USB2_ID: length 2
  TOP w0.102: v1(106.59,60.52) 107.18,60.52 v2(107.23,60.57) 107.47,60.32 R1601.2
  BOTTOM w0.102: v2(107.23,60.57) 107.23,60.57 107.23,60.61 107.05,60.61 CPU1.CE8
USB2_VBUSSENSE: length 2.7
  TOP w0.102: R1602.2 104.94,63.75 104.94,62.64 v1(105.15,62.43) 105.46,62.12 v2(105.46,61.85)
  BOTTOM w0.102: v2(105.46,61.85) 105.45,61.84 105.45,61.84 105.44,61.84 105.54,61.93 105.61,61.93 CPU1.CC6
USB4_USB20_CMC_N1: length 3.6
  BOTTOM w0.102: EL7201.1 27.79,56.95 27.79,57.18 27.24,57.72 26.42,58.55 26.42,59.19 26.58,59.35 U7201.L6
USB4_USB20_CMC_N2: length 3.7
  BOTTOM w0.102: EL7202.1 26,56.94 25.8,57.13 25.8,57.27 25.91,57.37 26.34,57.37 26.44,57.48 26.44,57.62 26.22,57.84 26.22,58 26,58.22 26,59.36 26.08,59.44 U7201.L7
USB4_USB20_CMC_P1: length 4.3
  BOTTOM w0.102: EL7201.4 28.01,57.06 28.01,57.27 27.33,57.95 26.64,58.64 26.64,59.09 26.8,59.25 26.8,59.92 U7201.K6
USB4_USB20_CMC_P2: length 3.8
  BOTTOM w0.102: EL7202.4 26.76,57.63 26.45,57.93 26.45,58.09 26.23,58.32 26.23,59.27 26.3,59.34 26.3,59.92 U7201.K7
USB4_USB20_CON_N1: length 46.4
  TOP w0.102: v2(11.19,42.47) 11.72,41.94 ED7303.10 ED7303.1 11.72,40.19 11.82,40.09 11.82,40 11.7,39.88 11.38,39.88 11.11,40.15 10.88,40.15 ; v2(9.22,40.39) 9.38,40.39 9.9,39.88 10.16,39.88 10.44,40.15 10.88,40.15 ; 10.88,40.15 v1(10.88,40.36)
  L8 w0.089: v2(11.19,42.47) 11.89,41.77 12.7,41.77 13.28,42.35 13.28,42.58 13.28,43.4 14.29,44.41 14.51,44.41 15.98,45.88 15.98,48.31 20.1,52.43 20.1,53.98 22.36,56.23 26.78,56.23 27.94,55.07 27.94,54.59 27.85,54.51 27.58,54.51 27.49,54.42 v2(27.49,54.15)
  BOTTOM w0.102: v2(9.22,40.39) 9.2,40.39 8.93,40.12 8.67,39.86 8.67,38.86 9.17,38.36 9.91,38.36 10.5,37.77 10.5,36.34 10.66,36.19 10.66,35.5 10.6,35.44 10.6,33.53 10.18,33.11 9.46,33.11 9.22,33.35 USB1.A7 ; EL7201.2 27.58,55.86 27.67,55.76 27.67,54.58 27.49,54.39 v2(27.49,54.15)
USB4_USB20_CON_N2: length 46.2
  TOP w0.102: v2(13.05,39.05) 13.23,39.22 ED7303.4 ED7303.7 13.23,41.74 13.38,41.89 13.38,42.09 13.68,42.4 13.89,42.4 ; 13.89,42.4 14.25,42.4 v2(14.51,42.65) ; 13.89,42.4 v1(13.89,42.59)
  L3 w0.089: v2(13.05,39.05) 13.05,39.07 13.3,39.31 13.3,39.5 12.79,40 11.28,40 10.72,39.44 10.72,37.07 9.09,35.44 9.09,33.52 8.58,33 8.37,33 8.28,32.92 8.28,32.79 8.2,32.7 USB1.B7
  L8 w0.089: v2(14.51,42.65) 14.77,42.39 15.27,42.39 17.09,44.21 17.09,47.89 17,47.98 17,48.8 17.7,49.5 20.3,49.5 22.31,47.49 24.41,47.49 25.59,48.67 27.39,48.67 28.42,49.7 28.42,52.11 27.08,53.45 26.84,53.45 26.54,53.75 26.35,53.75 v2(25.96,54.14)
  BOTTOM w0.102: v2(25.96,54.14) 26.24,54.42 26.24,55.34 26.24,55.91 EL7202.2
USB4_USB20_CON_P1: length 45.8
  TOP w0.102: v2(11.98,42.47) 12.09,42.36 12.09,41.92 12.22,41.78 ED7303.9 ED7303.2 12.22,39.98 11.9,39.65 11.29,39.65 11.02,39.92 10.53,39.92 10.26,39.65 9.81,39.65 9.75,39.71 v2(9.21,39.71)
  L8 w0.089: v2(28.28,54.15) 28.28,54.5 28.13,54.64 28.13,55.15 26.85,56.42 22.28,56.42 19.91,54.06 19.91,52.51 15.79,48.38 15.79,45.95 14.43,44.6 14.21,44.6 13.09,43.48 13.09,42.5 13.09,42.42 12.62,41.96 11.97,41.96 11.8,42.13 11.8,42.3 v2(11.98,42.47)
  BOTTOM w0.102: v2(9.21,39.71) 8.9,39.4 8.9,38.95 9.26,38.59 10.01,38.59 10.73,37.87 10.73,36.43 10.88,36.28 10.88,35.4 10.83,35.35 10.83,33.44 10.28,32.88 9.37,32.88 9.34,32.85 USB1.A6 ; v2(28.28,54.15) 27.9,54.52 27.9,55.29 ; 27.9,55.29 v1(28.06,55.29) ; 27.9,55.29 27.9,55.72 27.96,55.77 EL7201.3
USB4_USB20_CON_P2: length 46.1
  TOP w0.102: v2(14.51,41.86) 14.2,42.17 13.78,42.17 13.61,41.99 13.61,41.79 13.6,41.79 13.72,41.66 ED7303.6 ED7303.5 13.72,40.1 13.54,39.91 13.54,39.25 v2(13.72,39.07)
  L3 w0.089: USB1.B6 8.2,33.5 8.28,33.41 8.28,33.28 8.37,33.2 8.5,33.2 8.9,33.6 8.9,35.52 10.53,37.15 10.53,39.52 11.2,40.2 12.87,40.2 13.49,39.58 13.49,39.43 13.58,39.33 13.58,39.2 v2(13.72,39.07)
  L8 w0.089: v2(26.75,54.14) 26.75,53.81 26.92,53.64 27.15,53.64 28.61,52.19 28.61,49.62 27.47,48.48 25.67,48.48 24.49,47.3 22.23,47.3 20.22,49.31 17.78,49.31 17.19,48.72 17.19,48.05 17.28,47.97 17.28,44.13 15.35,42.2 14.84,42.2 v2(14.51,41.86)
  BOTTOM w0.102: v1(26.65,55.24) 26.47,55.24 ; 26.47,55.24 26.47,54.42 v2(26.75,54.14) ; 26.47,55.24 26.47,55.34 26.47,55.86 EL7202.3
USB4_USB20_N: length 143.1
  L8 w0.089: v2(111.42,71.31) 111.42,72.38 109.61,74.19 109.61,79.59 111.8,81.77 111.8,86.71 110.28,88.23 76.12,88.23 75.95,88.05 68.49,88.05 65.29,84.84 65.29,81.15 64.93,80.8 64.04,80.8 63,79.76 59.86,79.76 58.91,78.81 58.91,76.91 58.58,76.59 53.84,76.59 53.59,76.84 41.58,76.84 39.7,74.97 37.19,74.97 34.93,72.71 28.72,72.71 27.35,71.34 27.35,71.06 27.11,70.81 25.92,70.81 23.91,68.8 23.91,68.04 26.9,65.05 26.9,61.87 27.33,61.45 27.33,60.33 26.81,59.81 26.48,59.81 26.14,59.47 26.14,58.59 26.4,58.33 27.16,58.33 v2(27.5,58.36)
  BOTTOM w0.083: 106.94,66.96 106.94,66.95 106.9,66.91 106.9,66.35 106.1,65.55 106.1,64.79 106.04,64.74 106.04,64.58 CPU1.CD3
  BOTTOM w0.102: U7201.K5 27.3,59.92 27.3,59.18 27.53,58.95 27.53,58.39 v2(27.5,58.36) ; v2(111.42,71.31) 110.85,70.74 110.54,70.74 110.08,70.28 109.92,70.28 108.93,69.28 107.64,69.28 106.94,68.58 106.94,66.96
USB4_USB20_P: length 143.1
  L8 w0.089: v2(27.05,58.86) 27.05,58.61 26.96,58.52 26.48,58.52 26.33,58.67 26.33,59.39 26.56,59.62 26.89,59.62 27.52,60.25 27.52,61.52 27.09,61.95 27.09,65.13 24.1,68.12 24.1,68.72 25.99,70.62 27.18,70.62 27.55,70.98 27.55,71.27 28.8,72.52 35.01,72.52 37.27,74.78 39.78,74.78 41.66,76.65 53.51,76.65 53.76,76.4 58.66,76.4 59.1,76.84 59.1,78.73 59.94,79.57 63.08,79.57 64.12,80.61 65.01,80.61 65.48,81.07 65.48,84.77 68.57,87.86 76.03,87.86 76.2,88.04 110.2,88.04 111.61,86.63 111.61,81.85 109.42,79.67 109.42,74.11 111.23,72.3 111.23,72.08 111.14,71.99 110.33,71.99 110.19,71.86 110.19,71.66 110.35,71.51 110.76,71.51 v2(110.81,71.56)
  BOTTOM w0.083: CPU1.CD4 106.02,64.13 105.75,64.4 105.75,64.7 105.91,64.87 105.91,65.62 106.72,66.43 106.72,66.94 106.71,66.95 106.71,66.96
  BOTTOM w0.102: v2(110.81,71.56) 110.99,71.39 110.99,71.2 110.76,70.97 110.45,70.97 109.99,70.51 109.83,70.51 108.84,69.51 107.55,69.51 106.71,68.67 106.71,66.96 ; U7201.L5 27.08,58.88 v2(27.05,58.86)
USB4_USB30_RX_C_N: length 1.8
  TOP w0.102: C7106.2 19.59,31.65 19.86,31.92 19.86,32.47 19.77,32.56 U7101.4
USB4_USB30_RX_C_P: length 1.8
  TOP w0.102: C7105.2 20.35,31.65 20.09,31.92 20.09,32.47 20.17,32.56 U7101.5
USB4_USB30_RX_N: length 123.4
  TOP w0.102: v2(19.53,29.66) 19.53,29.68 19.79,29.95 19.79,30.24 C7106.1
  L8 w0.089: v2(103.5,62.49) 103.25,62.73 103.06,62.73 101.89,63.9 95.64,63.9 95.05,64.48 86.76,64.48 86.18,63.9 81.06,63.9 80.24,63.08 77.6,63.08 75.97,64.72 75.97,66.12 73.09,69 71.45,69 69.11,66.67 65.56,66.67 61.26,62.37 53.75,62.37 53.33,62.79 52.53,62.79 48.81,66.51 41.12,66.51 38.98,64.37 38.98,63.18 32.95,57.15 31.71,57.15 30.98,56.41 30.98,48.23 26.28,43.53 26.28,43.48 24.49,41.69 24.49,36.12 22.7,34.32 22.7,28.74 22.31,28.36 20.2,28.36 19.88,28.68 19.88,29.13 19.76,29.24 19.76,29.43 v2(19.53,29.66)
  BOTTOM w0.102: CPU1.BW6 103.39,62.49 v2(103.5,62.49)
USB4_USB30_RX_P: length 123.4
  TOP w0.102: v2(20.32,29.66) 20.02,29.96 20.02,30.11 C7105.1
  L8 w0.089: v2(20.32,29.66) 20.05,29.66 19.96,29.57 19.96,29.32 20.07,29.21 20.07,28.76 20.28,28.55 22.23,28.55 22.5,28.82 22.5,34.4 24.3,36.2 24.3,41.77 26.09,43.56 26.09,43.61 30.79,48.31 30.79,56.49 31.63,57.34 32.87,57.34 38.79,63.26 38.79,64.45 41.04,66.7 48.89,66.7 52.61,62.98 53.41,62.98 53.83,62.56 61.18,62.56 65.48,66.86 69.03,66.86 71.37,69.19 73.17,69.19 76.16,66.2 76.16,64.8 77.68,63.27 80.16,63.27 80.98,64.1 86.1,64.1 86.68,64.67 95.13,64.67 95.72,64.09 101.97,64.09 103.13,62.92 103.27,62.92 v2(103.5,63.15)
  BOTTOM w0.102: v2(103.5,63.15) 103.41,63.15 CPU1.BW5
USB4_USB30_TX_C_N: length 1.9
  TOP w0.102: C7104.2 21.33,31.57 21.32,31.58 21.32,31.91 21.06,32.17 21.06,32.47 20.97,32.56 U7101.7
USB4_USB30_TX_C_P: length 2
  TOP w0.102: C7103.2 21.55,31.68 21.55,32 21.29,32.27 21.29,32.47 21.37,32.56 U7101.8
USB4_USB30_TX_N: length 155.4
  TOP w0.102: v2(21.05,29.66) 21.33,29.94 21.33,30.22 C7104.1
  L8 w0.089: v2(102.83,69.2) 102.47,69.2 102.43,69.16 102.12,69.16 101.92,68.96 101.92,67.69 100.15,65.92 98.34,65.92 96.19,68.07 96.19,69.3 96.07,69.42 96.07,70.68 94.6,72.15 88.73,72.15 88.2,71.61 88.2,68.94 87.05,67.79 85.9,67.79 84.92,66.81 78.96,66.81 75.16,70.62 70.78,70.62 68.45,68.28 64.68,68.28 60.81,64.42 55.78,64.42 51.2,69 40.41,69 37.95,66.55 34.43,66.55 33,65.11 32.47,65.11 31.21,63.85 31.21,63.84 31.21,60.34 30.95,60.08 30.74,60.08 29.58,60.08 27.93,58.42 27.93,58.18 27.68,57.93 19.04,57.93 17.7,56.59 17.7,55.35 18.62,54.44 18.62,51.98 17.94,51.31 16.28,51.31 15.67,50.71 15.67,49.16 15.24,48.73 15.24,48.61 15.24,46.18 14.21,45.15 12.99,45.15 10.57,42.73 10.57,42.19 11.61,41.15 13.69,41.15 14.24,40.6 15.25,40.6 16.28,39.57 16.28,32.94 18.24,30.98 21.09,30.98 21.36,30.71 21.36,29.97 v2(21.05,29.66)
  BOTTOM w0.102: v2(102.83,69.2) 103.56,69.2 103.81,68.95 103.81,65.4 103.48,65.07 103.21,65.07 CPU1.BW2
USB4_USB30_TX_P: length 155.5
  TOP w0.102: v2(21.84,29.66) 21.56,29.94 21.56,30.12 C7103.1
  L8 w0.089: v2(102.83,68.33) 102.56,68.33 102.47,68.42 102.47,68.88 102.38,68.97 102.2,68.97 102.11,68.88 102.11,67.61 100.23,65.73 98.26,65.73 96,67.99 96,69.2 95.88,69.33 95.88,70.6 94.52,71.96 88.81,71.96 88.39,71.54 88.39,68.86 87.13,67.6 85.98,67.6 85,66.62 78.88,66.62 75.08,70.42 70.86,70.42 68.52,68.09 64.75,68.09 60.89,64.23 55.7,64.23 51.12,68.81 40.48,68.81 38.03,66.36 34.51,66.36 33.08,64.92 32.55,64.92 31.4,63.77 31.4,63.76 31.4,63.56 31.4,60.26 31.03,59.89 30.82,59.89 29.66,59.89 28.12,58.34 28.12,58.1 27.76,57.74 19.12,57.74 17.89,56.51 17.89,55.43 18.81,54.52 18.81,51.91 18.02,51.12 16.36,51.12 15.86,50.63 15.86,49.08 15.43,48.65 15.43,48.53 15.43,46.1 14.29,44.96 13.07,44.96 10.76,42.65 10.76,42.27 11.69,41.34 13.77,41.34 14.32,40.79 15.33,40.79 16.47,39.64 16.47,33.02 18.32,31.17 21.17,31.17 21.55,30.79 21.55,29.95 v2(21.84,29.66)
  BOTTOM w0.102: v2(102.83,68.33) 103.03,68.33 103.14,68.44 103.14,68.87 103.24,68.97 103.46,68.97 103.58,68.85 103.58,65.49 103.38,65.3 103.24,65.3 CPU1.BW1
USB_ADT: length 220.2
  TOP w0.508: v2(158.04,20.06) 158.04,20.54 PD4407.A 157.56,21.02 PD4408.2
  L6 w0.508: v2(29.12,11.03) 29.23,11.15 29.23,15.4 28.94,15.69 28.94,24.59 27.7,25.83 27.7,26.86 27.72,26.88 27.72,33.88 28.22,34.38 28.22,36.8 27.81,37.2 27.81,39.12 27.67,39.26 27.67,39.38 26.86,40.19 26.86,47.97 28.54,49.64 28.54,49.94 28.56,49.97 28.56,52.37 29.27,53.08 29.27,55.04 28.85,55.45 28.5,55.45 25.32,58.63 25.32,59.15 24.38,60.09 24.38,64.22 24.62,64.46 24.62,67.08 24.05,67.65 24.05,69.38 24.88,70.21 24.88,72.78 v4(25.51,73.41) ; v2(158.04,20.06) 159.52,18.59 159.52,11.34 158.99,10.8 158.99,8.78 154.59,4.38 150.02,4.38 149.33,5.07 132.21,5.07 131.6,4.46 124.89,4.46 124.06,3.64 122.51,3.64 121.21,4.94 121.21,5 120.83,5.37 116.11,5.37 115.42,6.06 98.76,6.06 95.41,9.41 90.78,9.41 90.29,8.91 84.44,8.91 84,8.48 65.9,8.48 64.32,10.06 60.84,10.06 58.95,8.17 37.13,8.17 v2(35.76,9.54)
  L8 w0.508: v2(29.12,11.03) 33.28,11.03 34.53,9.78 35.52,9.78 v2(35.76,9.54)
  vias: v1(25.9,73.95)
USB_EN#: length 181.4
  TOP w0.102: R2434.2 23.52,30.02 v2(23.33,29.83) 22.96,29.46 v1(22.96,29.36)
  L3 w0.102: v2(42.24,14.19) 42.86,13.57 53.39,13.57 54.15,14.33 70.2,14.33 70.5,14.04 88.75,14.04 89,13.79 91.39,13.79 92.76,12.41 104.38,12.41 109.17,7.62 110.35,7.62 113.2,4.77 113.2,3.51 v2(112.85,3.16) ; v2(180.02,7.23) 179.26,6.48 167.04,6.48 164.72,4.16 v2(164.21,4.16)
  L5 w0.102: v2(42.24,14.19) 41.94,13.88 39.15,13.88 37.27,15.76 37.13,15.76 33.02,19.87 33.02,21.57 28.78,25.82 28.51,25.82 27.8,26.52 27.8,28.74 26.91,29.63 24.2,29.63 24,29.83 v2(23.33,29.83)
  L8 w0.102: v2(112.85,3.16) 113.44,2.57 132.07,2.57 132.38,2.88 137.22,2.88 138.16,3.82 148.72,3.82 149.12,3.43 149.85,3.43 150.28,3 155,3 156.12,4.11 157.09,4.11 157.42,4.45 158.28,4.45 158.58,4.16 v2(164.21,4.16)
  BOTTOM w0.102: v2(23.33,29.83) 23.33,29.48 23.22,29.36 23.22,28.46 23.37,28.31 U2401.13 ; v2(180.02,7.23) 179.73,7.23 179.58,7.39 179.58,8.19 179.85,8.47 IO1.16
USB_OC0#: length 131.2
  TOP w0.102: RN1601.5 113.17,62.06 v1(112.24,62.06) 110.44,62.06 v2(110.02,62.48)
  L3 w0.102: v2(180.3,7.8) 179.67,7.8 179.41,7.55 179.41,6.92 179.17,6.68 166.96,6.68 166.44,6.16 156.95,6.16 154.65,3.87 151.34,3.87 150.43,4.77 147.89,4.77 147.76,4.91 146.34,4.91 145.21,6.04 140.19,6.04 139.43,6.8 126.55,6.8 124.07,9.28 124.07,14.36 124.37,14.67 124.37,16.02 124.36,16.03 124.36,18.11 123.46,19.02 123.46,19.98 123.37,20.06 123.37,24.56 124.63,25.82 124.63,27.16 125.18,27.72 125.18,30.38 126.15,31.34 126.15,36.6 126.66,37.11 126.66,40.8 125.7,41.75 125.7,48.03 125.13,48.6 125.13,50.25 123.53,51.84 123.53,54.19 120.36,57.36 114.37,57.36 112.69,59.05 112.69,60.24 110.45,62.48 v2(110.02,62.48)
  BOTTOM w0.102: IO1.17 180.35,7.85 v2(180.3,7.8) ; CPU1.CK6 109.85,62.48 v2(110.02,62.48)
USB_OC1#: length 5.7
  TOP w0.102: RN1601.6 111.53,61.46 111.14,61.85 110.36,61.85 110.32,61.89 v1(109.61,61.89) 109.61,62.28 109.56,62.33 109.56,62.58 v2(109.08,63.05)
  BOTTOM w0.102: CPU1.CK5 109.31,62.83 v2(109.08,63.05)
USB_OC2#: length 4.9
  TOP w0.102: v2(109.15,61.19) 109.36,60.98 110.35,60.98 v1(110.7,61.34) 111.06,60.98 112.74,60.98 112.76,60.96 RN1601.7
  BOTTOM w0.102: CPU1.CK8 109.34,61.09 109.28,61.09 109.21,61.16 109.19,61.16 109.16,61.19 v2(109.15,61.19)
USB_OC3#: length 101.6
  TOP w0.102: RN1601.8 v1(112.15,60.37) 110.72,60.37 110.69,60.41 110.65,60.41 110.34,60.71 109.33,60.71 v2(109.09,60.47)
  L5 w0.102: v2(34.38,64.88) 35.06,64.88 36.98,66.8 38.63,66.8 40.58,68.75 40.58,72.43 43.09,74.94 48.17,74.94 49.34,73.77 50.34,73.77 50.71,74.14 50.71,74.21 51.13,74.63 52.95,74.63 53.85,73.73 59.71,73.73 66.54,66.9 70.96,66.9 72.64,65.22 85.73,65.22 86.24,65.73 88.47,65.73 89.4,66.66 90.41,66.66 91.37,65.71 91.53,65.71 92.22,65.01 96.62,65.01 97.63,64 106.33,64 107.73,62.59 107.73,61.68 107.99,61.42 108.14,61.42 v2(109.09,60.47)
  BOTTOM w0.089: 29.52,65.54 29.03,65.04 29.01,65.04 28.8,64.83 28.8,64.37 U7201.B2
  BOTTOM w0.102: CPU1.CK9 109.31,60.47 v2(109.09,60.47) ; 29.52,65.54 30.08,65.54 30.29,65.32 30.87,65.32 31.68,64.51 34.01,64.51 v2(34.38,64.88)
USB_PWR_SHR_EN_L#: length 2.3
  BOTTOM w0.102: U2401.118 16.09,22.27 R2435.2 15.95,23.33 v1(15.86,23.43)
USBCOMP: length 0.6
  BOTTOM w0.254: v2(105.4,63.06) 105.64,62.83 CPU1.CC5
V_SM_VREF_CNTA: length 12.1
  TOP w0.508: C1250.1 R1224.2 64.07,36.6 v2(64.07,36.88)
  BOTTOM w0.203: 66.12,41.37 68.07,41.37 CPU1.D37 69.72,43.02 CPU1.D35
  BOTTOM w0.508: 66.12,41.37 63.84,39.09 63.84,37.11 v2(64.07,36.88)
V_SM_VREF_CNTB: length 10.6
  TOP w0.508: R1323.2 66.36,35.84 C1339.1 66.23,36.62 66.23,36.76 v2(65.87,37.12)
  BOTTOM w0.152: CPU1.E36 69.98,43.11 69.98,42.91 69.91,42.84 69.91,42.76 67.95,40.8 67.08,40.8
  BOTTOM w0.508: v2(65.87,37.12) 65.87,38.45 65.95,38.45 65.95,39.77 66.98,40.8 67.08,40.8
VCORE_OVP_+: length 65.4
  TOP w0.203: v2(154.47,26.96) 154.56,27.05 155.14,27.05 PR44A1.1 155.19,27 155.19,26.34 PC44A9.1 ; v1(136.15,55.43) 136.15,56.03 v3(136.18,56.05)
  L5 w0.203: v3(136.18,56.05) 135.56,56.05 134.4,54.89 134.4,51.39 133.3,50.29 133.3,38.48 130.02,35.19 129.13,35.19 128.62,34.69 128.62,31.57 130.36,29.83 131.92,29.83 132.2,29.55 132.2,29.39 132.82,28.77 133.72,28.77 134.14,28.35 134.14,27.78 134.42,27.49 134.82,27.49 135.11,27.78 135.11,27.8 135.39,28.09 138.07,28.09 138.2,28.22 138.6,28.22 140.26,26.56 140.26,25.88 140.54,25.6 141.15,25.6 141.19,25.56 144.27,25.56 144.77,26.07 146.79,26.07 147.31,26.58 154.09,26.58 v2(154.47,26.96)
  BOTTOM w0.203: v3(136.18,56.05) 135.6,56.05 PR44A6.2 ; v2(154.47,26.96) 154.47,26.99 154.69,27.21 155.86,27.21 PD44A1.K 154.85,28.41 PU44A1.3
VCORE_OVP_-: length 4.8
  TOP w0.203: v1(151.22,25.9) 151.22,25.92 151.12,26.01 151.12,26.66 PR44A2.2 151.58,26.43 PR44A3.1 152.05,27.18 PC44A1.1 152.04,27.25 152.04,28.01 v3(151.8,28.26)
  BOTTOM w0.203: v3(151.8,28.26) 152.48,28.26 152.63,28.41 PU44A1.1
VCORE_OVP_OUT: length 13.4
  TOP w0.203: 158.98,27.92 158.94,27.92 158.7,27.68 158.69,27.68 158.55,27.55 158.55,27.54 158.51,27.49 158.51,26.85 v3(158.2,26.55) ; 158.98,27.92 PQ44A1.2 ; 158.98,27.92 158.74,28.17 158.69,28.17 158.55,28.3 158.55,28.85 158.81,29.11 158.94,29.11 159.34,29.51 161.12,29.51 161.25,29.37 162.18,29.37 PR44A4.2 162,30.15 v1(162,30.51)
  BOTTOM w0.203: PU44A1.4 155.35,25.95 156.2,26.8 157.65,26.8 PD44A1.A 158.2,27.26 v3(158.2,26.55)
VGA_B7: length 6.1
  BOTTOM w0.102: R7701.2 160.87,47.41 v1(160.87,48.12) 161.02,48.27 161.02,49.54 161.03,49.55 161.03,51.02 159.87,52.18 159.87,52.66 GPU1.B7
VGA_CORE_DISCHG: length 2.2
  BOTTOM w0.102: Q8605.D 149.24,78.93 v1(149.24,77.9) 149.24,77.01 R8624.2
VGA_CORE_PSI: length 30.5
  TOP w0.203: PR8522.1 149.92,29.42 v1(149.96,29.38) 149.96,28.74 v2(149.93,28.71)
  L3 w0.203: v2(159.16,48.46) 158.97,48.27 158.97,45.85 160.06,44.76 160.59,44.22 160.59,39.11 158.41,36.92 158.41,34.13 154.15,29.87 152.54,29.87 152.53,29.86 152.13,29.86 152.11,29.87 151.8,29.87 151.78,29.85 151.4,29.85 151.38,29.87 151.1,29.87 v2(149.93,28.71)
  BOTTOM w0.203: GPU1.A4 158.81,50.2 158.81,49.97 159.04,49.74 159.04,48.54 159.14,48.44 159.14,48.46 v2(159.16,48.46)
VGA_CORE_VID: length 37.3
  TOP w0.203: PR8510.1 150.19,26.85 v2(149.9,27.14)
  L3 w0.203: v2(149.9,27.14) 151.34,27.14 153.56,29.36 154.1,29.36 154.12,29.38 154.31,29.38 158.27,33.35 160.09,33.35 161.84,35.1 161.84,36.07 161.05,36.85 161.05,44.41 160.25,45.22 159.42,46.04 v2(159.42,47.71)
  BOTTOM w0.089: 158.33,50.11 158.33,50.58 158.44,50.69 158.44,51.1 158.37,51.17 158.37,51.69 158.74,52.06 158.74,52.66 GPU1.C6
  BOTTOM w0.203: v2(149.9,27.14) 150.82,26.22 v1(151.35,26.22) ; 158.33,50.11 158.51,49.94 158.51,49.93 158.51,49.59 158.51,49.59 158.51,48.47 159.22,47.76 159.37,47.76 v2(159.42,47.71)
VGACORE_GND_SENSE_1: length 52.5
  TOP w0.203: v2(144.8,23.82) 144.8,24.07 145.04,24.3 145.04,24.31 v1(145.05,24.32)
  L3 w0.203: v2(144.8,23.82) 144.8,23.4 145,23.2 145.58,23.2 147.1,24.72 148.43,24.72 150.03,26.32 151.58,26.32 153.63,28.38 155.25,28.38 157.09,30.22 157.09,30.65 157.72,31.29 157.77,31.29 158.11,31.63 159.87,31.63 160.82,30.68 161.99,30.68 162.9,31.59 162.9,37.21 161.76,38.35 161.76,44.71 160.54,45.93 160.13,46.33 160.13,48.19 158.87,49.45 155.11,49.45 153.86,50.7 153.86,50.71 153.57,50.88 153.44,50.95 153.24,50.9 v2(152.84,51.14)
  BOTTOM w0.203: v2(144.8,23.82) 144.8,24.8 PR8520.1 ; v2(152.84,51.14) 153.68,51.14 GPU1.F1
VGACORE_VDD_SENSE_1: length 55
  L3 w0.203: v2(153.16,51.68) 153.56,51.44 153.61,51.24 154.03,50.99 154.19,50.89 154.19,50.84 155.25,49.78 159.01,49.78 160.46,48.33 160.46,46.47 160.68,46.26 162.09,44.85 162.09,38.49 163.23,37.34 163.23,31.46 162.12,30.35 160.68,30.35 159.74,31.3 158.24,31.3 157.91,30.96 157.86,30.96 157.42,30.52 157.42,30.08 155.39,28.05 153.77,28.05 151.71,25.99 150.17,25.99 148.56,24.39 147.24,24.39 145.72,22.87 144.87,22.87 144.32,23.41 144.32,23.56 v2(144.06,23.82)
  BOTTOM w0.203: PR8517.1 144.06,24.81 v2(144.06,23.82) 144.12,23.82 144.6,23.34 144.66,23.34 v1(144.88,23.13) ; v2(153.16,51.68) 153.2,51.72 153.72,51.72 154.1,52.1 GPU1.F2
VIDEO_CLK_XTAL_SS: length 11.4
  BOTTOM w0.102: GPU1.A10 164.66,51.39 164.66,49.31 162.75,47.4 162.75,46.67 v1(161.95,45.88) 161.95,44.9 R7901.1
VIO_18: length 2.3
  BOTTOM w0.127: R3321.1 5.2,15.91 5.56,15.55 5.56,14.85 6.01,14.4 U3301.14
VR_CAP: length 2.7
  TOP w0.254: v1(24.15,25.83) 24.57,26.25 C2418.2 24.64,26.67 v2(25.29,26.67)
  BOTTOM w0.203: U2401.18 25.37,26.75 v2(25.29,26.67)
VRALERT#: length 5.8
  BOTTOM w0.076: CPU1.CC36 105.9,43.49 106.06,43.21 106.06,43.21 106.16,43.02 106.16,42.69 106.12,42.65
  BOTTOM w0.102: 106.12,42.65 106.11,42.63 106.11,40.44 106.14,40.41 106.14,38.27 TP1708.1
VRAM_ID1: length 19.9
  TOP w0.102: v2(106.96,48.8) 107.23,48.8 v1(107.48,48.55)
  L5 w0.102: v2(117.41,48.03) 117.41,51.11 117.4,51.12 117.4,53.36 v2(117.51,53.47)
  L6 w0.102: v2(117.41,48.03) 117.15,48.29 115.81,48.29 115.59,48.51 115.04,48.51 114.11,49.44 108.5,49.44 108.37,49.31 108.01,49.31 107.98,49.34 107.49,49.34 v2(106.96,48.8)
  BOTTOM w0.102: v2(106.96,48.8) 106.96,48.83 106.65,49.14 CPU1.CE27 ; v2(117.51,53.47) 117.55,53.51 118.45,53.51 ; R2035.2 118.5,54.38 118.5,53.57 118.45,53.52 118.45,53.51 ; 118.45,53.51 R2034.1
VRAM_ID2: length 7.2
  BOTTOM w0.076: 113.91,52.15 112.68,52.15 112.47,51.94 112.05,51.94 arc(111.98,51.93) 111.92,51.89 111.72,51.69 CPU1.CN23
  BOTTOM w0.102: R2037.1 117.18,52.7 R2038.2 116.83,53.03 116.83,53.03 116.52,52.73 116.36,52.56 115.31,52.56 v1(114.94,52.93) 114.57,52.56 114.32,52.56 113.91,52.15
VSYS_UVP_+: length 5.5
  TOP w0.203: PR44B7.2 151.15,29.78 151.59,30.22 v3(151.59,30.31) v1(152.34,29.56) PR44B1.1 153.14,28.75 153.83,28.75 PC44B3.1
  BOTTOM w0.203: PU44B1.3 152.34,29.55 v3(151.59,30.31)
VSYS_UVP_-: length 4.2
  TOP w0.203: PR44B2.2 154.67,29.55 155.45,29.55 155.53,29.47 v3(155.54,29.47) ; PR44B2.2 154.64,28.93 PC44B1.1 154.84,28.74 155.51,28.74 PR44B3.1 ; PR44B2.2 153.86,29.53 v1(153.76,29.64)
  BOTTOM w0.203: v3(155.54,29.47) 155.53,29.47 155.45,29.55 PU44B1.1
VSYS_UVP_OUT: length 70.7
  TOP w0.203: PQ44B1.3 147.55,3.45 148.05,3.94 149.92,3.94 151.19,2.67 159.45,2.67 159.47,2.7 159.9,2.7 160.34,3.13 160.34,3.87 PD44B1.A 160.42,4.81 163.64,4.81 166.57,7.75 166.57,10.52 167.87,11.83 170.03,11.83 v2(171.08,12.88) ; PQ44A1.5 161.76,27.92 v3(161.96,28.12) 161.96,27.71 v1(162.07,27.6)
  L5 w0.203: v2(152.07,32.02) 157.21,32.02 157.5,31.72 160.27,31.72 161.96,30.03 v3(161.96,28.12)
  L8 w0.203: v3(161.96,28.12) 162.06,28.22 162.84,28.22 162.84,28.21 162.87,28.21 163.35,27.74 163.74,27.74 165.33,26.15 166.06,26.15 166.27,25.94 166.27,25.94 166.59,25.61 166.59,24.89 168.48,23 168.48,22.96 169.81,21.63 170.15,21.63 170.83,20.95 170.83,18.83 172.89,16.77 172.89,14.08 171.69,12.88 v2(171.08,12.88)
  BOTTOM w0.203: PR44B4.2 151.83,31.78 v2(152.07,32.02) PU44B1.4
VTT_CNTL: length 31.4
  L5 w0.102: v2(27.18,38.52) 27.63,38.07 27.63,37.61 28.24,36.99 30.38,36.99 30.87,36.5 43.64,36.5 44.58,37.44 44.58,38.06 47.35,40.82 47.92,40.82 v2(49.05,41.96)
  BOTTOM w0.102: v2(49.05,41.96) 49.79,41.22 R507.2 50.21,39.84 50.47,40.1 Q502.D ; PR5107.1 27.24,39.64 v1(27.24,39.43) 27.24,38.58 v2(27.18,38.52)
WHITE_LED_BAT: length 10
  BOTTOM w0.254: 5.26,69.95 5.51,69.69 7.34,69.69 EC6401.1 8.06,69.93 v1(8.7,69.93) ; 5.26,69.95 6.21,70.89 6.21,70.91 6.57,71.27 8.11,71.27 8.17,71.33 Q6401.C ; 5.26,69.95 5.08,69.77 4.11,69.77 R6402.1
WIFI_RF_EN: length 94.1
  TOP w0.102: AFTP6110.1 170.32,16.29 v2(169.74,16.87) 169.37,16.5 R6106.1 ; v1(135.29,47.89) 135.29,47.98 v2(134.93,48.33)
  L6 w0.102: v2(134.93,48.33) 133.88,48.33 133.4,47.86 127.11,47.86 126,48.96 125.65,48.96 125.02,48.33 123.4,48.33 122.75,47.68 119.3,47.68 117.87,49.1 116.43,49.1 115.79,49.75 115.79,50.01 115.33,50.47 111.46,50.47 110.73,51.19 108.69,51.19 108.64,51.25 108.04,51.25 v2(107.56,50.76)
  L8 w0.102: v2(169.74,16.87) 169.24,17.37 169.24,17.9 168.97,18.17 168.9,18.17 168.08,18.98 168.08,21.37 167.61,21.84 167.61,22.65 163.38,26.88 162.62,26.88 159.18,30.32 159.18,30.4 158.94,30.63 158.87,30.63 157.29,32.22 157.29,36.73 159.63,39.07 159.63,41.86 153.84,47.64 153.51,47.64 153.22,47.93 152.41,47.93 152.35,47.99 151.91,47.99 151.88,47.96 149.27,47.96 148.95,47.64 146.35,47.64 146.03,47.96 143.78,47.96 143.47,47.64 141.07,47.64 140.59,47.16 137.67,47.16 137.4,47.43 135.84,47.43 v2(134.93,48.33)
  BOTTOM w0.102: CPU1.CG25 107.91,50.41 v2(107.56,50.76)
WIFI_RF_EN_R: length 4.6
  TOP w0.102: v2(168.81,17.1) 168.54,17.37 v1(167.97,17.37) 167.71,17.37 167.54,17.2 R6106.2 166.79,16.5 R6113.2
  BOTTOM w0.102: v2(168.81,17.1) 168.81,17.1 168.79,17.12 168.57,17.12 168.14,17.55 WLAN1.56
WLAN_CLK_CPU_N: length 108.1
  L8 w0.089: v2(155.95,25.02) 156.11,25.02 156.2,25.11 156.2,25.54 156.07,25.67 155.31,25.67 155.06,25.41 152.2,25.41 151.58,24.79 138.39,24.79 136.98,26.21 136.98,26.66 136.98,27.14 135.41,28.71 134.86,29.26 134.86,30.01 132.43,32.44 132.43,37.01 128.83,40.61 128.83,46.92 127.94,47.82 127.46,47.82 121.39,53.88 121.39,54.34 121.39,54.56 120.92,55.03 120.92,56.78 117.48,60.22 116.65,60.22 116.29,60.58 116.29,60.73 115.06,61.96 113.96,61.96 111.37,64.54 105.31,64.54 104.55,65.31 97.79,65.31 95.42,67.67 95.42,68.65 94.57,69.5 94.14,69.5 94.08,69.44 93.96,69.44 93.88,69.36 93.88,68.63 93.78,68.53 93.51,68.53 93.35,68.69 v2(93.35,69)
  BOTTOM w0.102: CPU1.BC1 93.25,65.97 92.48,66.74 92.48,68.61 93.04,69.17 93.18,69.17 v2(93.35,69) ; WLAN1.49 159.12,19.3 158.85,19.57 158.56,19.57 158.22,19.23 157.04,19.23 156.54,19.73 156.54,21.29 154.91,22.91 154.91,23.52 156.11,24.72 156.11,24.86 v2(155.95,25.02)
WLAN_CLK_CPU_P: length 108.1
  L8 w0.089: v2(156.74,25.02) 156.74,25.02 156.39,25.37 156.39,25.61 156.15,25.86 155.23,25.86 154.98,25.6 152.12,25.6 151.5,24.99 138.47,24.99 137.17,26.29 137.17,26.58 137.17,27.22 135.49,28.9 135.05,29.34 135.05,30.09 132.62,32.52 132.62,37.09 129.03,40.69 129.03,47 128.02,48.01 127.54,48.01 121.58,53.96 121.58,54.26 121.58,54.64 121.11,55.11 121.11,56.86 118.79,59.19 117.56,60.41 116.73,60.41 116.48,60.66 116.48,60.81 115.14,62.15 114.04,62.15 111.45,64.73 105.39,64.73 104.63,65.5 97.87,65.5 95.62,67.75 95.62,68.72 94.65,69.69 94.06,69.69 94,69.63 v2(93.38,69.63)
  BOTTOM w0.102: WLAN1.47 159.91,19.79 158.46,19.79 158.13,19.46 157.14,19.46 156.77,19.83 156.77,21.38 155.14,23 155.14,23.42 v2(156.74,25.02) ; CPU1.BC2 93.06,64.93 92.86,65.19 92.86,65.36 92.98,65.49 92.98,65.68 93.02,65.72 93.02,65.87 92.25,66.64 92.25,68.71 93.18,69.63 v2(93.38,69.63)
WLAN_CLKREQ_CPU_N: length 90.1
  TOP w0.102: v2(107,46.23) 106.9,46.13 106.77,46 106.77,45.26 108.74,43.29 110.02,43.29 110.81,42.5 110.81,41.26 113.46,38.61 114.55,38.61 115.61,37.55 116.88,37.55 117.12,37.31 117.12,37.29 117.86,36.55 117.91,36.55 117.99,36.46 118.04,36.45 118.28,36.28 119.75,34.81 v2(120.05,34.81) 121.09,34.81 121.71,35.42 RN1813.8 ; AFTP6109.1 159.08,17.95 v2(158.73,18.3)
  L5 w0.102: v2(124.8,17.44) 124.39,17.85 124.39,18.27 125.84,19.73 125.84,22.42 129.04,25.61 136.96,25.61 138.09,24.48 138.67,24.48 140.01,23.14 143.6,23.14 143.6,23.14 145.98,23.14 147.26,24.42 148.43,24.42 149.22,25.21 152.19,25.21 154.29,23.11 155.05,23.11 155.57,22.59 156.41,22.59 158.73,20.28 v2(158.73,18.3)
  L8 w0.102: v2(124.8,17.44) 125.15,17.44 125.25,17.54 125.25,18.75 122.74,21.27 122.74,21.84 120.12,24.45 120.12,27.11 120.03,27.2 120.03,30.09 120.05,30.11 v2(120.05,34.81)
  BOTTOM w0.102: CPU1.CE32 106.66,45.89 v2(107,46.23) ; WLAN1.53 v2(158.73,18.3)
WLAN_COEX1: length 3.4
  TOP w0.102: v2(168.62,19.55) 168.96,19.21 R6107.2 169.82,18.95 169.94,18.83 v1(169.94,18.32)
  BOTTOM w0.102: WLAN1.48 v2(168.62,19.55)
WLAN_COEX2: length 3.3
  TOP w0.102: v1(168.27,20.01) 168.32,20.05 v2(169.17,20.05) 169.24,19.99 R6108.2
  BOTTOM w0.102: WLAN1.46 v2(169.17,20.05)
WLAN_COEX3: length 2.9
  TOP w0.102: v2(168.64,20.55) 168.64,20.85 v1(168.96,21.17) 169.16,21.37 R6109.2
  BOTTOM w0.102: WLAN1.44 v2(168.64,20.55)
WLAN_PCIE_RX_N: length 97.4
  L8 w0.089: v2(156.2,23.07) 156.2,23.1 156.51,23.4 156.51,23.63 156.33,23.8 155.33,23.8 154.63,23.1 138.25,23.1 134.96,26.4 132.94,26.4 132.67,26.67 129.73,26.67 129.53,26.87 129.53,28.54 128.55,29.52 128.55,30.71 128.34,30.92 128.34,35.67 127.06,36.94 127.06,38.38 125.27,40.18 124.94,40.51 124.94,40.74 124.94,44.3 124.58,44.66 123.61,44.66 120.19,48.08 120.19,50.19 118.18,52.21 118.18,53.73 116.67,55.24 116.67,57.75 113.64,60.78 111.66,60.78 111.15,60.26 111.15,57.9 110.71,57.46 107.26,57.46 106.5,58.22 105.43,58.22 103.09,60.56 103.09,61.95 101.51,63.53 100.5,63.53 99.65,62.67 99.18,62.67 v2(98.94,62.43)
  BOTTOM w0.102: CPU1.BN6 99.15,62.41 98.95,62.41 v2(98.94,62.43) ; WLAN1.43 159.12,20.8 158.96,20.96 158.49,20.96 157.32,22.13 156.69,22.13 156.46,22.37 156.46,22.79 156.18,23.07 v2(156.2,23.07)
WLAN_PCIE_RX_P: length 97.3
  L8 w0.089: v2(98.92,63.1) 98.94,63.1 99.18,62.86 99.57,62.86 100.42,63.72 101.58,63.72 103.28,62.03 103.28,60.64 105.51,58.41 106.58,58.41 107.34,57.65 110.63,57.65 110.96,57.98 110.96,60.34 111.58,60.97 113.72,60.97 116.86,57.83 116.86,55.32 118.37,53.81 118.37,52.29 120.38,50.27 120.38,48.16 123.69,44.85 124.66,44.85 125.13,44.38 125.13,40.66 125.13,40.59 125.35,40.37 127.25,38.46 127.25,37.02 128.53,35.75 128.53,31 128.74,30.79 128.74,29.6 129.72,28.62 129.72,26.95 129.81,26.86 132.75,26.86 133.02,26.59 135.04,26.59 138.33,23.3 154.55,23.3 155.25,24 156.41,24 156.7,23.71 156.7,23.34 v2(156.97,23.07)
  BOTTOM w0.102: WLAN1.41 159.06,21.3 158.96,21.19 158.58,21.19 157.41,22.36 156.79,22.36 156.68,22.46 156.68,22.79 v2(156.97,23.07) ; CPU1.BN5 99.14,63.07 98.95,63.07 v2(98.92,63.1)
WLAN_PCIE_TX_CON_N: length 3.3
  BOTTOM w0.102: WLAN1.37 159.12,22.3 158.98,22.44 158.77,22.44 157.72,23.49 157.72,23.7 C6107.1
WLAN_PCIE_TX_CON_P: length 2.9
  BOTTOM w0.102: C6108.1 157.95,23.73 157.95,23.58 158.87,22.67 159.01,22.67 159.14,22.8 WLAN1.35
WLAN_PCIE_TX_N: length 97.4
  L8 w0.089: v2(157.41,25.77) 157.71,26.07 157.71,26.18 157.16,26.73 155.41,26.73 154.9,26.21 153.96,26.21 153.72,26.45 152.46,26.45 151.35,25.34 138.62,25.34 137.53,26.43 137.53,28.11 132.98,32.66 132.98,37.03 132.98,37.24 129.38,40.83 129.38,47.14 128.16,48.36 127.69,48.36 121.94,54.11 121.94,55.01 121.55,55.4 121.55,58.07 120,59.62 120,60.34 118.52,61.81 117.08,61.81 113.59,65.3 107.11,65.3 106.06,66.34 106.06,67.84 105.28,68.62 103.96,68.62 103.54,69.04 103.54,70.08 103.09,70.54 102.71,70.54 101.31,69.14 101.31,67.86 100.31,66.86 v2(99.65,66.86)
  BOTTOM w0.083: v2(99.65,66.86) 99.66,66.86 99.81,67.01 100.3,67.01 100.38,66.93 100.38,66.18 100.14,65.66 100.14,65.4 100.17,65.27 100.17,65.13 100.15,65.04 100.14,65.02 100.14,64.73 100.15,64.71 100.2,64.62 100.2,64.58 100.33,64.09 CPU1.BR4
  BOTTOM w0.102: C6107.2 157.69,25.15 157.69,25.48 v2(157.41,25.77)
WLAN_PCIE_TX_P: length 97.8
  L8 w0.089: v2(99.66,67.54) 99.89,67.54 99.98,67.46 99.98,67.14 100.07,67.05 100.23,67.05 101.12,67.94 101.12,69.22 102.63,70.73 103.16,70.73 103.73,70.16 103.73,69.12 104.04,68.81 105.36,68.81 106.25,67.92 106.25,66.42 107.19,65.49 113.67,65.49 117.16,62 118.6,62 120.19,60.42 120.19,59.7 121.74,58.15 121.74,55.48 122.13,55.08 122.13,54.19 127.77,48.55 128.24,48.55 129.57,47.22 129.57,40.91 133.17,37.32 133.17,37.22 133.17,37.22 133.17,36.95 133.17,36.95 133.17,32.74 137.72,28.19 137.72,26.51 138.7,25.53 151.27,25.53 152.38,26.64 153.8,26.64 154.04,26.4 154.82,26.4 155.33,26.92 157.24,26.92 157.9,26.26 157.9,26.07 v2(158.2,25.77)
  BOTTOM w0.083: CPU1.BR3 100.31,64.77 100.31,64.95 100.34,65.06 100.34,65.34 100.31,65.42 100.31,65.63 100.55,66.14 100.55,67 100.37,67.19 100.01,67.19 v2(99.66,67.54)
  BOTTOM w0.102: C6108.2 157.92,25.18 157.92,25.49 v2(158.2,25.77)
WSSD_DEVSLP: length 13.5
  BOTTOM w0.102: CPU1.CR8 114.18,61.12 114.99,61.93 115.95,61.93 116.3,62.27 119.61,62.27 119.65,62.24 v1(124.28,62.24) 125.23,62.24 R6605.1
WSSD_DEVSLP_R: length 107.8
  L5 w0.102: v2(196.84,5.95) 196.76,5.95 195.73,6.98 195.73,10.6 194.57,11.76 194.37,11.76 193.9,12.23 193.9,12.6 193.93,12.62 193.93,18.55 191.03,21.45 191.03,24.9 186.32,29.61 186.3,29.61 185.39,30.52 178.49,30.52 178.46,30.55 177.42,31.59 177.39,31.62 176.2,31.62 176.17,31.59 176.17,31.59 175.42,30.84 173.96,30.84 v2(173.57,31.23)
  L8 w0.102: v2(173.57,31.23) 172.63,32.17 171.38,32.17 166.95,36.6 166.95,38.24 164.11,41.08 164.11,44.11 159.34,48.88 158.46,48.88 155.06,52.28 151.41,52.28 150.52,53.17 147.9,53.17 147.1,52.37 141.88,52.37 141.16,53.09 139.76,53.09 137.76,55.09 137.76,55.32 136.98,56.1 136.97,56.1 136.3,56.77 136.3,58 134.19,60.11 v3(134.18,60.11)
  BOTTOM w0.102: R6605.2 126.89,62.08 127.29,61.68 129.48,61.68 129.79,62 131.7,62 v1(132.99,60.71) 133.58,60.11 v3(134.18,60.11) ; IO2.16 196.49,6.1 196.64,5.95 v2(196.84,5.95)
WWAM_CARD_PWR_OFF#: length 122.9
  TOP w0.102: v2(144.82,20.21) 144.07,20.21 v1(143.48,20.81) 143.25,21.04 141.21,21.04 140.11,22.14 134.69,22.14 134.61,22.06 130.57,22.06 130.57,22.07 130.29,22.07 130.1,22.26 129.98,22.26 v2(129.52,22.71) ; R6607.1 171.54,30.84 v2(171.54,31.73)
  L3 w0.102: v3(110.03,52.92) 110.03,53.05 109.64,53.44 107.46,53.44 107.03,53.01 107.03,52.64 107.4,52.26 107.4,52.04 108.19,51.26 108.85,51.26 108.91,51.21 109.65,51.21 109.68,51.18 111.43,51.18 113.68,48.93 113.68,46.54 112.98,45.84 112.98,45.3 113.82,44.46 114.6,44.46 114.82,44.24 114.82,41.31 117.58,38.55 117.62,38.55 119.72,36.45 119.72,36.1 119.38,35.76 119.38,31.51 118.24,30.37 118.24,28.9 v2(118.81,28.33)
  L5 w0.102: v2(144.82,20.21) 144.82,19.79 145.76,18.85 146.39,18.85 146.66,18.59 146.66,18.21 148.17,16.69 151.92,16.69 152.75,15.86 153.11,15.86 153.36,16.11 153.36,16.65 153.63,16.92 156.55,16.92 157.21,16.26 159.83,16.26 160.78,15.31 165.38,15.31 165.96,14.73 170.07,14.73 173.23,17.89 173.23,20.08 170.85,22.46 170.85,24.64 170.75,24.74 168.61,24.74 168.14,25.21 168.14,26.68 171.54,30.08 v2(171.54,31.73)
  L6 w0.102: v2(118.81,28.33) 120.1,27.03 120.1,24.96 120.51,24.55 124.82,24.55 125.64,23.73 125.64,23.73 126.66,22.71 129.09,22.71 v2(129.52,22.71)
  BOTTOM w0.102: v3(110.03,52.92) 110.32,52.63 110.68,52.63 111.06,52.25 CPU1.CN22
WWAM_CARD_PWR_OFF#_R: length 47.1
  TOP w0.102: v1(172.24,29.27) 172.24,29.64 172.66,30.06 172.66,30.34 R6607.2 173.49,30.46 v2(173.55,30.41)
  L5 w0.102: v2(196.79,3.91) 196.59,3.91 195.52,4.98 195.52,10.51 194.48,11.55 194.23,11.55 193.71,12.07 193.71,12.11 193.69,12.14 193.69,12.69 193.71,12.71 193.71,18.46 190.81,21.36 190.81,24.81 186.23,29.39 179.31,29.39 177.3,31.4 176.29,31.4 175.3,30.41 v2(173.55,30.41)
  BOTTOM w0.102: v2(196.79,3.91) 196.54,3.91 196.35,4.1 IO2.26
WWAN_BB_RST#: length 132
  TOP w0.102: v2(135.17,52.92) 135.18,52.92 v1(135.57,52.53)
  L6 w0.102: v2(108.04,54.97) 108.35,55.28 109.2,55.28 109.58,55.65 113.44,55.65 114.11,54.98 123.25,54.98 123.91,54.32 125.14,54.32 125.14,54.32 125.85,54.32 126,54.17 126.66,54.17 126.84,53.99 128.97,53.99 129.01,54.03 133.11,54.03 134.22,52.92 v2(135.17,52.92)
  L8 w0.102: v2(135.17,52.92) 135.48,52.61 136.13,52.61 136.5,52.24 140.81,52.24 142.3,50.75 143.58,50.75 144.27,51.43 147.67,51.43 148.27,52.02 150.21,52.02 151.71,50.53 155.75,50.53 157.54,48.74 157.54,48.39 163.24,42.69 163.24,39.94 164.09,39.09 164.09,37.37 164.1,37.37 164.1,34.24 163.31,33.45 163.31,32.17 165.1,30.38 166.41,30.38 168.23,28.55 168.23,27.92 168.9,27.26 168.9,26.37 169.18,26.09 169.85,26.09 169.93,26.18 170.53,26.18 170.86,25.85 171.26,23.85 171.26,22.38 171.39,21.7 176.29,16.8 176.29,15.44 176.04,15.19 176.04,10.41 176.25,10.21 176.25,9.76 176.5,9.51 176.95,9.51 177.89,8.57 177.89,7.57 178.07,7.4 178.17,7.4 179.16,6.41 188.21,6.41 189.24,7.44 190.03,7.44 190.72,8.13 194.15,8.13 195.77,6.51 195.77,5.55 v2(196.75,4.57)
  BOTTOM w0.102: v2(196.75,4.57) 196.68,4.57 196.35,4.9 IO2.22 ; v2(108.04,54.97) 107.66,54.97 107.26,55.36 CPU1.CF17 ; v2(135.17,52.92) 136.04,52.06 R2120.2
