# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_CLKREQ_CPU_N: length 169.8
  TOP w0.102: RN1813.7 120.89,36.23 v1(120.67,36.01) 120.15,35.49 v2(120.03,35.49) 119.41,35.49 118.42,36.48 118.34,36.48 118.13,36.61 118.1,36.63 117.98,36.74 117.93,36.74 117.64,37.04 117.64,37.06 116.96,37.74 115.79,37.74 112.91,40.62 112.91,40.73 112.9,40.75 112.9,41.57 110.98,43.48 108.82,43.48 107.74,44.56 107.74,46.13 v2(107,46.87)
  L5 w0.102: v2(124.82,18.09) 126.05,19.32 126.05,22.33 129.13,25.41 136.88,25.41 138.05,24.24 138.63,24.24 139.93,22.94 143.68,22.94 143.69,22.94 146.07,22.94 147.34,24.22 148.51,24.22 149.3,25 152.1,25 154.2,22.91 154.96,22.91 155.49,22.39 156.33,22.39 158.48,20.24 158.48,19.17 158.3,18.99 158.3,18.12 158.55,17.87 160.78,17.87 161.39,18.49 163.75,18.49 167.24,14.99 170.04,14.99 172.75,17.7 172.75,20.06 167.94,24.87 167.94,30.88 169.22,32.16 171.72,32.16 172.12,31.75 172.12,31.22 173.54,29.8 176,29.8 176.63,29.18 181.57,29.18 183.67,27.08 188.25,27.08 190.59,24.74 190.59,21.27 193.51,18.36 193.51,13 193.51,12.8 193.48,12.77 193.48,12.06 193.51,12.03 193.51,11.98 194.16,11.33 194.41,11.33 195.3,10.44 195.3,4.31 v2(194.88,3.89)
  L8 w0.102: v2(124.82,18.09) 124.82,18.9 122.53,21.18 122.53,21.75 119.91,24.38 119.91,27.03 119.83,27.11 119.83,29.71 119.62,29.92 119.62,35.08 v2(120.03,35.49)
  BOTTOM w0.102: v2(107,46.87) 107.32,47.19 CPU1.CF30 ; IO2.24 195.95,4.45 195.23,4.45 194.85,4.07 194.85,3.93 v2(194.88,3.89)
WWAN_GPO_PEREST#: length 120.6
  TOP w0.102: v2(130.24,22.69) 130.66,22.27 134.53,22.27 134.6,22.34 134.84,22.34 134.96,22.47 140.06,22.47 141.18,21.35 144.48,21.35 v1(144.95,20.88) v2(145.61,20.22) ; R6603.1 173.08,29.66 172.89,29.47 v2(172.76,29.47)
  L3 w0.102: v2(118.96,29) 118.45,29.51 118.45,30.26 119.6,31.4 119.6,35.67 119.94,36.01 119.94,36.54 117.71,38.77 117.67,38.77 115.03,41.4 115.03,44.33 114.69,44.67 113.91,44.67 113.19,45.39 113.19,45.75 113.9,46.45 113.9,49.02 111.52,51.4 109.98,51.4 109.94,51.44 108.98,51.44 108.94,51.48 108.6,51.48 v2(108.22,51.86)
  L5 w0.102: v2(172.76,29.47) 171.06,27.77 169.54,27.77 168.35,26.58 168.35,25.29 168.7,24.94 170.84,24.94 171.16,24.62 171.16,22.47 173.44,20.2 173.44,17.98 173.44,17.81 170.15,14.53 165.85,14.53 165.33,15.04 160.41,15.04 159.56,15.89 156.69,15.89 154.84,14.04 152.92,14.04 152.24,14.71 149.95,14.71 148.18,16.48 147.62,16.48 144.39,19.71 144.39,20.39 144.64,20.64 145.19,20.64 v2(145.61,20.22)
  L6 w0.102: v2(130.24,22.69) 129.76,23.17 126.71,23.17 122.33,27.55 122.33,29.82 121.41,30.73 119.87,30.73 119.68,30.55 119.68,29.72 v2(118.96,29)
  BOTTOM w0.102: CPU1.CH22 108.22,52 v2(108.22,51.86)
WWAN_GPO_PEREST#_R: length 43.2
  TOP w0.127: v1(175.9,29.79) 175.26,30.44 R6604.2 174.48,29.69 R6603.2 174.51,29.12 v2(174.61,29.01)
  L5 w0.127: v2(194.87,5.53) 195,5.66 195,10.4 194.31,11.09 194.26,11.09 194.26,11.09 194.06,11.09 193.27,11.88 193.27,11.93 193.24,11.96 193.24,12.87 193.27,12.9 193.27,12.9 193.27,13.1 193.27,13.1 193.27,18.26 190.35,21.17 190.35,24.64 189.05,25.94 187.4,25.94 186.49,26.84 183.57,26.84 181.47,28.94 177.28,28.94 177.27,28.93 174.7,28.93 v2(174.61,29.01)
  BOTTOM w0.127: v2(194.87,5.53) 195.19,5.53 195.36,5.7 IO2.18
WWAN_PCIE_CLK_N: length 151
  L8 w0.089: v2(93.36,67.19) 93.56,67.38 93.68,67.38 94.53,66.53 95.7,66.53 97.37,64.86 104.18,64.86 105.14,63.9 111.45,63.9 115.84,59.5 117.15,59.5 117.82,58.83 117.82,55.4 118.9,54.32 118.9,53.72 121,51.62 121.32,51.62 122,50.94 122,49.13 124.1,47.03 124.71,47.03 125.95,45.79 125.95,40.92 130.61,36.25 130.61,31.42 132.27,29.76 132.27,27.85 133.18,26.94 135.47,26.94 138.17,24.25 151.81,24.25 152.16,24.6 154.86,24.6 155.1,24.35 156.56,24.35 156.56,24.35 163.59,24.35 165.97,21.96 165.97,21.1 166.38,20.69 166.38,15.15 168.48,13.05 168.48,12.57 168.97,12.08 168.97,10.11 171.09,7.98 171.09,6.33 171.09,6.09 172.43,4.75 189.61,4.75 189.61,4.75 190.07,4.75 190.68,5.37 191.79,5.37 191.9,5.48 191.9,5.63 v2(191.73,5.8)
  BOTTOM w0.102: CPU1.BD3 93.81,64.55 93.81,66.04 92.9,66.95 92.9,67.37 93,67.47 93.08,67.47 v2(93.36,67.19) ; IO2.27 192.81,3.7 192.24,3.13 192.22,3.13 192.16,3.08 191.73,3.08 190.93,3.88 190.93,4.75 191.44,5.27 191.44,5.51 v2(191.73,5.8)
WWAN_PCIE_CLK_P: length 151
  L8 w0.089: v2(191.03,5.8) 190.84,5.8 189.99,4.95 189.53,4.95 189.53,4.94 172.51,4.94 171.28,6.17 171.28,6.25 171.28,8.06 169.16,10.18 169.16,12.16 168.67,12.65 168.67,13.13 166.57,15.23 166.57,20.77 166.16,21.18 166.16,22.04 163.67,24.54 156.64,24.54 156.64,24.54 155.18,24.54 154.94,24.79 152.08,24.79 151.73,24.44 138.24,24.44 135.55,27.13 133.26,27.13 132.46,27.93 132.46,29.84 130.8,31.5 130.8,36.33 126.14,41 126.14,45.87 124.79,47.22 124.18,47.22 122.19,49.21 122.19,51.02 121.4,51.81 121.08,51.81 119.09,53.8 119.09,54.4 118.01,55.48 118.01,58.91 117.23,59.69 115.92,59.69 111.53,64.09 105.22,64.09 104.26,65.05 97.45,65.05 95.78,66.72 94.61,66.72 v2(93.36,67.98)
  BOTTOM w0.102: IO2.29 192.73,3.3 192.33,2.9 192.31,2.9 192.26,2.85 191.64,2.85 190.7,3.79 190.7,4.85 191.21,5.36 191.21,5.61 v2(191.03,5.8) ; CPU1.BC3 93.25,64.45 93.59,64.79 93.59,65.94 92.67,66.86 92.67,67.46 92.91,67.7 93.08,67.7 v2(93.36,67.98)
WWAN_PCIE_RX_N11: length 150.6
  L8 w0.089: v2(99.81,60.36) 100.06,60.36 101.22,59.19 103.62,59.19 105.09,57.72 106.14,57.72 107.49,56.36 109.17,56.36 111.32,54.22 111.32,40.74 112.75,39.31 113.83,39.31 115.48,37.67 118.56,37.67 120.48,35.74 120.48,34.3 121.48,33.3 121.48,24.72 125.61,20.59 125.61,16.17 124.91,15.47 124.91,14.45 122.84,12.37 122.84,11.79 126.79,7.84 127.51,7.84 128.02,8.35 136.91,8.35 137.5,7.76 138.29,7.76 139.38,6.68 148.09,6.68 151.37,9.95 155.53,9.95 156.17,9.31 161.68,9.31 162.52,8.48 169.77,8.48 170.5,7.75 170.5,5.81 172.1,4.21 189.39,4.21 190.29,4.21 190.91,4.82 192.39,4.82 192.99,4.22 v2(194.32,4.22)
  BOTTOM w0.102: IO2.9 193.69,7.3 194.07,6.92 194.07,5.64 194.42,5.29 194.5,5.29 194.75,5.04 194.75,4.56 194.42,4.22 v2(194.32,4.22) ; CPU1.BN10 99.25,60.1 99.25,60.26 99.34,60.36 v2(99.81,60.36)
WWAN_PCIE_RX_N12: length 148.6
  L8 w0.089: v2(191.58,4.04) 191.39,4.24 191.15,4.24 190.58,3.66 190.52,3.66 171.87,3.66 169.95,5.58 169.95,7.53 169.55,7.93 162.29,7.93 161.45,8.77 155.84,8.77 155.29,9.32 151.5,9.32 148.64,6.45 148.32,6.13 139.15,6.13 138.06,7.22 126.64,7.22 126.57,7.29 126.56,7.29 124.57,9.29 123.51,9.29 122.23,10.57 122.23,13.23 123.23,14.23 123.33,14.23 124.37,15.27 124.37,16.02 124.18,16.21 124.18,18.05 121.98,20.25 121.98,21.52 119.35,24.15 119.35,26.8 119.28,26.88 119.28,27.38 119.04,27.62 118.6,27.62 118.19,28.04 118.19,30.46 118.8,31.07 118.8,33.77 118.55,34.02 118.2,34.02 117.89,33.71 116.58,33.71 110.72,39.57 110.72,53.83 110.2,54.35 107.66,54.35 106.51,55.5 106.51,55.69 105.98,56.22 105.59,56.22 104.75,57.06 104.75,57.35 103.62,58.48 100.86,58.48 98.38,60.95 98.38,61.33 98.2,61.51 98.2,62.23 v2(97.99,62.44)
  BOTTOM w0.102: IO2.21 192.7,4.9 192.62,4.81 192.62,4.61 192.48,4.48 191.68,4.48 191.58,4.37 v2(191.58,4.04) ; CPU1.BL6 98.35,62.18 98.09,62.44 v2(97.99,62.44)
WWAN_PCIE_RX_P11: length 150.6
  L8 w0.089: v2(99.85,61.1) 99.84,61.1 100.01,61.26 100.21,61.26 100.34,61.14 100.34,60.35 101.3,59.38 103.7,59.38 105.17,57.91 106.22,57.91 107.57,56.55 109.25,56.55 111.51,54.3 111.51,40.82 112.83,39.5 113.91,39.5 113.97,39.45 115.56,37.86 118.64,37.86 120.68,35.82 120.68,34.37 121.67,33.38 121.67,24.8 125.8,20.67 125.8,16.09 125.1,15.39 125.1,14.37 123.03,12.29 123.03,11.87 126.87,8.03 127.43,8.03 127.94,8.54 136.99,8.54 137.58,7.96 138.37,7.96 139.45,6.87 148.01,6.87 151.29,10.14 155.61,10.14 156.25,9.5 161.76,9.5 162.6,8.67 169.85,8.67 170.69,7.83 170.69,5.89 172.18,4.4 189.47,4.4 190.21,4.4 190.83,5.02 192.47,5.02 193.07,4.41 193.68,4.41 193.79,4.52 193.79,5.09 193.88,5.18 194.23,5.18 194.32,5.09 v2(194.32,4.86)
  BOTTOM w0.102: v2(99.85,61.1) 99.84,61.1 99.84,61.09 99.84,61.04 99.68,60.88 CPU1.BN8 ; v2(194.32,4.86) 194.32,5.06 193.84,5.54 193.84,6.83 193.73,6.94 193.24,6.94 IO2.11
WWAN_PCIE_RX_P12: length 148.7
  L8 w0.089: v2(97.99,63.09) 98.39,62.69 98.39,61.59 98.57,61.41 98.57,61.03 100.94,58.67 103.7,58.67 104.94,57.43 104.94,57.13 105.67,56.41 106.06,56.41 106.7,55.77 106.7,55.57 107.74,54.54 110.28,54.54 110.91,53.9 110.91,39.65 116.66,33.9 117.81,33.9 118.12,34.21 118.63,34.21 118.99,33.85 118.99,30.99 118.38,30.38 118.38,28.12 118.68,27.81 119.12,27.81 119.47,27.46 119.47,26.96 119.55,26.88 119.55,24.23 122.17,21.6 122.17,20.32 124.37,18.12 124.37,16.29 124.56,16.1 124.56,15.19 123.41,14.04 123.31,14.04 122.42,13.16 122.42,10.65 123.58,9.48 124.65,9.48 126.64,7.48 126.65,7.48 126.72,7.41 138.14,7.41 139.23,6.32 148.24,6.32 148.45,6.53 148.45,6.53 151.43,9.51 155.37,9.51 155.92,8.96 161.53,8.96 162.37,8.12 169.63,8.12 170.14,7.61 170.14,5.66 171.95,3.85 189.24,3.85 189.24,3.85 190.5,3.85 191.12,4.47 191.92,4.47 v2(192.34,4.04)
  BOTTOM w0.102: v2(192.34,4.04) 192.38,4.04 192.83,4.5 IO2.23 ; v2(97.99,63.09) 97.99,63.09 97.99,63.1 98.09,63.1 98.36,62.83 CPU1.BL5
WWAN_PCIE_TX_N11: length 149.3
  L8 w0.089: v2(194.55,6.15) 194.53,6.15 194.46,6.22 190.3,6.22 189.38,5.3 172.77,5.3 171.79,6.28 171.79,10.16 169.39,12.56 169.39,13.38 166.92,15.85 166.92,20.92 166.52,21.33 166.52,22.19 163.81,24.89 162.39,24.89 161.5,25.78 160.28,25.78 158.58,27.47 152.7,27.47 151.18,25.96 142.19,25.96 141.3,26.85 140.44,26.85 140.28,26.85 140.17,26.96 138.33,28.81 137.76,28.81 137.61,28.81 133.57,32.84 133.57,33.29 133.57,37.41 129.94,41.05 129.94,47.36 128.39,48.91 127.95,48.91 124.04,52.82 124.04,53.68 122.12,55.59 122.12,59.11 118.84,62.39 117.7,62.39 113.16,66.94 110.37,66.94 106.11,71.19 102.51,71.19 100.15,68.83 100.13,68.83 99.94,68.64 v2(99.74,68.64)
  BOTTOM w0.083: 99.25,66.79 99.25,66.78 99.26,66.77 99.26,66.7 99.49,66.46 99.5,66.46 99.52,66.45 99.52,66 99.68,65.84 99.68,65.72 99.68,65.4 99.66,65.27 99.66,65.13 99.67,65.04 99.68,65.02 99.68,64.73 99.66,64.69 99.6,64.55 99.6,63.78 99.5,63.64 CPU1.BN4
  BOTTOM w0.102: IO2.3 193.72,8.5 194.78,7.44 194.78,7.19 194.98,6.99 194.98,6.6 194.55,6.17 v2(194.55,6.15) ; v2(99.74,68.64) 99.74,68.64 99.25,68.14 99.25,66.79
WWAN_PCIE_TX_N12: length 148.9
  L8 w0.089: v2(192.24,7.69) 191.81,7.26 190.64,7.26 190.26,6.89 189.93,6.89 188.89,5.85 174.51,5.85 173.95,6.41 173.95,7.35 174.21,7.6 174.21,8.56 169.94,12.83 169.94,13.61 167.53,16.02 167.53,21.14 167.06,21.61 167.06,22.42 163.15,26.33 160.5,26.33 158.81,28.02 152.39,28.02 152.33,27.96 152.04,27.67 150.88,26.5 147.33,26.5 146.82,27.01 143.93,27.01 143.52,26.6 142.34,26.6 141.54,27.4 140.66,27.4 138.71,29.35 137.83,29.35 134.12,33.07 134.12,37.64 130.49,41.27 130.49,48.5 128.32,50.67 128.25,50.67 127.34,51.58 127.34,51.91 124.28,54.97 124.25,54.97 123.9,55.32 123.9,55.36 122.7,56.56 122.7,59.96 123.18,60.44 123.18,61.21 121.28,63.11 117.87,63.11 112.77,68.21 112.05,68.21 109.95,70.31 108.07,70.31 106.32,72.06 99.85,72.06 99.09,71.3 v2(99.09,70.34)
  BOTTOM w0.076: 98.7,66.48 98.72,66.47 98.72,66.42 98.94,66.2 98.94,65.24 99.26,64.92 CPU1.BN2
  BOTTOM w0.102: v2(99.09,70.34) 98.9,70.34 98.59,70.03 98.59,66.61 98.6,66.6 98.6,66.59 98.7,66.48 ; IO2.15 192.82,6.1 192.64,6.27 192.43,6.27 192.29,6.41 192.04,6.66 192.04,7.42 192.24,7.62 v2(192.24,7.69)
WWAN_PCIE_TX_P11: length 149.3
  L8 w0.089: v2(99.74,69.32) 99.74,69.16 99.88,69.02 100.07,69.02 102.44,71.39 106.19,71.39 110.45,67.13 113.24,67.13 117.78,62.58 118.92,62.58 122.31,59.19 122.31,55.67 124.23,53.76 124.23,52.9 128.03,49.1 128.47,49.1 130.13,47.44 130.13,41.13 133.76,37.49 133.76,33.21 133.76,32.92 137.68,29 138.4,29 140.36,27.04 141.38,27.04 142.27,26.15 151.1,26.15 152.62,27.66 158.66,27.66 160.36,25.97 161.58,25.97 162.47,25.08 163.89,25.08 166.71,22.27 166.71,21.41 167.11,21 167.11,15.93 169.58,13.46 169.58,12.64 171.98,10.24 171.98,6.36 172.85,5.49 189.3,5.49 190.22,6.41 193.96,6.41 194.12,6.57 194.12,7.28 194.21,7.36 194.4,7.36 194.55,7.21 v2(194.55,6.81)
  BOTTOM w0.083: CPU1.BN3 99.37,64.47 99.47,64.68 99.48,64.69 99.51,64.76 99.51,64.77 99.51,64.95 99.48,65.06 99.48,65.34 99.51,65.42 99.51,65.72 99.51,65.76 99.35,65.93 99.35,66.37 99.09,66.63 99.09,66.63 99.06,66.65 99.06,66.7 99.02,66.75 99.02,66.79
  BOTTOM w0.102: 99.02,66.79 99.02,68.24 99.33,68.56 99.33,69.03 99.62,69.32 v2(99.74,69.32) ; IO2.5 193.25,8.15 193.75,8.15 194.55,7.35 v2(194.55,6.81)
WWAN_PCIE_TX_P12: length 148.9
  L8 w0.089: v2(99.14,69.5) 99.14,69.5 99.14,69.5 98.68,69.5 98.48,69.7 98.48,70.32 98.9,70.73 98.9,71.38 99.77,72.25 106.39,72.25 108.14,70.5 110.03,70.5 112.13,68.4 112.85,68.4 117.95,63.3 121.36,63.3 123.37,61.29 123.37,60.36 122.89,59.88 122.89,56.64 124.09,55.44 124.09,55.4 124.32,55.16 124.36,55.16 127.53,51.99 127.53,51.65 128.32,50.86 128.39,50.86 130.68,48.58 130.68,41.35 134.31,37.72 134.31,33.15 137.91,29.55 138.79,29.55 140.74,27.59 141.62,27.59 142.42,26.79 143.44,26.79 143.85,27.2 146.9,27.2 147.41,26.69 150.8,26.69 151.96,27.86 151.96,27.86 152.14,28.04 152.31,28.21 158.89,28.21 160.58,26.52 163.23,26.52 167.25,22.5 167.25,21.69 167.72,21.22 167.72,16.1 170.13,13.68 170.13,12.91 174.4,8.64 174.4,7.52 174.14,7.27 174.14,6.48 174.59,6.04 188.81,6.04 189.85,7.08 190.18,7.08 190.56,7.45 191.41,7.45 191.53,7.57 v2(191.53,7.69)
  BOTTOM w0.076: 98.88,66.63 98.88,66.49 99.1,66.27 99.1,65.68 CPU1.BN1
  BOTTOM w0.102: v2(99.14,69.5) 99.13,69.5 98.95,69.5 98.82,69.37 98.82,66.71 98.83,66.7 98.83,66.68 98.88,66.63 ; IO2.17 193.16,5.74 192.85,5.74 192.55,6.04 192.33,6.04 192.2,6.18 192.2,6.18 191.81,6.56 191.81,7.42 191.53,7.7 191.53,7.69 v2(191.53,7.69)
WWAN_USB20_N: length 146.2
  L3 w0.089: v2(194.35,2.93) 194.16,2.74 193.43,2.74 193.37,2.8 193.09,3.08 191.4,3.08 190.55,3.94 165.87,3.94 164.96,3.03 162.77,3.03 161.56,4.24 160.37,4.24 160.2,4.41 158.25,4.41 158,4.65 156.82,4.65 156.75,4.58 155.88,4.58 154.8,3.5 151.19,3.5 150.28,4.41 147.74,4.41 147.61,4.55 144.43,4.55 143.3,5.68 140.04,5.68 139.28,6.44 130.88,6.44 129.84,5.39 127.26,5.39 125.5,7.15 123.52,7.15 122.62,8.04 122.62,8.58 122.81,8.78 122.81,19.75 122.76,19.81 122.76,24.88 123.75,25.87 123.75,32.22 124.08,32.56 124.49,32.56 124.88,32.95 124.88,33.45 124.41,33.91 124.41,36.28 124.88,36.75 124.88,40.15 123.93,41.1 123.93,44.32 125.19,45.58 125.19,47.68 124.58,48.3 124.58,50.17 120.79,53.96 120.79,53.96 120.54,54.21 119.46,54.21 117.5,56.16 117.11,56.16 116.41,56.86 114.62,56.86 111.65,59.83 111.65,60.64 110.29,62 108.82,62 108.54,62.28 108.4,62.28 v2(108.17,62.51)
  BOTTOM w0.102: IO2.30 195.51,3.3 195.34,3.14 195.34,3.06 194.93,2.65 194.63,2.65 v2(194.35,2.93) ; v2(108.17,62.51) 108.17,62.59 108.4,62.83 CPU1.CH5
WWAN_USB20_P: length 146
  L3 w0.089: v2(108.17,61.85) 108.7,61.85 108.74,61.81 110.21,61.81 111.46,60.56 111.46,59.75 114.54,56.67 116.33,56.67 117.03,55.97 117.43,55.97 119.38,54.02 120.46,54.02 120.71,53.76 120.71,53.76 124.39,50.09 124.39,48.22 125,47.6 125,45.66 123.74,44.4 123.74,41.02 124.69,40.07 124.69,36.83 124.22,36.36 124.22,33.84 124.68,33.37 124.68,33.36 124.69,33.35 124.69,33.03 124.41,32.75 124,32.75 123.56,32.3 123.56,26.01 123.56,25.95 122.57,24.96 122.57,24.94 122.57,24.94 122.57,19.73 122.62,19.67 122.62,8.86 122.43,8.66 122.43,7.96 123.44,6.95 125.42,6.95 127.18,5.2 129.91,5.2 130.96,6.25 139.2,6.25 139.96,5.49 143.22,5.49 144.35,4.36 147.53,4.36 147.66,4.22 150.2,4.22 151.11,3.31 154.88,3.31 155.96,4.39 156.83,4.39 156.9,4.46 157.92,4.46 158.17,4.22 160.13,4.22 160.29,4.05 161.48,4.05 162.69,2.84 165.04,2.84 165.94,3.75 190.47,3.75 191.33,2.89 193.01,2.89 193.29,2.61 193.35,2.55 194.07,2.55 194.16,2.46 194.16,2.32 v2(194.35,2.14)
  BOTTOM w0.102: CPU1.CH6 108.49,62.18 v2(108.17,61.85) ; IO2.32 195.51,2.9 195.02,2.42 194.63,2.42 v2(194.35,2.14)
XCLK_BIASREF: length 5.1
  BOTTOM w0.305: 111.01,67.29 110.15,66.43 110.02,66.43 109.12,65.52 CPU1.CJ1
  BOTTOM w0.508: 111.01,67.29 112.7,68.97 v1(112.7,69.02)
XDP_CLK_CPU_N: length 5.6
  BOTTOM w0.102: CPU1.AU1 89.49,65.52 89.35,65.52 89.14,65.73 89.14,66.75 89.19,66.8 89.19,69.29 89.46,69.57 89.67,69.57 89.78,69.46 89.78,68.95 89.62,68.79 TP1808.1
XDP_CLK_CPU_P: length 5.8
  BOTTOM w0.102: TP1807.1 89.57,70 88.97,69.39 88.97,66.89 88.91,66.84 88.91,65.63 89.49,65.05 CPU1.AU2
XDP_DBRESET#: length 11.6
  BOTTOM w0.076: 115.15,59.76 113.55,59.76 113.54,59.77 112.77,59.77 112.73,59.73 arc(112.71,59.73) 112.68,59.72 arc(112.63,59.67) 112.55,59.65 112.39,59.65 arc(112.35,59.66) 112.31,59.67 arc(112.24,59.7) 112.17,59.71 112.1,59.71 arc(112.04,59.7) 111.98,59.67 arc(111.94,59.66) 111.9,59.65 111.74,59.65 arc(111.66,59.67) 111.6,59.72 arc(111.39,59.79) CPU1.CN10
  BOTTOM w0.102: 115.15,59.76 115.39,59.76 116.5,60.87 116.5,61.01 116.73,61.24 116.87,61.24 117.1,61.47 119.28,61.47 119.63,61.12 119.63,60.48 v1(119.85,60.26) 120.05,60.26 120.66,60.87 R1701.2
XDP_PRDY#: length 5.3
  BOTTOM w0.102: TP306.1 75.58,68.37 77.46,66.49 78.27,66.49 78.6,66.16 CPU1.W1
XDP_PREQ#: length 6.2
  BOTTOM w0.102: CPU1.W2 78.6,65 78.87,65.27 78.87,66.16 78.34,66.7 77.61,66.7 75.73,68.57 75.73,69.21 TP305.1
XDP_TCLK: length 4.2
  TOP w0.102: TP309.1 75.03,62.35 R317.2 75.5,61.88 v2(76.77,61.88)
  BOTTOM w0.102: CPU1.P6 75.44,62.11 76.22,62.11 CPU1.T6 76.47,62.18 v2(76.77,61.88)
XDP_TDI: length 15.8
  BOTTOM w0.102: CPU1.U6 CPU1.U5 76.83,62.83 76.54,63.12 75.51,63.12 75.14,63.49 75.14,65 74.95,65.2 74.75,65.2 72.92,67.03 67.05,67.03 65.53,68.54 TP310.1
XDP_TDO_CPU: length 18.8
  TOP w0.102: v2(77.64,62.55) 77.47,62.37 TP316.1
  BOTTOM w0.102: v2(77.64,62.55) 77.92,62.83 CPU1.W5 CPU1.Y5 78.67,63.22 76.99,63.22 76.43,63.78 76.43,65.7 75.43,66.7 74.41,66.7 73.65,67.46 72.23,67.46 71.39,68.3 67.38,68.3 67.25,68.42 67.17,68.42 66.93,68.66 66.93,69.55 R310.2
XDP_TMS: length 1.8
  TOP w0.102: v2(75.81,62.52) 76.17,62.88 TP317.1
  BOTTOM w0.102: CPU1.T5 76.12,62.83 v2(75.81,62.52) 75.51,62.83 CPU1.P5
XDP_TRST#: length 1.7
  TOP w0.102: v2(79.52,61.95) 79.44,62.03 TP313.1
  BOTTOM w0.102: CPU1.AB6 79.76,61.95 79.52,61.95 v2(79.52,61.95) 79.51,61.95 79.29,61.95 CPU1.Y6
XTL_24M_X1_CPU: length 9.1
  BOTTOM w0.089: CPU1.CK3 110.25,64.37 110.25,64.66 111.06,65.47 111.06,65.94 111.82,66.7 112.01,66.7 112.38,67.07 113.05,67.07 114.1,68.12 114.1,68.15 114.37,68.42 R1839.1
XTL_24M_X1_R: length 4.2
  BOTTOM w0.089: R1839.2 115.79,71.4 115.79,72.42 R1841.2 115.81,73.21 C1807.1 115.8,73.26 X1801.1
XTL_24M_X2_CPU: length 9.4
  BOTTOM w0.089: 113.86,69.34 113.86,71.09 114.37,71.6 R1840.1 ; 113.86,69.34 v1(113.87,69.34) ; 113.86,69.34 113.86,68.25 112.86,67.25 111.94,67.25 109.7,65.01 CPU1.CK2
XTL_24M_X2_R: length 5.1
  BOTTOM w0.089: R1840.2 115.11,71.75 115.11,72.28 R1841.1 114.95,73.18 C1808.1 114.99,73.25 115.58,73.85 115.58,75.1 X1801.3
XTL_27M_X2: length 3.3
  BOTTOM w0.089: v1(172.44,40.14) 173.55,40.14 X7901.3 173.07,40.63 C7908.1 172.51,41.65 R7904.2
XTL_32K_X1_CPU: length 15.5
  TOP w0.089: v2(98.84,46.25) 98.84,45.71 v1(98.86,45.69) 98.84,45.68 98.84,44.76 100.68,42.92 100.68,41.4 102.45,39.62 103.09,39.62 104.48,38.23 104.48,36.62 C1804.1 R1815.1 105.19,35.95 X1802.1
  BOTTOM w0.089: v2(98.84,46.25) 98.85,46.25 98.85,46.39 99,46.54 CPU1.BN31
XTL_32K_X2_CPU: length 15.1
  TOP w0.089: v2(99.49,45.43) 101.15,43.77 101.15,41.69 102.75,40.09 103.28,40.09 106.71,36.66 C1803.1 R1815.2 106.05,35.95 X1802.2
  BOTTOM w0.089: v2(99.49,45.43) 99.48,45.43 99.48,45.62 99.26,45.84 CPU1.BN32

## Copper pours and planes (outline as drawn)
1V_CPU_CORE on TOP: outline of 82 points within 73.44,48.49 95.49,77.91 ; 83 cut-outs
1V_CPU_CORE on BOTTOM: 87.1,48.79 86.82,49.07 86.82,50.6 87.76,51.54 95.16,51.54 95.41,51.28 95.41,49.94 95.82,49.53 95.82,48.89 95.71,48.79
1V_CPU_CORE on BOTTOM: 79.25,59.16 79.2,59.2 79.2,59.6 78.89,59.92 78.89,60.97 78.98,61.07 86.56,61.07 86.64,60.99 86.64,60.82 86.91,60.55 87.79,60.55 88.17,60.93 88.17,61.57 88.04,61.7 88.04,62.84 88.17,62.97 90.2,62.97 90.21,62.95 90.23,62.97 93.89,62.97 94.01,62.84 94.01,62.58 93.63,62.2 93.63,61.82 92.74,60.93 92.74,60.81 92.87,60.68 93.25,60.68 93.63,61.06 94.01,61.06 94.39,60.68 95.28,60.68 95.41,60.55 95.41,60.17 94.65,60.17 93.63,59.16
1V_CPU_CORE on BOTTOM: 74.66,72.29 74.43,72.52 74.43,72.82 74.17,73.08 72.02,73.08 71.49,73.62 71.49,79.28 71.89,79.68 74.13,79.68 74.38,79.43 74.38,78.67 74.89,78.16 83.78,78.16 84.21,78.59 84.21,79.68 84.3,79.77 86.99,79.77 87.06,79.71 87.06,76.59 88.52,75.13 88.52,73.27 88.21,72.97 86.53,72.97 86.51,72.99 84.22,72.99 83.53,72.29 ; 18 cut-outs
1V_CPU_CORE on L2GND, L4VCC: 95.15,50.52 95.4,50.27 95.4,48.9 95.26,48.76 88.56,48.76 87.8,49.52 82.08,49.52 79.27,52.33 79.27,59.67 80.3,60.7 85.38,60.7 86.39,61.7 86.39,64.27 83.85,66.81 83.85,71.25 81.45,73.65 73.57,73.65 73.05,74.18 73.05,77.32 73.7,77.97 83.99,77.97 84.62,78.61 89.67,78.61 90.58,77.7 90.58,67.54 91.72,66.4 91.72,65.51 92.23,65 92.23,63.13 91.85,62.75 91.85,61.32 92.1,61.06 92.1,60.56 92.72,59.94 93.35,59.94 93.62,59.67 93.62,58.65 93.88,58.4 93.88,53.44 95.4,51.92 95.4,51.32 95.15,51.06
1V_CPU_CORE on L3: 90.64,69.12 92.01,67.75 92.01,65.71 92.66,65.06 92.66,60.49 93.94,59.21 93.94,53.4 95.47,51.87 95.47,48.8 95.34,48.67 88.23,48.67 87.37,49.52 82.09,49.52 79.36,52.25 79.36,60.05 80.05,60.74 84.98,60.74 85.51,61.27 85.53,61.27 86.19,61.93 86.19,64.44 83.81,66.83 83.81,71.3 83.78,71.3 81.37,73.72 73.62,73.72 73.18,74.16 73.18,77.46 73.62,77.91 84.16,77.91 84.8,78.54 89.62,78.54 90.64,77.53
1V_CPU_CORE on L6: 74.76,77.93 86.78,77.93 87.03,77.68 87.03,76.56 87.4,76.19 90.07,76.19 93.31,72.95 93.31,70.82 93.05,70.57 93.05,66.83 93.66,66.22 93.66,54.08 95.52,52.23 95.52,48.9 95.26,48.65 88.28,48.65 87.19,49.74 87.19,51.24 86.67,51.75 79.91,51.75 79.36,52.29 79.36,59.85 73.44,65.77 73.44,76.61
1V_VCCGT on TOP: outline of 88 points within 49.2,46.72 79.77,66.14 ; 77 cut-outs
1V_VCCGT on BOTTOM: 50.38,46.16 49.87,46.66 49.87,55.91 50.15,56.19 55.23,56.19 55.82,56.77 55.82,57.94 56.86,58.98 56.86,60.85 57.45,61.44 58.43,61.44 59.21,62.23 65.33,62.23 66.62,63.52 67.98,63.52 68.31,63.85 68.31,64.59 68.82,65.1 69.05,65.1 70.77,63.37 71.71,63.37 71.8,63.28 71.79,63.28 71.79,62.29 72.29,61.79 74.55,61.79 74.69,61.64 74.69,61.1 74.81,60.98 75.15,60.98 75.23,61.06 75.62,61.06 75.64,61.04 78.56,61.04 78.79,60.82 78.79,60.43 78.77,60.42 78.77,59.91 79.03,59.66 79.03,59.15 78.9,59.03 73.31,59.03 73.19,58.9 73.19,53.95 72.83,53.59 67.55,53.59 67.54,53.6 65.19,53.6 64.22,52.63 62.83,52.63 59.02,48.82 55.71,48.82 55.08,48.19 53.17,48.19 52.92,47.93 52.92,46.28 52.79,46.16 ; 8 cut-outs
1V_VCCGT on L3: 58.38,60.81 77.69,60.81 79.01,59.49 79.01,57 79.15,56.86 79.15,51.68 78.94,51.47 73.48,51.47 71.28,53.68 66.61,53.68 65.62,54.67 58.51,54.67 55.02,51.17 50.83,51.17 49.87,52.13 49.87,56.32 50.51,56.95 54.52,56.95
1V_VCCGT on L5: 67.25,53.98 72.73,53.98 73.29,54.54 73.29,57.71 74.49,58.91 78.8,58.91 78.98,59.09 78.98,59.87 78.73,60.13 58.13,60.13 56.18,58.18 54.23,58.18 52.49,56.44 50.25,56.44 49.87,56.06 49.87,51.87 50.76,50.98 55.61,50.98 59.8,55.17 66.05,55.17
1V_VCCGT on L6: 67.17,53.95 70.46,53.95 72.82,51.59 78.92,51.59 79.15,51.81 79.15,59.73 78.24,60.63 58.13,60.63 55.61,58.12 54.04,58.12 53.38,57.46 50.51,57.46 49.87,56.82 49.87,51.74 50.51,51.11 55.66,51.11 59.78,55.22 65.9,55.22
1V_VCCGT on L8: 67.27,54.03 72.94,54.03 73.44,54.54 73.44,57.87 74.43,58.86 78.7,58.86 79.08,59.24 79.08,59.72 78.45,60.36 58.51,60.36 56.48,58.32 55.23,58.32 54.75,57.84 50.63,57.84 49.87,57.08 49.87,52.13 50.89,51.11 54.06,51.11 57.11,54.16 67.14,54.16
1V_VCCIO on TOP: 94.27,49.38 94.22,49.43 94.22,50.27 94.45,50.5 95.67,50.5 95.92,50.75 95.92,50.96 95.75,51.14 95.75,51.36 96,51.62 96,52.81 96.18,52.99 96.69,52.99 97.09,52.58 97.09,51.52 97.22,51.39 97.22,51.03 96.96,50.78 96.96,50.14 96.71,49.89 96.38,49.89 95.87,49.38 ; 2 cut-outs
1V_VCCIO on TOP: 99.32,55.39 99.11,55.6 98.51,55.6 98.51,55.6 98.38,55.46 97.61,55.46 97.52,55.56 97.52,55.98 97.79,56.26 98.04,56.26 98.11,56.32 98.11,56.91 98.17,56.97 98.73,56.97 98.88,56.82 98.88,56.68 98.97,56.58 99.61,56.58 99.78,56.41 99.78,55.61 99.56,55.39 ; 1 cut-out
1V_VCCIO on TOP: 84.57,49.15 84.37,49.36 84.37,50.07 85.28,50.99 85.28,51.28 86.65,51.28 86.83,51.1 86.83,50.42 86.7,50.3 86.7,49.51 86.35,49.15 ; 2 cut-outs
1V_VCCIO on TOP: 107.7,77.69 107.1,78.29 107.1,79.16 107.55,79.6 108.98,79.6 108.99,79.61 110.87,79.61 111.1,79.38 111.1,77.94 110.86,77.69
1V_VCCIO on BOTTOM: 96.05,48.61 95.92,48.74 95.92,51.28 96.04,51.41 97.06,51.41 97.19,51.28 97.19,49.5 97.19,49.5 97.19,48.74 97.06,48.61
1V_VCCIO on BOTTOM: 85.58,48.92 85,49.5 85,51.23 85.3,51.54 86.65,51.54 86.93,51.26 86.93,50.9 86.73,50.71 86.73,49.06 86.6,48.92
1V_VCCIO on L3: 109.37,79.04 109.37,79.81 109.3,79.88 105.74,79.88 104.06,78.21 103.83,78.21 103.82,78.2 103.18,78.2 103.18,78.19 103.12,78.19 102.81,77.88 102.81,77.06 103.29,76.58 106.09,76.58 106.91,76.58
1V_VCCIO on L6: 98.29,70.58 98.32,70.6 98.32,70.99 101.65,74.32 101.65,76.7 102.91,77.95 105.04,77.95 105.32,77.67 105.32,73.42 102.06,70.16 102.06,64.28 101.69,63.91 101.69,60.21 101.27,59.79 101.25,59.79 101.25,56.93 101.24,56.92 101.24,55.11 100.38,54.25 99.5,54.25 99.24,53.99 99.24,52.99 99.96,52.27 99.96,50.33 98.95,49.32 97.74,49.32 97.41,49 97.41,48.7 97.26,48.54 95.8,48.54 95.69,48.65 95.69,50.16 95.96,50.43 95.96,50.9 95.79,51.07 95.79,51.58 95.85,51.64 97.05,51.64 97.29,51.4 97.29,51.12 97.12,50.95 97.12,50.57 97.23,50.46 98.47,50.46 99.11,51.1 99.11,51.81 98.29,52.63
1V_VCCIO on L8: 97.35,51.16 97.14,50.96 97.14,49.31 97.4,49.05 97.4,48.8 97.14,48.54 95.82,48.54 95.26,49.1 85.99,49.1 85.08,50.02 85.08,50.86 84.85,51.08 84.85,51.36 84.89,51.41 84.89,51.84 86.7,53.65 86.7,59.24 86.96,59.49 87.21,59.49 87.45,59.25 87.45,53.36 87.83,52.98 95.03,52.98 98.72,56.68 99.53,56.68 99.86,56.35 99.86,54.83 97.35,52.32
1V_VCCIO_R on TOP: 108.11,79.74 107.96,79.89 107.96,81.42 108.41,81.87 108.41,82.78 108.49,82.86 111.46,82.86 111.81,82.51 111.81,80.41 111.63,80.23 109.3,80.23 108.8,79.74 ; 2 cut-outs
1V_VCCSA on TOP: 97.19,50.5 97.17,50.53 97.17,52.66 96.75,53.08 96.34,53.08 95.92,53.5 95.92,59 95.76,59.16 95.76,60.08 95.59,60.24 95.59,63.28 95.61,63.29 95.34,63.56 95.34,66.45 95.03,66.76 95.03,74.12 95.66,74.75 95.66,76.36 95.65,76.37 95.65,77.19 96.03,77.56 98.48,77.56 98.95,78.03 103.16,78.03 104.28,76.92 104.28,74.68 103.16,73.56 101.79,73.56 98.77,70.54 98.77,69.52 99.29,69 99.29,61.65 99.24,61.6 99.2,61.6 99,61.4 98.97,61.4 98.9,61.33 98.92,61.31 98.92,58.65 98.58,58.31 97.79,58.31 97.42,57.94 97.42,54.68 98.41,53.69 98.41,52.66 99.05,52.02 99.05,50.83 98.72,50.5 ; 16 cut-outs
1V_VCCSA on BOTTOM: 97.44,49 97.31,49.12 97.31,51.41 97.44,51.54 99.22,51.54 99.47,51.28 99.47,50.01 99.35,49.88 98.97,49.88 98.08,49
1V_VCCSA on BOTTOM: 98.11,73.16 97.95,73.31 97.95,76.75 99.29,78.08 100.99,78.08 101.29,77.78 101.29,77.34 101.66,76.96 103.77,76.96 103.9,76.83 103.9,74.27 103.85,74.21 101.61,74.21 100.56,73.16 ; 2 cut-outs
1V_VCCSA on BOTTOM: 95.72,59.03 95.56,59.18 95.56,60.96 96.02,61.41 96.33,61.41 96.58,61.16 96.73,61.16 96.99,61.41 97.27,61.41 97.49,61.18 97.67,61.18 97.93,61.44 98.21,61.44 98.61,61.03 98.61,59.25 98.38,59.03
1V_VCCSA on L6: 99.09,51.25 99.09,51.77 98.22,52.64 98.22,70.96 101.46,74.2 101.46,77.7 101.13,78.03 97.47,78.03 94.98,75.54 94.98,75.44 93.69,74.15 93.69,66.95 93.91,66.73 93.91,59.34 94.83,58.42 94.83,53.99 97.14,51.68 97.14,50.65 97.3,50.5 98.02,50.5 98.03,50.49 98.33,50.49
1V_VCCST_CPU_R on TOP: 137.28,83.78 137.17,83.9 137.17,85.61 137.28,85.72 139.24,85.72 139.38,85.87 139.39,85.87 139.41,85.9 139.41,86.2 139.5,86.28 140.32,86.28 140.44,86.17 140.44,84.47 139.96,83.99 138.24,83.99 138.04,83.78 ; 3 cut-outs
1V_VGA_CORE on TOP: 158.43,61.93 154.57,65.79 154.57,66.5 153.13,67.94 153.13,68.42 153.54,68.83 154.05,68.83 155.28,67.59 155.28,66.76 157.44,64.6 157.44,64.52 159.35,62.62 159.35,62.21 159.07,61.93 ; 4 cut-outs
1V_VGA_CORE on TOP: 156.39,60.43 155.91,60.91 155.91,61.69 155.94,61.73 155.71,61.96 155.18,61.96 154.57,62.57 154.57,63.1 152.16,65.51 152.16,65.87 152.67,66.38 152.84,66.38 153.73,65.49 153.73,65.19 154.86,64.06 154.98,64.06 155.18,63.86 155.18,63.35 155.87,62.67 156.35,62.67 156.6,62.41 156.6,61.8 156.6,61.8 156.6,61.73 157.12,61.21 157.12,60.77 156.79,60.43
1V_VGA_CORE on TOP: 156.94,37.45 154.06,40.32 154.06,42.3 152.87,43.49 148.81,43.49 148.2,42.88 141.8,42.88 140.73,43.95 136.99,43.95 135.87,42.82 135.47,42.82 135.21,43.09 135.21,46.95 136.36,48.11 139.39,48.11 139.72,48.44 153.99,48.44 162.32,40.11 162.32,40.07 163.9,38.49 163.9,37.62 163.73,37.45 ; 21 cut-outs
1V_VGA_CORE on TOP: 160.21,63.38 157.11,66.47 157.11,66.85 156.43,67.53 156.43,67.7 155.4,68.73 155.4,68.74 155.31,68.83 155.31,69.21 154.87,69.65 154.87,70.04 155.29,70.47 155.69,70.47 156.12,70.04 156.12,69.14 157.04,68.23 157.38,68.23 157.9,67.71 157.9,67.14 158.29,66.76 158.56,66.76 160.9,64.42 160.9,63.63 160.64,63.38 ; 2 cut-outs
1V_VGA_CORE on BOTTOM: 162.74,33.34 162.68,33.4 162.68,35.68 162.7,35.69 162.7,36.08 162.32,36.46 162.32,38.51 161.96,38.87 155.69,38.87 154.29,40.26 154.29,42.93 153.23,44 132.89,44 130.93,42.04 130.93,41.26 130.35,40.68 129.38,40.68 129.15,40.91 129.15,47.55 129.91,48.32 140.42,48.32 141.01,47.73 153.77,47.73 158.27,43.23 158.94,43.23 163.65,38.52 163.65,34.17 163.67,34.16 163.67,33.62 163.39,33.34 ; 23 cut-outs
1V_VGA_CORE on BOTTOM: 151.07,51.44 148.81,53.69 148.56,53.69 147.32,54.93 147.32,54.94 146.06,56.2 145.62,56.2 144.09,57.73 144.09,58.96 144.75,59.62 146.16,59.62 154.19,67.65 154.19,68.2 156.1,70.11 157.47,70.11 163.06,64.52 163.06,62.54 157.21,56.7 157.21,55.35 153.3,51.44
1V_VGA_CORE on L5: 154.65,68.92 158.79,68.92 162.37,65.33 162.37,63.73 159.63,60.99 159.63,58.76 158.84,57.97 158.84,55.66 159.63,54.87 159.63,40.37 158.13,38.87 154.7,38.87 153.63,39.93 153.63,42.98 152.92,43.69 136.23,43.69 136.22,43.71 135.68,43.71 135.3,44.09 135.3,47.8 135.47,47.96 135.47,49.74
1V_VGA_CORE on L6: 154.65,68.92 158.79,68.92 162.37,65.33 162.37,63.73 159.63,60.99 159.63,40.37 158.13,38.87 154.7,38.87 153.63,39.93 153.63,42.98 152.92,43.69 136.23,43.69 136.23,43.7 135.63,43.7 135.29,44.05 135.29,47.73 135.47,47.91 135.47,49.74
1V_VGA_CORE on L8: 158.21,59.2 156.3,59.2 152.21,63.29 152.21,64.7 155.79,68.28 158.19,68.28 159.34,67.13 160.5,67.13 162.36,65.27 162.36,63.35
1V_VGA_S0 on BOTTOM: 157.34,72.4 157.31,72.42 157.31,77.63 157.8,78.11 157.8,80.68 160.44,83.32 160.44,87.58 160.82,87.97 161.61,87.97 161.89,87.69 161.89,83.16 158.78,80.06 158.78,78.07 158.33,77.61 158.33,77.6 157.87,77.14 157.87,72.6 157.67,72.4 ; 4 cut-outs
1V_VGA_S0 on BOTTOM: 134.05,87.56 134.05,88.5 134.15,88.6 134.18,88.6 134.35,88.78 135.37,88.78 135.75,88.4 135.75,87.71 135.62,87.58 134.69,87.58 134.67,87.56
1V_VGA_S0 on L5: 134.37,88.63 145.05,88.63 147.45,86.23 147.45,84.92 149.8,82.57 149.8,82.57 150,82.37 153.69,82.37 155.28,83.96 157.65,83.96 159.79,86.1 160.44,86.1 161.14,85.41 161.14,84.94 158.35,82.16 156.77,82.16 154.3,79.68 148.58,79.68 148.02,80.25 148.02,82.31 147.33,83 146.34,83 145.4,83.95 145.4,83.96 144.69,83.96 141.45,87.21 140.45,87.21 139.94,86.7 134.42,86.7 134.09,87.02 134.09,88.35
5V_FAN_VCC on TOP: 191.54,35.95 189.92,37.57 189.46,37.57 189.17,37.85 189.17,38.76 189.43,39.02 191.69,39.02 191.69,39.02 191.71,39.01 192.63,39.01 192.81,38.83 192.81,37.01 192.79,36.98 192.79,36.14 192.6,35.95 ; 3 cut-outs
5V_FAN_VCC on BOTTOM: 186.88,37.52 186.75,37.65 186.75,38.59 187.23,39.07 190.03,39.07 190.53,38.56 190.87,38.56 191.12,38.31 191.12,37.8 190.92,37.6 189.5,37.6 189.42,37.52
5V_HDMI on TOP: 14.03,59.82 12.45,61.4 12.45,62.54 12.39,62.61 11.44,62.61 11.29,62.76 11.29,63.54 11.63,63.89 13.21,63.89 13.63,63.46 13.63,62.19 14.12,61.7 14.96,61.7 15.08,61.58 15.08,60.03 15.55,59.57 15.55,59.19 15.45,59.09 15.07,59.09 14.96,59.2 14.96,59.62 14.75,59.82
5V_KB_BL on BOTTOM: 19.73,8.43 19.53,8.63 19.53,9.42 19.74,9.63 20.44,9.63 20.66,9.85 20.66,10.28 21.05,10.67 24.93,10.67 25.13,10.88 25.61,10.88 25.7,10.79 25.7,9.08 25.58,8.96 22.04,8.96 21.5,8.43 ; 1 cut-out
5V_S0 on TOP: 15.14,61.18 15.47,61.51 16.71,61.51 16.8,61.42 16.8,59.94 16.72,59.86 16.72,59.84 16.6,59.72 16.6,59.18 16.42,59.01 16.15,59.01 16.14,59.02 15.97,59.02 15.89,59.1 15.89,59.45 15.14,60.2
5V_S0 on TOP: 179.97,23.32 179.97,23.35 179.6,23.35 179.36,23.59 179.36,24.3 179.55,24.49 180.03,24.49 180.92,25.38 183.53,25.38 183.9,25.01 183.9,23.63 183.59,23.32 ; 1 cut-out
5V_S0 on TOP: 193.52,35.96 193.33,36.15 193.33,38.06 193.46,38.2 194.64,38.2 194.88,37.96 194.88,36.22 194.62,35.96 ; 1 cut-out
5V_S0 on BOTTOM: 19.98,6.33 19.59,6.72 19.59,7.72 19.76,7.9 21.97,7.9 22.67,7.2 22.67,6.45 22.54,6.33
5V_S0 on BOTTOM: 62.33,8.72 62.11,8.94 59.65,8.94 59.51,9.07 59.51,10.3 59.84,10.63 60.99,10.63 61.47,10.15 63.66,10.15 64.14,10.63 64.57,10.63 64.69,10.5 64.69,9 64.41,8.72
5V_S0 on L6: outline of 148 points within 13.23,1.1 196.23,61.07
5V_S0 on L8: 181.07,23.88 183.56,23.88 189.45,29.76 191.05,29.76 195.29,34 195.29,38.16 194.8,38.65 193.29,38.65 190.92,36.29 190.92,34 187.68,30.75 187.53,30.75 185.55,28.77 185.48,28.77 182.33,25.61 181.57,25.61 180.97,25.01 180.97,23.98
5V_S5 on TOP: 64.99,1.58 64.1,2.47 64.1,3.99 64.22,4.12 64.99,4.12 65.37,4.5 67.43,4.5 67.53,4.4 70.09,4.4 70.09,4.4 70.19,4.5 72.99,4.5 73.24,4.25 73.24,2.34 72.48,1.58 ; 14 cut-outs
5V_S5 on BOTTOM: 23.83,63.01 23.76,63.09 23.24,63.09 23.18,63.15 23.18,63.35 22.9,63.63 22.44,63.63 22.29,63.78 22.29,64.17 22.03,64.42 22.03,65 22.01,65.03 22.01,65.51 22.67,66.17 23.13,66.17 23.38,66.43 23.58,66.43 24.31,65.7 24.31,63.11 24.21,63.01 ; 3 cut-outs
5V_S5 on BOTTOM: 65.6,2.32 65.41,2.5 65.41,4.09 64.17,5.33 64.17,6.99 64.38,7.19 65.2,7.19 65.56,7.55 65.56,8.87 65.94,9.26 65.94,10.4 66.09,10.55 67.01,10.55 67.34,10.22 68.75,10.22 68.88,10.09 68.88,9.84 69,9.72 69.45,9.72 69.56,9.61 69.56,7.93 70.38,7.1 70.41,7.1 70.74,6.78 70.74,2.59 70.46,2.32 ; 2 cut-outs
5V_S5 on BOTTOM: 172.59,7.3 171.84,8.05 171.84,9.7 171.97,9.83 173.48,9.83 173.55,9.76 173.55,8.33 173.96,7.92 173.96,7.5 173.77,7.3
5V_S5 on BOTTOM: 50.52,70.43 50.45,70.5 50.45,70.82 52,72.37 57.51,72.37 58.36,73.22 61.11,73.22 61.64,72.69 63.9,72.69 64.61,73.39 64.61,73.69 64.79,73.87 65.1,73.87 65.33,73.65 65.33,72.78 64.63,72.08 60.75,72.08 60.16,72.66 59.47,72.66 58.41,71.6 52.7,71.6 51.54,70.43
5V_S5 on L3: 120.34,22.57 120.75,22.57 120.84,22.47 120.84,21.07 119.68,19.91 119.68,18.66 120.72,17.62 120.72,16.05 121.63,15.14 121.63,6.26 121.64,6.26 121.64,6.07 123.04,4.66 123.04,4.19 122.9,4.05 122.59,4.05 120.68,5.95 120.68,13.36 119.95,14.09 119.95,16.8 118.79,17.96 118.79,20.04 120.05,21.3 120.05,22.28
5V_S5 on L5: 136.34,1.2 136.41,1.26 164.13,1.26 164.15,1.25 166.28,1.25 168.62,3.59 173.04,3.59 173.89,4.43 173.89,7.98 173.89,7.99 173.78,8.1 157.78,8.1 155,5.32 68.06,5.32 68.06,5.32 66.21,5.32 65.24,4.35 65.24,2.14 66.18,1.2 ; 1 cut-out
5V_S5 on L6: 9.46,25.3 9.46,25.51 9.94,25.99 10.02,25.99 11.44,27.41 11.44,29.39 10.42,30.41 10.42,35.38 11.54,36.5 11.54,40.29 11.54,46.81 11.7,47.01 11.7,47.75 12.25,48.29 12.25,50.49 13.2,51.44 13.2,52.43 12.49,53.14 12.49,63.58 12.41,63.66 11.85,63.66 11.52,63.99 11.52,64.75 11.95,65.18 14.01,65.18 14.49,64.7 14.49,56.62 15.85,55.26 15.85,52.51 16.08,52.28 16.08,50.7 16.65,50.12 16.65,44.64 16.64,44.63 16.64,43.79 15.86,43 15.86,41.92 16.3,41.48 16.3,31.34 15.15,30.19 15.15,25.54 13.13,23.52 13.13,10.48 16.72,6.89 20.61,6.89 21.99,5.52 23.24,5.52 23.25,5.51 23.96,5.51 25.02,4.45 30.52,4.45 32.66,6.59 35.84,6.59 36.09,6.34 36.09,6.32 36.54,5.87 59.71,5.87 60.29,5.29 60.29,5.26 68.95,5.26 71.16,3.05 71.16,2.37 69.88,1.09 37.13,1.09 35.42,2.8 33.61,2.8 32.98,2.16 31.92,1.1 24.83,1.1 24.35,1.58 16.52,3.13 16.5,3.11 12.75,3.11 8.26,7.59 8.26,20.81 9.15,21.7 9.15,24.99 9.2,25.04 9.2,25.04
5V_S5 on L8: 22.19,66.88 23.36,66.88 23.81,66.43 23.81,63.2 23.05,62.44 22.52,62.44 21.76,61.68 21.76,60.63 21.12,60 20.64,60 14.75,54.11 13.67,54.11 13.52,54.26 13.52,56.92 16.47,59.87 16.47,60.89 17.87,62.29 19.43,62.29 19.69,62.54 19.69,64.38
5V_S5 on L8: 103.54,84.39 102.53,84.39 101.68,85.24 101.68,87.18 102.17,87.67 108.76,87.67 109.15,87.28 109.15,86.65 109.14,86.64 109.14,86.57 108.8,86.24 107.86,86.24 107.1,87 104.81,87 104.71,86.9 103.67,86.9 103.29,86.52 103.29,85.37 103.63,85.03 103.63,84.48
19V_AD+ on TOP: 28.38,71.79 28.33,71.83 28.33,73.95 28.14,74.14 28.14,77.83 27.82,78.15 27.48,78.15 27.34,78.29 26.4,78.29 26.25,78.44 26.25,78.9 26.3,78.95 27.57,78.95 27.77,79.15 27.77,79.38 27.88,79.48 29.07,79.48 29.15,79.41 29.15,78.87 29.17,78.85 29.17,78.41 29.58,78.01 30.53,78.01 30.82,77.71 30.82,74.85 31.64,74.03 31.64,71.95 31.47,71.79 ; 2 cut-outs
19V_AD_JK on TOP: 31.09,74.99 31.08,75 31.08,76.65 31.2,76.78 31.98,76.78 32.03,76.83 32.03,77.33 30.95,78.41 30.7,78.41 30.57,78.54 30.57,80.31 31.08,80.82 31.08,81.22 30.82,81.48 30.54,81.48 29.99,82.03 29.99,82.47 30.16,82.64 31.33,82.64 31.66,82.3 31.66,79.73 31.97,79.43 32.73,79.43 32.85,79.3 32.85,78.54 33.11,78.29 33.12,78.3 33.7,78.3 33.79,78.21 33.79,75.14 33.63,74.99 ; 4 cut-outs
19V_DCBATOUT on TOP: outline of 115 points within 121.95,9.4 188.07,60.97 ; 30 cut-outs
19V_DCBATOUT on TOP: outline of 81 points within 34.45,36.84 66.56,80.98 ; 24 cut-outs
19V_DCBATOUT on BOTTOM: 40.25,69.78 40.18,69.84 40.18,69.94 39.97,70.16 39.97,73.49 40.13,73.65 42.44,73.65 43.68,72.42 46.47,72.42 46.7,72.19 46.7,71.38 46.49,71.18 44.95,71.18 43.68,69.91 41.82,69.91 41.69,69.78 ; 2 cut-outs
19V_DCBATOUT on BOTTOM: 40.73,36.5 40.47,36.76 40.47,37.89 39.83,38.53 39.83,39.14 40.03,39.33 41.05,39.33 41.22,39.17 42.13,39.17 42.51,38.79 42.51,36.63 42.38,36.5
19V_DCBATOUT on BOTTOM: 136.74,33.2 136.54,33.41 135.83,33.41 135.61,33.63 134.66,33.63 134.46,33.82 134.46,34.11 134.16,34.4 133.23,34.4 131.6,36.04 131.32,36.04 131.32,36.03 130.92,36.03 130.12,36.83 130.12,37.81 130.23,37.92 130.75,37.92 131.08,37.6 134.23,37.6 135.06,38.44 137.66,38.44 137.71,38.38 137.71,33.36 137.55,33.2 ; 1 cut-out
19V_DCBATOUT on BOTTOM: 78.89,86.8 78.81,86.89 73.27,86.89 72.65,87.52 72.65,88.2 72.94,88.5 79.54,88.5 79.77,88.27 79.77,86.95 79.62,86.8 ; 5 cut-outs
19V_DCBATOUT on BOTTOM: 129.05,82.07 128.69,82.43 128.69,83.13 128.88,83.33 131.65,83.33 131.8,83.17 131.8,82.33 131.54,82.07
19V_DCBATOUT on BOTTOM: 127.84,9.9 126.95,10.79 126.95,12.95 126.3,13.6 126.31,13.61 126.31,16.55 126.92,17.16 126.92,18.51 127.25,18.83 128.21,18.83 128.41,18.62 128.41,18.29 128.39,18.27 128.39,16.48 128.41,16.46 128.41,15.34 128.47,15.28 128.47,13.48 129.6,12.35 131.33,12.35 132.85,10.82 132.85,10.02 132.74,9.9
19V_DCBATOUT on BOTTOM: 96.42,85.71 95.3,86.83 95.29,86.83 95.15,86.97 95.15,87.16 95.18,87.19 95.53,87.19 95.62,87.28 95.97,87.28 96.54,87.85 101.38,87.85 101.7,87.52 101.7,86.98 101.52,86.79 100.92,86.79 100.84,86.71 100.84,86.3 100.77,86.24 99.01,86.24 98.49,85.71 ; 1 cut-out
19V_DCBATOUT on BOTTOM: 186.19,33.33 186.09,33.43 186.09,34.09 185.92,34.27 185.51,34.27 185.38,34.4 185.38,37.44 185.69,37.75 186.6,37.75 186.73,37.62 186.73,33.46 186.6,33.33
19V_DCBATOUT on BOTTOM: 38.67,57.28 38.34,57.61 36.92,57.61 36.66,57.87 36.66,59.95 36.87,60.15 37.75,60.15 38.04,59.87 38.04,59.26 38.8,58.5 39.79,58.5 39.94,58.35 39.94,58.04 40.09,57.89 40.45,57.89 40.53,57.82 40.53,57.51 40.3,57.28 ; 2 cut-outs
19V_DCBATOUT on BOTTOM: 80.73,2.22 80.26,2.68 80.26,3.95 80.57,4.26 80.57,4.69 80.57,4.69 80.57,6.19 80.23,6.53 80.23,7.47 80.02,7.68 79.41,7.68 78.5,6.76 77.18,6.76 77.1,6.84 77.1,7.88 77.61,8.39 77.61,12.37 78.12,12.88 80.58,12.88 83.52,9.95 83.52,8.2 83.53,8.18 83.53,5.31 83.96,4.88 85.64,4.88 86.42,5.67 87.69,5.67 87.87,5.49 87.87,4.45 88.2,4.12 89.47,4.12 89.75,3.84 89.75,3.1 89.37,2.72 83.52,2.72 83.02,2.22 ; 10 cut-outs
19V_DCBATOUT on BOTTOM: 154.36,32.55 154.32,32.59 152.16,32.59 152.02,32.72 152.02,33.02 152.13,33.13 152.13,37.27 152.11,37.29 152.11,38.26 152.23,38.38 152.95,38.38 153.2,38.13 153.2,37.37 153.48,37.09 156.22,37.09 156.85,36.46 156.85,32.82 156.58,32.55
19V_DCBATOUT on L2GND: 105.59,13.69 105.59,13.88 106.67,14.96 112.63,14.96 112.97,14.62 112.97,12.64 112.15,11.82 108.54,11.82 98.6,1.88 81.56,1.88 80.69,2.75 80.69,3.96 81.81,5.08 88.67,5.08 89.57,5.97 97.88,5.97
19V_DCBATOUT on L5: 134.3,38.31 135.72,38.31 136.55,37.48 136.55,35.1 138.52,33.13 148.48,33.13 149.32,33.97 153.88,33.97 154.42,34.51 154.42,36.4 154.37,36.45 154.37,36.94 154.7,37.27 156.3,37.27 156.73,36.84 156.73,31.96 156.35,31.58 135.04,31.58 134.05,32.57 134.05,38.05
19V_DCBATOUT on L5: 128.08,85.93 136.74,77.27 136.74,67.62 139.59,64.77 139.59,59.6 138.43,58.44 136.25,58.44 135.23,59.45 135.23,59.45 135.03,59.66 135.03,59.82 135.01,59.82 133.41,61.42 132.75,61.42 128.41,65.77 128.41,65.82 128.03,66.2 128.03,70.69 129.1,71.76 129.1,75.69 125.33,79.46 105.68,79.46 105.65,79.48 105.37,79.48 104.66,80.19 72.61,80.19 72.05,80.75 66.44,80.75 66.18,80.49 66.18,79.19 65.4,78.41 63.34,78.41 62.93,78.82 62.93,78.87 61.92,79.88 61.92,82.15 63.82,84.05 63.82,87.01 64.61,87.8 107.18,87.8 109.04,85.93
19V_DCBATOUT on L6: 129.09,11.05 130.96,11.05 130.96,11.05 131.32,11.41 131.32,12.51 131.16,12.66 129.91,12.66 128.31,14.26 121.6,14.26 120.82,13.48 115.84,13.48 115.54,13.78 115.5,13.78 114.9,14.38 112.63,14.38 112.54,14.47 110.79,14.47 110.79,14.44 109.84,13.5 109.84,10.61 109.85,10.61 109.97,10.5 116.39,10.5 117.1,9.79 121.65,9.79 122.9,11.03 122.9,11.03 122.99,11.12 126.56,11.12 126.65,11.03 127.55,11.03 127.56,11.02 129.06,11.02
19V_DCBATOUT_LCD on TOP: 38.37,76 38.19,76.18 38.19,77.4 38.52,77.73 38.52,79.71 38.39,79.84 38.39,80.24 38.24,80.4 37.93,80.4 37.76,80.57 37.76,80.93 37.87,81.04 38.99,81.04 39.2,80.83 39.2,80.7 39.33,80.57 39.76,80.57 39.97,80.37 39.97,77.2 38.77,76
19V_DCBATOUT_LCD on BOTTOM: 38.38,68.76 38.37,68.78 37.34,68.78 37.21,68.91 37.21,69.69 36.74,70.16 36.45,70.16 36.41,70.2 36.41,73.59 36.92,73.59 38.19,74.86 38.19,77.4 38.44,77.65 40.4,77.65 40.45,77.6 40.45,77.17 40.22,76.94 40.22,75.7 39.97,75.44 39.97,73.84 38.82,72.7 38.82,70.29 38.46,69.92 38.46,68.84 ; 2 cut-outs
19V_DCBATOUT_LCD on BOTTOM: 38.6,78.49 38.44,78.64 38.44,80.95 38.6,81.11 39.59,81.11 39.97,80.73 39.97,79.51 39.69,79.23 39.69,78.54 39.64,78.49
20V_VCCPD_VBUS on TOP: 24.12,70.24 23.76,70.59 23.76,71.53 23.94,71.71 23.94,73.46 23.99,73.51 24.24,73.51 24.32,73.44 24.32,72.19 24.47,72.04 25.01,72.04 25.2,72.23 25.2,72.57 25.56,72.94 26.62,72.94 26.82,72.74 26.82,70.27 26.78,70.24 ; 3 cut-outs
20V_VCCPD_VBUS on BOTTOM: 13.78,29.29 13.45,29.62 13.45,30.08 10.76,30.08 10.68,30.15 10.68,32.16 12.69,34.17 12.69,35.31 13.04,35.67 13.37,35.67 13.68,35.97 13.68,36.43 13.83,36.58 14.77,36.58 14.77,35.67 13.83,34.73 13.83,33.58 13.58,33.33 13.58,33.05 13.73,32.9 14.06,32.9 14.64,33.48 15.63,33.48 15.71,33.41 15.71,31.93 15.58,31.93 15.13,31.48 15.13,29.55 14.87,29.29 ; 4 cut-outs
20V_VCCPD_VBUS on BOTTOM: 19.29,56.53 18.35,57.47 18.35,58.31 18.54,58.5 21.61,58.5 21.74,58.37 21.74,57.59 20.68,56.53
20V_VCCPD_VBUS on L5: 26.61,73.03 26.82,72.82 26.82,69.74 26.38,69.3 23.36,69.3 23.33,69.27 21.07,69.27 17.49,65.69 17.49,60.38 19.77,58.09 20.15,58.09 20.54,57.71 20.54,56.57 20.37,56.41 20.19,56.41 19.5,55.72 19.5,51.62 17.49,49.61 17.49,48.72 14.17,45.4 14.17,40.7 14.85,40.02 14.85,32.64 13.7,31.5 8.92,31.5 8.78,31.36 7.57,31.36 7.32,31.61 7.32,35.33 7.47,35.48 8.57,35.48 10.24,37.15 10.24,37.74 9.63,38.35 9.63,47.28 13.74,51.39 13.74,66.38 15.02,67.65 15.02,69.05 18.99,73.03
20V_VCCPD_VBUS on L8: 7.46,34.76 8.11,34.76 11.22,31.65 13.29,31.65 13.42,31.52 13.42,30.71 12.45,29.73 9.62,29.73 7.91,31.45 7.4,31.45 7.3,31.55 7.3,34.6
20V_VCCPD_VBUS_L on BOTTOM: 18.63,58.73 18.12,59.24 18.12,59.87 18.38,60.13 20.52,60.13 21.78,61.39 24.09,61.39 24.37,61.11 24.37,60.93 24.4,60.91 24.67,60.91 24.85,60.73 24.85,60.47 24.73,60.35 24.41,60.35 24.29,60.23 24.29,60.06 24.23,59.99 23.58,59.99 23.2,59.62 23.2,59.11 22.82,58.73 ; 1 cut-out
+3V_1D8V_AVDD on TOP: 184.52,18.75 184.4,18.87 184.4,19.03 184.89,19.52 184.89,19.74 185.13,19.98 186.15,19.98 186.35,20.19 187.33,20.19 187.46,20.06 187.46,19.38 187.24,19.15 186.16,19.15 186.15,19.16 185.48,19.16 185.07,18.75 ; 2 cut-outs
+3V_1D8V_DVDD on TOP: 178.64,17.46 177.87,18.23 177.69,18.23 177.68,18.22 177.46,18.44 177.46,18.82 176.86,19.43 176.86,20.76 176.95,20.86 177.38,20.86 177.5,20.74 177.5,20.35 177.85,20.01 178.06,20.01 178.3,19.77 178.3,19.35 179.46,18.19 179.56,18.19 180.09,17.66 180.09,17.53 180.03,17.46 ; 2 cut-outs
+3V_1D8V_DVDD on TOP: 173.94,10.93 173.15,11.72 173.15,12.23 172.92,12.46 172.92,13.2 173.13,13.41 173.83,13.41 174.09,13.15 174.09,12.28 174.34,12.03 178,12.03 178.52,12.55 178.63,12.55 178.93,12.84 179.7,12.84 179.85,12.7 179.85,12.28 179.48,11.91 179.48,11.89 178.51,10.93 ; 6 cut-outs
+5V_PVDD on TOP: 180.24,18.58 180.13,18.69 180.13,20.31 180.25,20.43 180.25,21.13 180.17,21.21 180.17,22.58 180.4,22.81 183.64,22.81 184.21,22.25 184.71,22.25 185.09,21.87 185.09,21.49 184.5,20.9 184.5,20.11 184.59,20.02 184.59,19.34 184.13,18.88 183.88,18.88 183.81,18.95 183.81,19.26 184.03,19.47 184.03,20.08 183.78,20.32 183.78,21.65 183.68,21.75 182.98,21.75 181.81,20.58 181.81,19.78 181.61,19.58 180.88,19.58 180.73,19.44 180.73,18.71 180.61,18.58 ; 5 cut-outs
DV12S on BOTTOM: 7.98,15.39 7.89,15.49 7.89,16.93 7.64,17.18 7.64,17.6 7.72,17.69 8.32,17.69 8.34,17.67 8.34,16.99 8.23,16.87 8.23,16.01 8.23,15.46 8.16,15.39
DV3318_ANA_CORE on BOTTOM: 2.26,8.36 1.87,8.75 1.87,10.01 1.97,10.11 2.26,10.11 3.11,9.27 3.86,9.27 6,11.4 6,11.84 6.03,11.87 6.03,12.47 6.08,12.52 6.56,12.52 6.57,12.51 6.57,11.01 4.18,8.62 3.46,8.62 3.2,8.36 ; 1 cut-out
DV3318_HOST on BOTTOM: 5.85,13.84 4.26,15.43 3.77,15.43 3.62,15.57 3.62,16.1 3.7,16.18 4.16,16.18 4.34,16 4.65,16 4.74,15.91 4.74,15.42 4.8,15.36 5.33,15.36 5.36,15.32 5.36,14.83 5.86,14.32 5.86,14.17 5.9,14.12 6.6,14.12 6.64,14.08 6.64,13.91 6.57,13.84
DV3318_S_PAD on BOTTOM: 7.31,7.7 7.22,7.79 6.19,7.79 6.12,7.85 6.12,9.59 7.89,11.36 7.89,11.89 7.97,11.97 7.97,12.11 7.96,12.11 7.96,12.14 7.99,12.17 8.15,12.17 8.17,12.15 8.17,12.02 8.28,11.91 8.28,10.69 7.14,9.56 7.14,8.67 7.37,8.44 7.79,8.44 7.88,8.35 7.88,7.79 7.79,7.7 ; 1 cut-out
GND on TOP: 120.21,20 119.38,20.82 118.77,20.82 117.56,22.03 115.43,22.03 115.1,22.36 115.1,23.23 115.71,23.83 115.71,24.96 115.58,25.09 115.58,25.59 115.84,25.84 115.84,29.35 115.44,29.74 115.17,29.74 115.01,29.91 115.01,32.73 115.09,32.81 115.63,32.81 115.87,32.56 115.87,29.85 116.37,29.35 118.06,29.35 118.54,28.87 118.54,28.19 118.69,28.05 119.46,28.05 120.16,27.34 120.16,25.91 120.77,25.3 120.77,24.94 120.67,24.84 120.38,24.84 119.45,25.78 118.78,25.78 118.53,25.53 118.53,25.19 117.77,24.42 117.66,24.42 117.39,24.16 117.39,23.01 118.71,21.69 118.71,21.42 118.82,21.31 119.76,21.31 120.37,20.7 121.1,20.7 121.31,20.49 121.31,20.18 121.12,20 ; 7 cut-outs
GND on TOP: 127.11,61.56 127.03,61.64 127.03,61.95 127.1,62.02 127.98,62.02 128.59,62.64 128.9,62.64 129.02,62.52 129.02,62.23 128.85,62.05 128.61,62.05 128.12,61.56
GND on TOP: outline of 162 points within 146.88,55.93 163.27,79.73 ; 32 cut-outs
GND on TOP: 97.12,25.71 96.99,25.84 96.99,29.27 97.12,29.39 99.66,29.39 99.78,29.27 99.78,25.84 99.66,25.71 ; 6 cut-outs
GND on TOP: 157.06,35.32 156.83,35.55 156.83,37.09 156.98,37.24 163.69,37.24 163.92,37.01 163.92,36.53 162.73,35.34 157.77,35.34 157.76,35.32 ; 8 cut-outs
GND on TOP: 104.68,52.81 104.55,52.93 104.55,55.09 104.68,55.22 104.93,55.22 105.06,55.35 105.06,55.85 104.93,55.98 100.11,55.98 99.91,56.18 99.91,56.42 100.11,56.62 101.76,56.62 102.01,56.87 103.41,56.87 103.66,56.62 105.44,56.62 105.57,56.49 105.57,54.2 105.82,53.95 106.59,53.95 106.71,54.08 106.97,54.08 107.09,53.95 107.09,53.57 106.71,53.19 105.44,53.19 105.06,52.81 ; 1 cut-out
GND on TOP: 98.64,16.69 98.51,16.82 98.51,17.33 98.89,17.71 98.89,20.25 99.53,20.88 100.42,20.88 100.55,20.76 100.55,18.47 100.42,18.35 100.42,16.8 100.31,16.69 ; 7 cut-outs
GND on TOP: 141.24,23.53 140.6,24.17 140.6,24.65 140.7,24.76 141.22,24.76 141.5,24.47 142.23,24.47 142.28,24.43 142.28,23.83 141.97,23.53 ; 2 cut-outs
GND on TOP: 134.35,14.4 134.24,14.51 134.24,19.04 134.6,19.41 136.38,19.41 136.74,19.77 136.74,20.27 137.59,21.11 138.61,21.11 138.88,20.84 138.88,19.72 137.73,18.57 137.73,14.67 137.46,14.4 ; 1 cut-out
GND on TOP: 78.83,25.96 78.57,26.22 78.57,28.88 78.7,29.01 81.24,29.01 81.37,28.88 81.37,26.09 81.24,25.96 ; 6 cut-outs
GND on TOP: outline of 119 points within 46.37,24.35 55.89,31.23
GND on TOP: 59.52,29.27 59.4,29.39 59.4,30.92 59.52,31.04 61.81,31.04 61.94,30.92 61.94,29.39 61.81,29.27 ; 4 cut-outs
GND on TOP: 41.44,44.12 41.06,44.5 41.06,44.91 41.29,45.14 42.02,45.14 42.38,45.49 42.38,45.78 42.63,46.03 44.92,46.03 45.17,45.78 45.17,44.76 44.54,44.12 ; 4 cut-outs
GND on TOP: 42.51,49.46 41.74,50.22 41.74,50.98 41.62,51.11 41.11,51.11 40.98,51.24 40.98,53.14 41.62,53.78 41.62,57.08 42,57.46 44.79,57.46 45.68,56.57 46.82,56.57 47.04,56.79 48.79,56.79 48.97,56.6 48.97,55.2 48.94,55.17 48.41,55.17 48.15,55.42 48.15,55.7 48.1,55.74 47.63,55.74 47.21,55.32 47.21,53.65 46.82,53.27 44.67,53.27 44.41,53.52 43.52,53.52 43.14,53.14 43.14,49.71 42.89,49.46 ; 6 cut-outs
GND on TOP: 93.38,51.6 93.22,51.76 93.22,58.76 93.35,58.89 93.52,58.89 93.53,58.88 93.58,58.88 93.76,59.07 93.76,59.51 93.32,59.95 93.32,60.66 92.96,61.02 92.96,63.58 92.8,63.74 92.69,63.74 92.53,63.9 92.53,64.23 92.64,64.35 92.8,64.35 93.25,64.8 93.69,64.8 93.93,64.56 93.93,64.05 94.43,64.05 94.75,64.37 94.98,64.37 95.14,64.22 95.14,63.82 94.7,63.39 94.1,63.39 94,63.29 94,62.23 94.13,62.1 94.13,61.78 94.87,61.04 94.87,60.2 94.98,60.1 95.5,60.1 95.62,59.98 95.62,59.24 95.81,59.05 95.81,58.29 95.88,58.22 95.88,51.71 95.77,51.6 ; 21 cut-outs
GND on TOP: 116.36,3.95 116.26,4.04 116.26,5.88 116.01,6.13 116.01,6.78 116.34,7.11 116.34,9.39 116.22,9.51 116.22,10.21 116.25,10.25 116.95,10.25 117.06,10.14 117.06,5.8 117.51,5.34 117.51,4.51 117.51,4.51 117.51,4.16 117.29,3.95
GND on TOP: 87.41,51.54 87.28,51.66 87.28,58.77 87.41,58.9 89.62,58.9 89.99,58.53 89.99,51.69 89.83,51.54 ; 16 cut-outs
GND on TOP: 37.5,72.98 37.43,73.06 37.43,75.11 37.68,75.37 38.37,75.37 41.01,78.01 41.01,78.14 41.02,78.14 41.02,79.65 41.06,79.68 42.35,79.68 42.41,79.63 42.41,79.51 42.56,79.35 42.56,78.24 43.27,77.53 43.27,77.14 43.17,77.04 41.82,77.04 39.69,74.91 39.69,74.12 39.64,74.07 39.64,73.03 39.59,72.98 ; 4 cut-outs
