# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A2: length 44.5
  TOP w0.152: RAM3.N2 91.78,20.87 91.88,20.77 v3(91.88,20.38) 91.88,18.93 92.63,18.19 RN1301.8
  L8 w0.114: v3(81.57,36.53) 80.82,35.78 80.82,25.29 83.39,22.72 83.39,22.71 83.62,22.48 89.06,22.48 89.46,22.09 89.46,21.35 90.44,20.37 90.44,19.33 90.8,18.96 91.17,18.96 91.29,19.07 91.29,19.42 91.4,19.53 91.63,19.53 91.74,19.42 91.74,19.07 91.86,18.96 93.91,18.96 94.14,19.19 94.14,19.73 94.02,19.85 92.08,19.85 91.88,20.04 v3(91.88,20.38)
  BOTTOM w0.076: 81,38.53 81,40 81.63,40.63 81.63,41.64 82.05,42.06 82.05,42.79 CPU1.AE37
  BOTTOM w0.152: 81,38.53 81.04,38.48 81.04,36.49 81.14,36.39 81.43,36.39 v3(81.57,36.53)
M_B_A3: length 44.3
  TOP w0.089: 92.23,20.6 92.12,20.71 v3(92.12,21.28)
  TOP w0.152: 92.23,20.6 92.29,20.54 92.29,20.12 93.21,19.2 RN1301.7 ; RAM3.N3 91.78,21.67 92.12,21.33 92.12,21.29 v3(92.12,21.28)
  L8 w0.114: v3(92.12,21.28) 92.2,21.28 92.84,21.91 92.84,23.69 93.05,23.91 93.05,24.19 92.93,24.3 89.41,24.3 89.12,24.01 89.12,22.97 89.04,22.89 88.79,22.89 88.68,22.99 88.68,24.06 88.44,24.3 84.08,24.3 83.92,24.15 83.92,23.64 83.71,23.42 83.38,23.42 82.55,24.25 82.55,24.42 82.71,24.58 82.71,24.74 82.52,24.93 82.36,24.93 82.2,24.77 82.03,24.77 81.74,25.06 81.74,25.22 81.9,25.37 81.9,25.54 81.74,25.7 81.58,25.7 81.5,25.62 81.33,25.62 81.19,25.76 81.19,34.9 v3(81.57,35.28)
  BOTTOM w0.076: 80.79,36.82 80.79,40.08 81.15,40.44 81.46,41.7 81.67,41.91 81.77,42.08 81.77,42.66 81.69,42.73 81.69,43.03 81.95,43.5 CPU1.AE36
  BOTTOM w0.152: v3(81.57,35.28) 81.15,35.71 80.79,36.41 80.79,36.82
M_B_A4: length 45.3
  TOP w0.076: v3(91.48,21.27) 91.48,20.54 91.5,20.52 91.5,19.89 91.38,19.78
  TOP w0.152: R1306.2 91.67,17.99 91.27,18.39 91.27,19.66 91.38,19.78 ; v3(91.48,21.27) 91.48,21.32 RAM3.M3
  L6 w0.152: v3(80.57,47.63) 81.01,47.2 81.01,44.43 82.67,40.98 82.86,40.51 82.86,36.39 83.32,35.92 83.32,35.02 86.21,32.14 88.08,32.14 94.15,30.71 95.67,29.19 95.67,22.27 94.24,20.83 91.91,20.83 v3(91.48,21.27)
  BOTTOM w0.152: v3(80.57,47.63) 80.67,47.63 CPU1.AC29
M_B_A5: length 41.9
  TOP w0.102: 87.1,19.86 87.1,20.46 86.93,20.64 86.93,21.26 v3(86.94,21.27)
  TOP w0.152: 87.1,19.86 87.11,19.86 87.11,17.38 87.38,17.11 R1305.2 ; RAM3.F3 87.23,21.63 86.94,21.33 v3(86.94,21.27)
  L8 w0.114: v3(77.79,48.17) 77.83,48.17 78.27,47.73 78.27,45.6 78.81,45.06 78.89,45.06 79.19,44.76 79.19,37.52 79.18,37.52 79.18,37.18 79.19,37.17 79.19,37.13 78.8,36.74 78.8,30.75 77.77,29.73 77.77,26.25 84.03,19.99 86.81,19.99 87.03,20.22 87.03,21.17 v3(86.94,21.27)
  BOTTOM w0.152: v3(77.79,48.17) 77.79,48.16 77.8,48.11 CPU1.W29
M_B_A6: length 44.5
  TOP w0.102: 86.26,19.7 v3(86.26,21.26)
  TOP w0.152: RAM3.E3 86.58,21.67 86.26,21.34 v3(86.26,21.26) ; 86.26,19.7 86.26,18.69 85.87,18.31 RN1302.4
  L6 w0.152: v3(79.67,48.21) 79.66,48.21 79.24,47.8 79.24,46.68 79.2,46.63 79.2,45.24 79.36,45.08 79.36,42.65 82,40.01 82,35.77 82.21,35.56 82.21,23.47 82.36,23.32 83.59,23.32 83.74,23.17 83.74,22.86 83.59,22.71 81.85,22.71 81.62,22.47 81.62,19.87 81.88,19.61 84.45,19.61 84.7,19.85 84.7,20.64 84.89,20.83 85.83,20.83 v3(86.26,21.26)
  BOTTOM w0.152: CPU1.AB28 v3(79.67,48.21)
M_B_A7: length 43.9
  TOP w0.152: RN1302.3 86.52,17.03 86.65,17.15 v3(86.65,20.38) 86.64,20.38 86.64,20.81 86.58,20.87 RAM3.E2
  L8 w0.114: v3(86.65,20.38) 86.19,20.84 84.23,20.84 79.53,25.53 79.53,29.34 79.65,29.46 79.95,29.46 80.07,29.57 80.07,29.8 79.95,29.91 79.65,29.91 79.53,30.03 79.53,30.26 79.65,30.37 79.95,30.37 80.07,30.48 80.07,30.71 79.95,30.83 79.65,30.83 79.53,30.94 79.53,31.17 79.65,31.28 79.95,31.28 80.07,31.4 80.07,31.63 79.95,31.74 79.65,31.74 79.53,31.86 79.53,36.08 80.62,37.17 80.62,41.71 80.17,42.17 80.17,43.53 80.29,43.64 81.51,43.64 81.62,43.75 81.62,43.98 81.51,44.1 80.29,44.1 80.14,44.24 80.14,44.99 80.26,45.11 80.86,45.11 80.97,45.22 80.97,45.45 80.86,45.56 80.26,45.56 80.14,45.68 80.14,47.78 v3(80.58,48.21)
  BOTTOM w0.152: v3(80.58,48.21) 80.85,48.15 80.97,48.22 CPU1.AC28
M_B_A8: length 41.4
  TOP w0.152: RAM3.D2 85.93,20.87 85.93,20.7 85.68,20.45 85.68,20.42 v3(85.66,20.4) 85.66,18.48 85,17.82 RN1306.3
  L8 w0.114: v3(77.82,48.85) 78.22,49.25 78.57,49.25 78.59,49.26 78.93,49.26 78.94,49.25 79.01,49.25 79.24,49.02 79.24,48.24 79.13,48.13 78.81,48.13 78.7,48.02 78.7,47.79 78.81,47.67 79.13,47.67 79.24,47.56 79.24,45.26 79.44,45.06 79.44,42.36 80.26,41.54 80.26,37.43 79.17,36.34 79.17,30.6 78.14,29.57 78.14,26.41 84.15,20.4 v3(85.66,20.4)
  BOTTOM w0.089: CPU1.W28 78.2,48.49 77.86,48.83 v3(77.82,48.85)
M_B_A9: length 43.5
  TOP w0.152: v3(85.58,21.26) 85.28,20.96 RAM3.C2 85.11,20.7 85.11,19.66 84.35,18.89 RN1306.4
  L8 w0.114: v3(85.58,21.26) 85.18,21.67 83.92,21.67 80.45,25.14 80.45,32 79.9,32.54 79.9,32.93 80.02,33.04 80.33,33.04 80.45,33.16 80.45,33.39 80.33,33.5 80.02,33.5 79.9,33.61 79.9,33.84 80.02,33.96 80.33,33.96 80.45,34.07 80.45,34.3 80.33,34.41 80.02,34.41 79.9,34.53 79.9,34.76 80.02,34.87 80.33,34.87 80.45,34.99 80.45,35.21 80.33,35.33 80.02,35.33 79.9,35.44 79.9,35.81 80.45,36.36 80.45,36.39 80.99,36.93 80.99,42.58 81.99,43.57 81.99,47.08 81.87,47.2 81.36,47.2 81.25,47.31 81.25,47.54 81.36,47.65 81.87,47.65 81.99,47.77 81.99,49.02 81.68,49.33 80.41,49.33 80.39,49.31 80.13,49.31 v3(79.67,48.85)
  BOTTOM w0.152: CPU1.Y28 v3(79.67,48.85)
M_B_B0: length 53.6
  TOP w0.127: v3(111.95,20.42) 111.95,19.58 113.44,18.08 RN1307.3
  TOP w0.152: v3(111.95,20.42) 112.26,20.87 RAM4.R2
  L5 w0.152: v3(84.79,40.68) 85.22,41.11 85.22,41.85 85.5,42.13 85.92,42.13 86.12,41.93 87.29,41.93 87.97,41.25 87.97,37.26 88.85,36.38 88.85,35.49 88.85,35.31 89.56,34.6 93.27,34.6 94.58,33.29 96.61,33.29 98.71,31.18 98.71,30.97 98.63,30.89 98.63,30.67 98.85,30.46 99.06,30.46 99.14,30.54 99.36,30.54 99.58,30.32 99.58,30.11 99.49,30.02 99.49,29.81 99.71,29.59 99.92,29.59 100.01,29.67 100.22,29.67 100.77,29.13 100.77,24.16 102.25,22.69 102.91,22.69 103.14,22.46 107.55,22.46 107.81,22.2 107.81,20.71 107.95,20.57 107.95,20.42 108.44,19.94 111.47,19.94 v3(111.95,20.42)
  BOTTOM w0.076: v3(84.79,40.68) 84.35,41.12 84.35,41.92 84.88,42.45 84.88,43.04 84.86,43.11 84.86,43.34 84.9,43.42 84.9,43.55 CPU1.AK35
M_B_B1: length 56.6
  TOP w0.127: RAM4.P2 111.51,20.77 111.51,19.16 112.79,17.87 RN1307.4
  TOP w0.152: v3(111.95,21.28) 111.61,20.87 RAM4.P2
  L5 w0.152: v3(84.79,39.41) 84.18,40.02 84.18,41.37 85.58,42.77 86.75,42.77 87,42.74 87.02,42.73 88.75,41.01 89.46,39.7 89.46,35.57 89.81,35.21 93.52,35.21 94.83,33.9 96.86,33.9 101.38,29.38 101.38,24.42 102.25,23.55 102.26,23.55 102.54,23.27 107.55,23.27 107.84,22.99 107.84,22.62 108.05,22.4 108.05,21.8 108.99,20.86 111.52,20.86 v3(111.95,21.28)
  BOTTOM w0.076: v3(84.79,39.41) 84.25,39.95 84.25,40.98 84.18,41.05 84.18,41.98 84.72,42.52 84.72,43.02 84.7,43.08 84.7,43.38 84.73,43.47 84.73,43.64 84.74,43.84 CPU1.AK34
M_B_B2: length 53.8
  TOP w0.127: RAM4.N2 111.13,20.69 111.13,17.74 111.59,17.29 R1308.2
  TOP w0.152: RAM4.N2 110.96,20.87 v3(111.26,21.28)
  L5 w0.152: v3(111.26,21.28) 110.87,21.67 108.9,21.67 108.89,21.67 108.55,21.67 108.29,21.92 108.29,22.5 108.28,22.51 108.28,23.38 107.5,24.16 102.5,24.16 101.99,24.67 101.99,29.63 97.11,34.51 95.09,34.51 93.28,36.32 91.41,36.32 90.46,37.26 90.46,40.71 90.16,41.01 89.56,41.01 89.5,41.13 87.81,42.81 87.51,42.89 87.46,42.9 87.17,42.97 86.76,43.01 84.66,43.01 84.58,42.95 82.83,41.21 82.83,40.84 v3(83.27,40.4)
  BOTTOM w0.076: v3(83.27,40.4) 83.69,40.81 83.69,42.19 84.02,42.53 84.02,43.03 84.15,43.25 84.15,43.88 CPU1.AJ35
M_B_B3: length 53.8
  TOP w0.127: RN1303.3 110.72,17.03 110.72,20.1 110.81,20.2 110.81,20.57 110.63,20.75 v3(110.63,21.27)
  TOP w0.152: RAM4.N3 110.96,21.67 110.63,21.34 v3(110.63,21.27)
  L6 w0.152: v3(110.63,21.27) 110.63,21.28 110.6,21.28 110.2,21.67 108.9,21.67 108.83,21.6 108.46,21.6 108.04,22.02 108.04,23.86 107.54,24.35 102.79,24.35 99.89,27.25 99.89,28.14 96.34,31.69 96.34,31.91 96.84,32.4 96.84,32.62 96.62,32.83 96.41,32.83 95.8,32.22 95.58,32.22 95.37,32.44 95.37,32.65 96.52,33.8 96.52,34.08 96.27,34.33 95.98,34.33 95.2,33.55 94.57,33.55 93.87,34.25 86.68,34.25 85.22,35.71 85.22,38.34 v3(84.79,38.77)
  BOTTOM w0.076: 85.17,39.6 85.17,42.11 85.18,42.12 85.18,42.16 85.31,42.29 85.34,42.35 85.34,43.02 85.37,43.11 85.37,43.33 85.35,43.39 85.35,43.69 85.4,43.83 85.4,44.4 85.4,44.64 85.19,44.84 CPU1.AJ34
  BOTTOM w0.152: v3(84.79,38.77) 85.28,38.77 85.38,38.88 85.38,39.25 85.2,39.44 85.2,39.58 85.17,39.6
M_B_B4: length 53.4
  TOP w0.127: RN1303.4 110.03,17.58 109.83,17.78 109.83,20.05 109.99,20.21 109.99,20.23 109.99,20.23 109.99,21.27 v3(109.99,21.27)
  TOP w0.152: v3(109.99,21.27) 109.99,21.35 110.31,21.67 RAM4.M3
  L6 w0.152: v3(83.27,36.56) 83.93,35.89 83.93,35.28 86.29,32.92 92.51,32.92 93.09,32.65 96.99,28.76 96.99,22.84 98.13,21.7 98.13,21.47 99.6,19.99 103.85,19.99 104.05,19.79 106.37,19.79 106.52,19.85 107.11,20.44 107.11,20.58 107.37,20.83 109.56,20.83 v3(109.99,21.27)
  BOTTOM w0.076: CPU1.AJ37 84.47,42.5 84.02,42.05 84.02,40.98 84.09,40.91 84.09,39.75
  BOTTOM w0.152: 84.09,39.75 84.09,38.2 84.56,37.72 84.84,37.72 85.08,37.49 85.08,36.47 84.98,36.37 84.57,36.37 84.47,36.47 84.47,36.94 84.37,37.04 83.96,37.04 83.86,36.94 83.86,36.49 83.76,36.38 83.44,36.38 v3(83.27,36.56)
M_B_B5: length 56.7
  TOP w0.127: 106.66,19.61 106.8,19.75 106.8,20.51 106.74,20.57 v3(106.74,21.29)
  TOP w0.14: RAM4.F3 106.41,21.67 106.41,21.62 v3(106.74,21.29)
  TOP w0.152: R1307.2 106.01,17.01 106.01,18.95 106.66,19.61
  L5 w0.152: v3(106.74,21.29) 107.05,20.98 107.05,19.5 106.76,19.21 106.07,19.21 105.82,19.46 105.82,20.42 105.61,20.63 104.96,20.63 104.7,20.37 104.7,20.12 104.25,19.67 99.68,19.67 99.27,20.07 98.72,20.07 98.32,19.67 95.72,19.67 95.07,20.32 95.07,22.32 95.24,22.49 95.24,23.19 94.14,24.29 94.14,25.37 94.48,25.71 94.48,27.05 94.22,27.31 93.83,27.31 93.76,27.23 92.56,27.23 92.48,27.31 91.93,27.31 91.84,27.22 90.66,27.22 90.39,27.49 90.39,29.88 89.65,30.61 88.26,30.61 87.93,30.94 87.41,30.94 86.59,31.76 85.21,31.76 83.1,33.87 83.1,35.89 82.69,36.3 82.69,37.36 v3(81.57,38.49)
  BOTTOM w0.076: v3(81.57,38.49) 81.39,38.49 81.2,38.67 81.2,39.97 81.8,40.57 81.8,41.57 82.31,42.08 82.31,44.11 82.38,44.3 CPU1.AF34
M_B_B6: length 55.7
  TOP w0.127: 105.38,19.56 105.52,19.7 105.52,20.41 105.44,20.49 v3(105.44,21.29)
  TOP w0.152: v3(105.44,21.29) 105.44,21.34 105.76,21.67 RAM4.E3 ; 105.38,19.56 104.44,18.61 104.44,17.72 104.49,17.66 RN1308.4
  L6 w0.152: v3(105.44,21.29) 105.44,21.25 104.87,20.68 104.48,20.68 104.46,20.7 104.1,20.7 104.08,20.68 102.65,20.68 102.44,20.89 102.44,21.9 102.29,22.05 101.98,22.05 101.83,21.9 101.83,20.83 101.68,20.68 101.37,20.68 101.22,20.83 101.22,21.87 101.07,22.03 100.76,22.03 100.61,21.87 100.61,20.93 100.4,20.71 99.85,20.71 99.5,21.06 99.5,21.32 97.6,23.22 97.6,23.76 97.75,23.92 98.97,23.92 99.13,24.07 99.13,24.37 98.97,24.53 97.78,24.53 97.62,24.68 97.62,24.98 97.78,25.14 98.97,25.14 99.13,25.29 99.13,25.59 98.97,25.75 97.75,25.75 97.6,25.9 97.6,29.01 93.02,33.59 86.48,33.59 84.57,35.5 84.57,36.57 v3(83.28,37.86)
  BOTTOM w0.076: 83.85,40.41 83.85,42.12 84.19,42.46 84.19,42.99 84.47,43.49 CPU1.AJ36
  BOTTOM w0.152: v3(83.28,37.86) 83.47,37.66 83.74,37.66 83.85,37.77 83.85,39.85 83.85,39.86 83.85,40.41
M_B_B7: length 54.2
  TOP w0.127: 105.78,19.3 105.78,20.51 105.76,20.53 RAM4.E2
  TOP w0.152: RN1308.3 105.14,17.07 105.1,17.11 105.1,18.62 105.78,19.3 ; v3(106.08,21.29) 106.08,21.19 RAM4.E2
  L5 w0.152: v3(106.08,21.29) 106.08,21.02 105.92,20.87 104.86,20.87 104.84,20.85 103.68,20.85 103.51,21.02 103.51,21.94 103.36,22.09 102.89,22.09 102.69,21.89 102.69,21.22 102.37,20.89 100.23,20.89 99.81,21.31 99.15,21.31 99,21.46 99,22.12 98.66,22.45 98.45,22.45 97.84,21.84 97.63,21.84 97.41,22.06 97.41,22.28 98.01,22.87 98.01,23.11 97.79,23.33 97.58,23.33 96.87,22.62 96.65,22.62 96.47,22.8 96.47,23.09 97.15,23.76 97.15,23.97 96.07,25.04 96.07,29.36 94.94,30.5 94.27,30.5 94.25,30.51 93.89,30.51 93.87,30.5 93.67,30.5 92.21,31.96 88.76,31.96 88.06,32.66 87.84,32.66 87.74,32.55 87.52,32.55 87.31,32.77 87.31,32.98 87.41,33.09 87.41,33.3 86.98,33.74 85.97,33.74 84.34,35.36 84.34,36.47 84.49,36.63 84.64,36.63 84.79,36.78 84.79,37.08 84.64,37.24 84.49,37.24 84.34,37.39 84.34,38.99 83.58,39.76 v3(83.27,39.76)
  BOTTOM w0.076: CPU1.AG34 83.25,44.6 83.56,44.28 83.56,43.25 83.62,43.16 83.67,43.06 83.67,42.67 83.28,42.29 83.28,41.72 82.84,41.28 82.84,40.6 82.79,40.55 82.79,39.69 82.86,39.61 83.12,39.61 v3(83.27,39.76)
M_B_B8: length 55.1
  TOP w0.152: RAM4.D2 105.11,20.87 105.11,20.24 v3(105.13,20.22) 105.13,20.11 103.93,18.91 103.93,17.93 103.6,17.59 RN1304.3
  L5 w0.152: v3(81.57,37.16) 82.08,36.65 82.08,36.05 82.49,35.64 82.49,33.62 84.96,31.15 85.46,31.15 86.34,31.15 87.15,30.33 87.68,30.33 88.01,30 89.37,30 89.75,29.62 89.75,28.68 89.5,28.43 89.5,27.51 89.96,27.05 89.96,24.8 89.08,23.92 89.08,22.7 90.38,21.4 90.38,20.89 90.56,20.71 90.56,19.31 90.81,19.06 91.39,19.06 91.54,19.21 91.54,19.59 91.69,19.74 92,19.74 92.15,19.59 92.15,19.21 92.3,19.06 93.08,19.06 93.23,19.21 93.23,19.77 93.41,19.94 93.74,19.94 93.92,19.77 93.92,19.21 94.07,19.06 104.98,19.06 105.13,19.21 v3(105.13,20.22)
  BOTTOM w0.076: CPU1.AG35 83.03,43.97 83,43.89 83,43.43 83.02,43.36 83.02,43.08 82.95,42.89 82.95,41.88 82.4,41.33 82.4,39.72 82.39,39.72 82.39,39.31
  BOTTOM w0.152: 82.39,39.31 82.36,39.11 82.36,37.36 82.17,37.16 v3(81.57,37.16)
M_B_B9: length 51.8
  TOP w0.152: RAM4.C2 104.46,20.87 104.46,20.45 v3(104.28,20.27) 104.28,20.07 103.95,19.74 103.75,19.74 103.25,19.24 103.25,18.04 102.95,17.74 RN1304.4
  L5 w0.152: v3(104.28,20.27) 102.76,20.27 102.75,20.28 99.97,20.28 99.57,20.68 98.44,20.68 98.04,20.28 97.5,20.28 97.35,20.43 97.35,21 97.19,21.15 96.89,21.15 96.74,21 96.74,20.43 96.58,20.28 95.97,20.28 95.68,20.57 95.68,22.01 95.85,22.18 95.85,23.44 95.46,23.82 95.46,24.52 95.31,24.67 94.88,24.67 94.75,24.8 94.75,25.12 94.91,25.28 95.3,25.28 95.46,25.44 95.46,29.09 94.86,29.7 94.5,29.7 94.08,29.27 94.08,28.07 93.92,27.92 93.43,27.92 93.28,28.07 93.28,29.91 91.96,31.22 88.62,31.22 88.29,31.55 87.66,31.55 86.85,32.37 86.35,32.37 83.71,35.01 83.71,38.05 v3(83.27,38.49)
  BOTTOM w0.076: CPU1.AG36 83.25,43.49 83.4,43.22 83.4,43.19 83.45,43.1 83.48,43.07 83.5,43.02 83.5,42.74 83.12,42.36 83.12,41.81 82.6,41.29 82.6,39.4 82.6,39.4 82.6,39.16 v3(83.27,38.49)
M_B_CKE0: length 50.8
  TOP w0.089: 89.39,20.2 89.39,20.21 89.39,20.54 89.51,20.66 89.51,21.21 89.51,21.22 89.51,21.35 RAM3.K3
  TOP w0.152: R1316.2 90.13,17.96 89.48,18.61 v3(89.48,18.78) 89.37,18.88 89.37,19.93 89.39,19.95 89.39,20.2
  L8 w0.114: v3(89.48,18.78) 89.05,19.2 87.38,19.2 86.78,18.61 83.37,18.61 82.76,19.21 82.4,19.21 82.39,19.2 82.21,19.2 78.86,22.55 78.7,22.55 78.23,22.08 78.06,22.08 77.9,22.24 77.9,22.4 78.38,22.88 78.38,23.04 78.12,23.29 78.12,23.31 77.65,23.78 77.49,23.78 76.91,23.21 76.75,23.21 76.59,23.37 76.59,23.54 77.16,24.11 77.16,24.27 76.67,24.76 76.67,30.22 77.79,31.34 77.79,44.47 77.59,44.67 77.59,46.57 77.31,46.97 76.94,47.34 76.32,47.34 75.68,47.98 75.68,48.39 v3(76.1,48.8)
  BOTTOM w0.152: CPU1.T28 v3(76.1,48.8)
M_B_CKE1: length 51.5
  TOP w0.089: RAM3.K4 89.83,22.47 90.17,22.13 90.17,20.16 90.16,20.15
  TOP w0.152: 90.27,18.72 90.27,18.69 90.89,18.06 R1317.2 ; 90.27,18.72 v3(90.26,18.72) ; 90.27,18.72 90.27,18.74 90.16,18.85 90.16,20.15
  L8 w0.114: v3(90.26,18.72) 90.27,18.72 90.27,18.74 89.4,19.62 88.71,19.62 88.67,19.57 84.75,19.57 84.64,19.46 84.64,19.1 84.52,18.98 84.29,18.98 84.18,19.1 84.18,19.46 84.06,19.57 83.7,19.57 82.53,20.74 82.37,20.74 81.98,20.35 81.82,20.35 81.66,20.51 81.66,20.67 82.04,21.06 82.04,21.22 79.68,23.59 79.52,23.59 79.07,23.14 78.91,23.14 78.74,23.3 78.74,23.46 79.2,23.91 79.2,24.07 78.49,24.77 78.33,24.77 78.17,24.61 78.01,24.61 77.85,24.77 77.85,24.94 78.01,25.1 78.01,25.26 77.85,25.42 77.69,25.42 77.53,25.26 77.37,25.26 77.2,25.42 77.2,25.58 77.36,25.74 77.36,25.9 77.06,26.2 77.06,29.94 78.35,31.23 78.35,44.67 77.95,45.08 77.95,46.62 76.92,47.65 76.57,47.65 v3(76.07,48.14)
  BOTTOM w0.152: CPU1.T29 v3(76.07,48.14)
M_B_CKE2: length 56.1
  TOP w0.127: R1318.2 108.42,19 108.64,19.22 108.64,20.16 108.62,20.18 108.62,20.68 108.68,20.74 108.68,21.34 RAM4.K3
  TOP w0.152: v3(109.35,22.08) 109.35,22.01 RAM4.K3
  L5 w0.152: v3(76.95,48.77) 77.34,49.08 77.64,49.28 80.34,49.28 80.4,49.35 80.76,49.35 81.02,49.09 81.02,48.13 81.38,47.76 82.48,47.52 83.16,47.48 84.67,45.96 84.67,45.48 86.19,43.96 87.81,43.96 89.04,43.72 90.88,43.09 93.47,42.68 93.9,42.51 95.6,40.82 96,39.69 96,37.56 96.64,35.98 96.89,35.73 97.62,35.73 102.71,30.63 106.8,30.63 107.32,30.12 107.32,25.34 108.53,24.13 108.67,24.13 109.75,23.05 109.75,22.63 v3(109.35,22.08)
  BOTTOM w0.152: CPU1.V28 v3(76.95,48.77)
M_B_CKE3: length 57.3
  TOP w0.127: v2(109.35,19.01) 109.18,18.84 R1319.2
  TOP w0.152: RAM4.K4 109.01,22.55 v3(109.34,22.88)
  L5 w0.152: v3(109.34,22.88) 107.72,24.5 102.98,24.5 102.78,24.69 102.78,25.69 103.01,25.92 103.01,29.47 97.36,35.12 96.64,35.12 95.99,35.77 95.36,37.31 95.1,37.57 94.97,37.57 94.17,38.38 94.17,40.94 93.91,41.65 93.56,41.99 91.88,41.99 91.74,41.85 90.93,41.85 89.71,42.37 89.63,42.42 88.92,42.86 88.53,43.11 87.65,43.35 85.94,43.35 84,45.3 84,46.02 83.43,46.58 83.15,46.72 80.68,47.16 78.06,47.16 78.03,47.13 77.67,47.13 76.94,47.87 v3(76.94,48.07)
  L8 w0.114: v3(109.34,22.88) 108.94,23.28 108.51,23.28 108.27,23.04 108.27,20.09 v2(109.35,19.01)
  BOTTOM w0.152: CPU1.V29 76.98,47.99 v3(76.94,48.07)
M_B_CLK0: length 48.9
  TOP w0.14: v3(88.84,21.25) 89.21,21.25 89.31,21.36 89.31,21.54 89.18,21.67 RAM3.J3 ; v2(88.8,18.73) 88.8,18.7 89.11,18.39 R1341.2
  L3 w0.114: v3(88.84,21.25) 88.84,21.06 88.99,20.91 89.15,20.91 89.44,21.2 89.44,22.23 88.81,22.86 88.81,23.65 88.23,24.23 84.03,24.23 82.17,26.09 82.17,41.86 82.41,42.1 84.25,42.1 84.37,42.22 84.37,42.45 84.25,42.56 82.41,42.56 82.17,42.8 82.17,43.21 82.41,43.45 84.25,43.45 84.37,43.57 84.37,43.79 84.25,43.91 82.41,43.91 82.17,44.15 82.17,46.03 83.28,47.14 83.28,47.3 82.84,47.74 82.84,47.96 82.93,48.05 v3(83.31,48.05)
  L5 w0.14: v3(88.84,21.25) 88.86,21.25 89.36,20.75 89.36,19.99 89.17,19.8 89.17,19.43 88.8,19.05 v2(88.8,18.73)
  BOTTOM w0.14: v3(83.31,48.05) 83.18,48.18 82.96,48.18 82.86,48.08 CPU1.AF29
M_B_CLK1: length 64.3
  TOP w0.127: RAM4.J3 108.36,21.67 108.03,21.33 108.03,19.92 107.93,19.82 v3(107.72,19.82)
  TOP w0.14: v3(107.72,19.82) 107.72,19.64 107.6,19.52 107.57,19.52 107.18,19.14 107.18,18.77 107.16,18.74 107.16,17.39 R1311.2
  L5 w0.076: 85.94,45.44 85.93,45.44 85.93,45.52 85.52,45.93 85.52,47.94 84.62,48.84 84.62,48.84 83.99,49.03 83.57,49.08 83.14,49.08 82.64,48.85 82.41,48.63 81.91,48.45 81.71,48.45 v3(81.49,48.23)
  L5 w0.14: 85.94,45.44 86.08,45.3 86.39,44.99 89.11,44.99 90.55,43.88 91.12,43.88 91.12,43.88 91.7,43.88 91.7,43.88 93.6,43.88 93.62,43.85 94.02,43.85 96.47,41.39 96.89,41.39 96.91,41.41 97.27,41.41 97.61,41.07 97.61,36.59 102.61,31.59 112.01,31.59 112.47,31.13 112.47,20.38 111.8,19.7 107.83,19.7 v3(107.72,19.82)
  BOTTOM w0.14: CPU1.AE29 v3(81.49,48.23)
M_B_CLK#0: length 47.7
  TOP w0.14: v3(88.9,20.35) 88.9,20.38 88.91,20.39 88.91,20.59 89.18,20.87 RAM3.J2 ; R1310.2 88.34,18.51 v2(88.17,18.68)
  L3 w0.114: v3(83.31,48.68) 83.57,48.4 83.78,48.13 83.78,47.66 83.49,47.37 83.49,47.05 82.38,45.94 82.38,44.24 82.5,44.12 84.34,44.12 84.58,43.88 84.58,43.48 84.34,43.24 82.5,43.24 82.38,43.12 82.38,42.89 82.5,42.78 84.34,42.78 84.58,42.54 84.58,42.13 84.34,41.89 82.5,41.89 82.38,41.77 82.38,26.18 84.12,24.45 88.32,24.45 89.03,23.74 89.03,22.95 89.66,22.32 89.66,21.11 v3(88.9,20.35)
  L5 w0.14: v2(88.17,18.68) 88.17,18.8 88.9,19.54 v3(88.9,20.35)
  BOTTOM w0.14: CPU1.AF28 v3(83.31,48.68)
M_B_CLK#1: length 63.8
  TOP w0.127: v3(108.06,19.23) 108.06,19.52 108.26,19.71 108.26,20.76 108.36,20.87 RAM4.J2
  TOP w0.14: R1312.2 107.45,17.08 107.45,18.62 107.48,18.64 107.48,19.02 107.69,19.23 v3(108.06,19.23)
  L5 w0.076: 86.13,45.63 86.05,45.7 86,45.7 85.7,46.01 85.7,48.02 84.7,49.02 84.65,49.02 84.02,49.21 83.58,49.25 83.1,49.25 82.54,49 82.32,48.78 81.88,48.63 81.73,48.63 v3(81.49,48.86)
  L5 w0.14: v3(108.06,19.23) 108.27,19.44 111.91,19.44 112.74,20.27 112.74,31.02 112.74,31.24 112.12,31.85 102.72,31.85 97.88,36.7 97.88,41.18 97.72,41.33 97.72,41.33 97.38,41.68 96.8,41.68 96.78,41.66 96.58,41.66 94.13,44.12 93.73,44.12 93.71,44.14 91.59,44.14 91.58,44.14 91.23,44.14 91.23,44.14 90.64,44.14 89.2,45.26 86.5,45.26 86.27,45.49 86.13,45.63
  BOTTOM w0.14: CPU1.AE28 v3(81.49,48.86)
M_B_CS#0: length 67.4
  TOP w0.152: RAM4.L3 109.66,21.67 109.33,21.34 v3(109.33,21.27) ; R1313.2 100.32,22.48 v2(100.32,22.94) ; v3(90.81,21.29) 90.81,21.29 90.48,21.62 90.48,21.67 RAM3.L3
  L3 w0.114: v3(90.81,21.29) 90.81,21.28 91.24,20.85 94.6,20.85 94.72,20.96 94.72,21.97 94.83,22.09 95.06,22.09 95.18,21.97 95.18,20.96 95.48,20.66 95.97,20.66 96.08,20.77 96.08,21.02 96.2,21.14 96.43,21.14 96.54,21.02 96.54,20.77 96.66,20.66 98.03,20.66 98.29,20.92 98.29,21.08 97.81,21.56 97.81,21.72 97.97,21.88 98.14,21.88 98.62,21.4 98.78,21.4 v2(100.32,22.94) 100.42,22.83 100.42,22.4 100.54,22.29 101.46,22.29 101.62,22.45 101.62,23.62 101.77,23.76 101.97,23.76 102.08,23.65 102.08,22.49 102.24,22.33 102.78,22.33 103.1,22.66 103.1,23.03 103.33,23.25 107.55,23.25 108.26,22.54 108.26,21.05 108.54,20.77 108.84,20.77 v3(109.33,21.27)
  L5 w0.152: v2(100.32,22.94) 100.83,22.43 101.64,22.43 102.13,21.95 102.13,21.65 101.97,21.5 100.48,21.5 96.68,25.3 96.68,29.61 95.19,31.11 94.52,31.11 94.5,31.12 93.91,31.12 92.46,32.57 89.01,32.57 86.98,34.6 86.09,34.6 85.4,35.29 85.4,39.05 85.4,39.06 85.4,39.11 85.4,39.12 85.4,39.6 85.4,39.6 85.4,40.58 v3(85.83,41.02)
  BOTTOM w0.076: v3(85.83,41.02) 85.61,41.02 85.51,41.12 85.51,41.99 85.77,42.25 CPU1.AL37
M_B_CS#1: length 75.2
  TOP w0.152: v3(90.83,22.07) 90.83,22.07 90.83,22.12 90.48,22.47 RAM3.L4 ; v2(100.21,23.57) 99.4,22.76 R1314.2 ; v3(109.99,22.09) 109.99,22.14 109.66,22.47 RAM4.L4
  L3 w0.114: v3(90.83,22.07) 90.83,22.07 90.83,22.08 91.21,22.45 95.45,22.45 95.56,22.57 95.56,24.16 95.68,24.28 95.9,24.28 96.02,24.16 96.02,22.57 96.13,22.45 96.36,22.45 96.48,22.57 96.48,24.16 96.59,24.28 96.82,24.28 96.93,24.16 96.93,22.57 97.05,22.45 97.28,22.45 97.39,22.57 97.39,23.87 97.5,23.99 97.73,23.99 97.85,23.87 97.85,22.57 97.96,22.45 99.1,22.45 v2(100.21,23.57) 100.29,23.64 100.29,25.06 100.48,25.25 101.11,25.25 101.47,24.89 101.47,24.73 100.82,24.07 100.82,23.91 100.98,23.75 101.14,23.75 101.8,24.41 101.96,24.41 102.29,24.08 102.65,24.08 102.77,24.19 102.77,24.62 102.88,24.74 103.11,24.74 103.23,24.62 103.23,24.19 103.34,24.08 103.57,24.08 103.68,24.19 103.68,24.62 103.8,24.74 104.03,24.74 104.14,24.62 104.14,24.19 104.25,24.08 107.79,24.08 107.9,23.96 107.9,23.26 108.02,23.15 108.24,23.15 108.36,23.27 108.36,23.96 108.47,24.08 109.01,24.08 110.21,22.88 110.29,22.55 v3(109.99,22.09)
  L5 w0.152: v3(85.83,39.24) 86.01,39.24 86.32,38.93 86.32,36.12 89.06,33.38 92.77,33.38 94.37,31.78 95.57,31.78 97.29,30.06 97.29,30.05 97.29,29.54 97.29,29.54 97.29,29.36 97.29,29.05 97.45,28.9 97.94,28.9 97.95,28.89 98.11,28.89 98.26,28.73 98.26,28.43 98.11,28.28 97.45,28.28 97.29,28.12 97.29,27.63 97.45,27.47 97.74,27.47 97.86,27.35 97.86,26.96 97.71,26.8 97.45,26.8 97.29,26.65 97.29,25.76 97.45,25.61 97.66,25.61 97.9,25.85 98.16,25.85 98.31,25.7 98.31,25.29 98.04,25.02 98.04,24.81 99.27,23.57 99.62,23.57 99.62,23.56 100.13,23.56 100.13,23.57 v2(100.21,23.57)
  BOTTOM w0.076: CPU1.AL35 85.67,44.1 85.51,43.67 85.51,43.42 85.54,43.36 85.54,43.08 85.5,42.99 85.5,42.21 85.33,42.04 85.33,40.99 85.43,40.89 85.43,40.38
  BOTTOM w0.152: v3(85.83,39.24) 85.43,39.64 85.43,40.38
M_B_DQ0: length 22
  TOP w0.152: v3(85.6,26.05) 85.6,26.07 85.62,26.09 85.62,26.16 RAM3.D9
  L3 w0.114: v3(85.84,38.65) 85.83,38.64 85.41,38.23 85.34,38.14 85.24,37.94 84.69,37.15 83.4,35.62 83.2,35.4 83.16,35.37 83.16,26.8 83.46,26.5 84.12,26.5 84.15,26.47 85.18,26.47 v3(85.6,26.05)
  BOTTOM w0.076: v3(85.84,38.65) 86.06,38.87 86.21,39.16 86.33,39.62 86.46,40.94 86.46,41.82 86.48,41.88 86.64,42.08 86.7,42.2 86.73,42.34 86.73,42.51 86.56,42.68 86.56,43.06 86.64,43.21 86.65,43.33 86.73,43.69 CPU1.AN35
M_B_DQ1: length 21
  TOP w0.152: RAM3.E10 86.58,27.27 86.92,26.93 v3(86.92,26.88)
  L3 w0.114: v3(85.84,35.71) 85.42,35.29 85.42,31.82 86.17,31.07 86.21,31.07 86.45,30.83 86.45,28.34 86.94,27.85 86.94,26.9 v3(86.92,26.88)
  BOTTOM w0.076: CPU1.AN34 87.7,44.84 87.91,44.64 87.91,43.83 87.85,43.67 87.85,43.42 87.89,43.33 87.89,43.11 87.85,43.02 87.85,42.58 88.15,42.28 88.15,40.75 88.05,40.65 88.05,40.12
  BOTTOM w0.152: 88.05,40.12 87.48,37.93 87.32,37.46 86.3,36.17 86.3,36.11 86.09,35.9 85.93,35.71 v3(85.84,35.71)
M_B_DQ2: length 17.7
  TOP w0.14: v3(87.5,29.9) 87.42,29.9 86.88,29.36 86.88,29.03 86.9,29 86.9,28.39 86.58,28.07 RAM3.E11
  L3 w0.114: v3(88.43,40.38) 87.87,39.82 87.87,39.74 86.98,38.85 86.98,31.53 87.54,30.97 87.54,29.95 87.49,29.9 v3(87.5,29.9)
  BOTTOM w0.076: CPU1.AR35 88.19,44.1 88.02,43.64 88.02,43.45 88.06,43.34 88.06,43.1 88.02,42.99 88.02,42.67 88.32,42.38 88.32,40.54 88.43,40.43 v3(88.43,40.38)
M_B_DQ3: length 22.7
  TOP w0.152: v3(87.54,26.08) 87.54,26.16 87.23,26.47 RAM3.F9
  L3 w0.114: v3(87.54,26.08) 87.91,26.45 89.62,26.45 89.89,26.71 89.89,27.03 89.67,27.25 89.67,30.46 88.09,32.05 88.09,37.14 v3(88.41,37.46)
  BOTTOM w0.076: 89.17,38.51 89.17,40.66 88.82,41.01 88.82,42.85 88.71,43.05 88.6,43.26 88.6,44.2 CPU1.AR34
  BOTTOM w0.152: 89.17,38.51 89.17,38.22 88.41,37.46 v3(88.41,37.46)
M_B_DQ4: length 19.6
  TOP w0.152: v3(86.91,26.06) 86.91,26.14 86.58,26.47 RAM3.E9
  L3 w0.114: v3(86.91,26.06) 86.45,26.52 86.45,27.3 86.63,27.48 86.63,27.86 84.67,29.82 84.67,35.69 v3(85.86,36.87)
  BOTTOM w0.076: 86.96,39.19 86.8,39.35 86.8,41.72 87.1,42.02 87.1,42.78 CPU1.AN37
  BOTTOM w0.152: 86.96,39.19 86.96,37.98 v3(85.86,36.87)
M_B_DQ5: length 22
  TOP w0.152: RAM3.F8 86.92,25.36 v3(86.92,25.21)
  L3 w0.114: v3(85.84,37.46) 83.65,35.27 83.65,29.06 85.44,27.28 85.76,27.28 86.07,26.97 86.07,26.06 v3(86.92,25.21)
  BOTTOM w0.076: 86.63,39.01 86.63,41.79 86.93,42.09 86.93,42.54 86.73,42.75 86.73,43.02 86.83,43.21 86.83,43.21 86.98,43.49 CPU1.AN36
  BOTTOM w0.152: 86.63,39.01 86.63,38.25 v3(85.84,37.46)
M_B_DQ6: length 20
  TOP w0.152: RAM3.F10 87.23,27.27 87.56,26.94 v3(87.56,26.87)
  L3 w0.114: v3(87.56,26.87) 87.95,27.26 88.98,27.26 89.35,27.63 89.35,30.23 87.72,31.86 87.72,37.36 v3(88.41,38.04)
  BOTTOM w0.076: CPU1.AR36 88.28,43.49 88.55,43.01 88.66,42.8 88.66,40.92 88.96,40.62 88.96,38.6 v3(88.41,38.04)
M_B_DQ7: length 17.8
  TOP w0.152: v3(87.55,28.49) 87.55,28.38 87.23,28.07 RAM3.F11
  L3 w0.114: v3(88.43,39.21) 88.02,39.21 87.35,38.55 87.35,31.67 87.93,31.09 87.93,30.72 88.04,30.61 88.63,30.61 88.75,30.49 88.75,30.26 88.63,30.15 88.04,30.15 87.93,30.04 87.93,28.86 v3(87.55,28.49)
  BOTTOM w0.076: v3(88.43,39.21) 88.8,39.58 88.8,40.55 88.49,40.85 88.49,42.69 CPU1.AR37
M_B_DQ8: length 19.5
  TOP w0.14: v3(91.4,30.79) 92.3,30.79 93.4,29.69 93.4,28.61 93.25,28.24 RAM3.R11
  L3 w0.114: v3(89.97,38.19) 89.54,37.76 89.54,37.01 89.12,36.59 89.12,35.18 89.24,35.06 89.24,32.95 v3(91.4,30.79)
  BOTTOM w0.076: CPU1.AU35 89.18,43.88 89.18,43.25 89.06,43.03 88.99,42.96 88.99,41.07 89.33,40.73 89.33,40.7 89.36,40.67 89.36,38.8 v3(89.97,38.19)
M_B_DQ9: length 20.4
  TOP w0.127: RAM3.T11 93.73,28.41 94.06,28.74 94.06,29 94.33,29.27 v3(94.68,29.27)
  L3 w0.114: v3(94.68,29.27) 94.68,30.02 91.06,33.64 91.06,38.7 91.55,39.19 v3(91.56,39.19)
  BOTTOM w0.076: CPU1.AU34 90.24,44.84 90.44,44.64 90.46,44.62 90.46,43.91 90.37,43.67 90.37,43.42 90.41,43.31 90.41,43.13 90.37,43.02 90.37,41.99 90.37,41.99 90.37,41.85 90.75,41.13 90.84,40.96 90.84,40.55 90.84,40.55 90.84,40.28 91.07,39.54 91.43,39.19 v3(91.56,39.19)
M_B_DQ10: length 23.6
  TOP w0.152: RAM3.R8 93.08,25.67 93.38,25.37 v3(93.38,25.25)
  L3 w0.114: v3(93.38,25.25) 95,25.25 95.7,25.94 95.7,30.56 92.34,33.92 92.34,38.98 v3(91.56,39.77)
  BOTTOM w0.076: v3(91.56,39.77) 91.4,39.78 91.09,40.04 91.05,40.16 91.01,40.36 91.01,40.62 91,40.62 91,40.99 90.9,41.2 90.7,41.59 90.54,41.89 90.54,42.06 90.54,42.06 90.54,42.99 90.58,43.1 90.58,43.34 90.54,43.45 90.54,43.64 90.66,43.99 CPU1.AW35
M_B_DQ11: length 21.7
  TOP w0.14: v3(94.87,28.63) 94.78,28.54 94.38,28.54 94.06,28.22 94.06,28.21 94.06,28.2 94.06,27.94 94.06,27.93 93.87,27.74 93.56,27.74 93.08,27.27 RAM3.R10
  L3 w0.114: v3(94.87,28.63) 95.29,29.05 95.29,29.93 91.43,33.79 91.43,36.65 v3(91.56,36.78)
  BOTTOM w0.076: CPU1.AW34 91.09,44.24 91.09,43.3 91.22,43.07 91.22,42.66 91.03,42.47 91.03,42.12 91.42,41.74 91.5,41.74 91.5,41.73 91.5,41.73 91.76,41.47 91.78,41.47 92.09,41.16 92.09,41.15 92.18,41.06 92.18,38.8 92.19,38.79 92.19,38.25
  BOTTOM w0.152: v3(91.56,36.78) 91.58,36.78 91.61,36.81 91.82,36.81 92.19,37.17 92.19,38.25
M_B_DQ12: length 22.6
  TOP w0.152: v3(93.43,26.07) 93.08,26.42 93.08,26.47 RAM3.R9
  L3 w0.114: v3(93.43,26.07) 93.42,26.07 93.02,25.67 90.63,25.67 90.28,26.02 90.28,27.37 90.23,27.43 90.23,30.82 88.51,32.54 88.51,36.79 88.88,37.16 88.88,39.48 v3(89.98,40.58)
  BOTTOM w0.076: v3(89.98,40.58) 89.93,40.58 89.66,40.85 89.66,40.87 89.32,41.21 89.32,42.71 CPU1.AU37
M_B_DQ13: length 22.5
  TOP w0.152: RAM3.T9 93.73,26.47 94.04,26.78 v3(94.04,26.87)
  L3 w0.114: v3(94.04,26.87) 93.66,26.49 90.94,26.49 90.49,26.95 90.49,27.45 90.43,27.51 90.43,31.24 88.87,32.8 88.87,36.81 89.21,37.15 89.21,37.86 89.59,39 v3(89.97,39.38)
  BOTTOM w0.076: v3(89.97,39.38) 89.53,39.82 89.53,40.73 89.52,40.74 89.52,40.74 89.5,40.77 89.5,40.8 89.15,41.14 89.15,42.78 89.25,42.87 89.25,43.03 89.41,43.33 89.5,43.42 CPU1.AU36
M_B_DQ14: length 20.4
  TOP w0.14: v3(94.85,27.47) 94.73,27.59 94.52,27.59 94.51,27.59 94.25,27.59 94.24,27.59 94.06,27.59 93.73,27.27 RAM3.T10
  L3 w0.114: v3(91.55,38) 91.97,37.58 91.97,36.31 91.8,36.14 91.8,33.95 95.5,30.24 95.5,28.11 v3(94.85,27.47)
  BOTTOM w0.076: CPU1.AW36 90.8,43.49 91.05,43.03 91.05,42.73 90.87,42.54 90.87,42.05 91.35,41.57 91.44,41.57 91.7,41.31 91.71,41.31 91.92,41.09 91.92,41.08 92.01,40.99 92.01,38.36 91.99,38.33 91.99,38.2 91.79,38 v3(91.55,38)
M_B_DQ15: length 19.9
  TOP w0.152: v3(94.05,26.08) 94.04,26.08 94.04,25.98 93.73,25.67 RAM3.T8
  L3 w0.114: v3(94.05,26.08) 94.43,26.47 94.43,28.9 93.68,29.65 93.68,30.35 92.22,31.82 90.61,33.43 90.61,39.99 v3(91.56,40.94)
  BOTTOM w0.076: v3(91.56,40.94) 91.56,40.99 91.22,41.33 91.22,41.46 90.7,41.98 90.7,42.8 CPU1.AW37
M_B_DQ16: length 25.8
  TOP w0.127: RAM3.C8 85.28,25.73 v3(84.95,26.06)
  L8 w0.114: v3(85.14,47.58) 84.83,47.25 84.72,47.11 84.72,46.86 84.19,46.33 83.7,45.15 83.56,44.87 83.37,44.2 82.56,43.39 82.56,42.86 82.48,42.78 82.48,27.33 82.56,27.12 82.56,26.84 82.7,26.46 83.51,25.66 84.46,25.66 84.52,25.69 v3(84.95,26.06)
  BOTTOM w0.152: CPU1.AJ29 v3(85.14,47.58)
M_B_DQ17: length 23.7
  TOP w0.127: v3(84.31,26.06) 84.63,25.73 RAM3.B8
  L8 w0.114: v3(85.14,46.94) 84.45,46.25 84.45,44.22 82.85,42.62 82.85,27.4 83,27 83.48,26.52 83.85,26.52 v3(84.31,26.06)
  BOTTOM w0.152: CPU1.AJ30 v3(85.14,46.94)
M_B_DQ18: length 20.9
  TOP w0.14: RAM3.C11 85.28,28.07 85.35,28.1 85.6,28.69 85.6,28.73 85.6,28.74 85.6,29 85.6,29.01 85.6,29.56 86.02,29.97 v3(86.07,29.97)
  L8 w0.114: v3(86.07,29.97) 86.43,30.33 86.43,30.82 86.38,30.87 86.38,32.43 86.26,32.54 85.86,32.54 85.75,32.66 85.75,32.88 85.86,33 86.26,33 86.38,33.11 86.38,33.95 86.66,34.22 86.66,41.51 86.97,41.82 86.97,44.81 86.59,45.19 86.59,45.85 86.96,46.22 v3(86.96,46.3)
  BOTTOM w0.152: CPU1.AM32 v3(86.96,46.3)
M_B_DQ19: length 22.7
  TOP w0.152: RAM3.C10 85.28,27.27 85.59,26.96 v3(85.59,26.87)
  L8 w0.114: v3(85.59,26.87) 86.01,26.87 86.75,27.61 86.75,33.48 87.6,34.33 87.6,41.9 87.19,42.31 87.19,45.34 87.37,45.52 87.37,46.54 v3(86.96,46.94)
  BOTTOM w0.152: CPU1.AM31 v3(86.96,46.94)
M_B_DQ20: length 21.7
  TOP w0.14: RAM3.B11 84.63,28.07 84.97,28.4 84.97,28.73 84.96,28.74 84.96,29 84.97,29.01 84.97,30.09 v3(85.38,30.51)
  L8 w0.114: v3(86.96,47.58) 86.56,47.18 86.56,46.1 86.39,45.94 86.39,45.1 86.76,44.73 86.76,43.72 85.96,42.92 85.96,42.1 86.29,41.77 86.29,34.68 85.38,33.77 v3(85.38,30.51)
  BOTTOM w0.152: CPU1.AM30 v3(86.96,47.58)
M_B_DQ21: length 25.5
  TOP w0.127: RAM3.C9 85.28,26.55 v3(84.95,26.88)
  L8 w0.114: v3(86.96,48.23) 87.44,47.75 87.44,46.99 87.57,46.87 87.57,45.44 87.39,45.26 87.39,42.4 87.97,41.82 87.97,34.18 87.12,33.32 87.12,27.69 85.91,26.48 85.36,26.48 v3(84.95,26.88)
  BOTTOM w0.152: CPU1.AM29 v3(86.96,48.23)
M_B_DQ22: length 20.9
  TOP w0.152: RAM3.B10 84.63,27.27 84.28,27.62 v3(84.28,27.67)
  L8 w0.114: v3(84.28,27.67) 83.22,28.73 83.22,34.7 83.81,35.29 83.81,43 84.72,43.91 84.72,45.91 v3(85.12,46.31)
  BOTTOM w0.152: CPU1.AJ31 v3(85.12,46.31)
M_B_DQ23: length 21
  TOP w0.127: v3(84.3,26.88) 84.63,26.56 RAM3.B9
  L8 w0.114: v3(84.3,26.88) 84.66,27.25 84.66,28.28 83.59,29.35 83.59,34.4 84.38,35.19 84.38,42.98 85.11,43.71 v3(85.11,45.66)
  BOTTOM w0.152: v3(85.11,45.66) 85.1,45.66 CPU1.AJ32
M_B_DQ24: length 23
  TOP w0.152: v3(92.11,26.88) 92.11,26.94 91.78,27.27 RAM3.N10
  L8 w0.114: v3(92.11,26.88) 91.26,26.88 91.12,27.03 90.61,27.03 89.92,27.71 89.92,29.71 89.21,30.41 89.21,36.84 89.25,36.88 89.25,41.18 88.96,41.47 88.96,43.9 88.39,44.47 88.39,45.92 v3(88.76,46.3)
  BOTTOM w0.152: CPU1.AR31 v3(88.76,46.3)
M_B_DQ25: length 21.2
  TOP w0.152: RAM3.M10 91.13,27.27 91.47,27.6 91.47,27.65 v3(91.46,27.65)
  L8 w0.114: v3(88.77,45.69) 88.77,45.2 89.29,44.67 89.29,42.85 89.58,42.56 89.58,38 89.58,37.99 89.58,30.87 90.12,30.33 90.12,27.8 90.66,27.26 91.08,27.26 91.46,27.65 v3(91.46,27.65)
  BOTTOM w0.152: CPU1.AR32 88.76,45.71 v3(88.77,45.69)
M_B_DQ26: length 23.5
  TOP w0.152: v3(92.09,26.06) 91.78,26.36 91.78,26.47 RAM3.N9
  L8 w0.114: v3(90.59,46.91) 90.9,46.6 90.9,45.65 90.93,45.62 90.93,45.3 90.77,45.14 90.77,44.15 92.36,42.55 92.36,42.53 92.53,42.37 92.53,30.8 93.13,30.2 93.13,27.1 v3(92.09,26.06)
  BOTTOM w0.152: CPU1.AV30 v3(90.59,46.91)
M_B_DQ27: length 24.2
  TOP w0.152: v3(92.75,26.06) 92.43,26.37 92.43,26.47 RAM3.P9
  L8 w0.114: v3(92.75,26.06) 93.5,26.81 93.5,30.37 92.89,30.97 92.89,42.53 91.02,44.41 91.02,45.1 91.13,45.21 91.13,45.93 91.1,45.96 91.1,47.08 v3(90.61,47.58)
  BOTTOM w0.152: CPU1.AV29 v3(90.61,47.58)
M_B_DQ28: length 24.5
  TOP w0.152: RAM3.M9 91.13,26.47 91.13,26.4 v3(91.45,26.09)
  L8 w0.114: v3(88.84,47.52) 88.18,46.86 88.18,44.32 88.63,43.88 88.63,41.52 89.05,41.1 89.05,37.2 88.84,37 88.84,30.35 89.72,29.48 89.72,27.63 90.52,26.82 90.71,26.82 v3(91.45,26.09)
  BOTTOM w0.152: v3(88.84,47.52) 88.66,47.52 CPU1.AR30
M_B_DQ29: length 24
  TOP w0.127: RAM3.M8 91.13,25.72 v3(90.79,26.06)
  L8 w0.114: v3(87.9,47.49) 87.9,43.25 88.3,42.85 88.3,41.56 88.82,41.04 88.82,37.32 88.48,36.98 88.48,30.43 89.51,29.39 89.51,27.55 90.79,26.27 v3(90.79,26.06)
  BOTTOM w0.152: v3(87.9,47.49) 87.98,47.49 CPU1.AR29
M_B_DQ30: length 18.8
  TOP w0.152: RAM3.N11 91.78,28.07 92.11,28.39 v3(92.11,28.47)
  L8 w0.114: v3(92.11,28.47) 92.11,30.31 92.16,30.35 92.16,42.47 90.54,44.09 v3(90.54,45.46)
  BOTTOM w0.152: CPU1.AV32 90.53,45.46 v3(90.54,45.46)
M_B_DQ31: length 19.8
  TOP w0.152: RAM3.M11 91.13,28.07 91.45,28.38 v3(91.45,28.47)
  L8 w0.114: v3(91.45,28.47) 91.49,28.47 91.79,28.77 91.79,33.91 91.14,34.56 91.14,41.74 91.04,41.83 91.04,42.53 90.15,43.42 90.15,45.86 v3(90.51,46.22)
  BOTTOM w0.152: CPU1.AV31 90.5,46.22 v3(90.51,46.22)
M_B_DQ32: length 27.9
  TOP w0.127: v3(105.45,26.06) 105.76,26.37 105.76,26.47 RAM4.E9
  L3 w0.114: v3(93.37,40.39) 92.96,39.98 92.96,36.39 92.88,36.26 92.96,35.89 92.96,33.95 98.79,28.12 99.48,28.12 102.23,25.37 104.76,25.37 v3(105.45,26.06)
  BOTTOM w0.076: CPU1.BA35 92.24,43.97 92.24,43.75 92.27,43.64 92.27,43.43 92.25,43.37 92.25,43.07 92.27,42.98 92.32,42.93 92.32,42.92 92.32,41.86 92.84,41.35 92.84,40.93 v3(93.37,40.39)
M_B_DQ33: length 28.6
  TOP w0.127: v3(104.78,26.06) 105.11,26.39 105.11,26.47 RAM4.D9
  L3 w0.114: v3(93.37,37.47) 93.33,37.43 93.33,36.29 93.27,36.19 93.33,35.93 93.33,34.1 98.85,28.58 101.48,28.58 101.84,28.22 101.84,26.33 102.54,25.63 104.38,25.63 104.78,26.04 v3(104.78,26.06)
  BOTTOM w0.076: 92.46,38.76 92.34,38.87 92.34,41.13 92.25,41.22 92.25,41.23 91.83,41.66 91.83,42.45 91.6,42.68 91.6,43.07 91.61,43.1 91.63,43.13 91.68,43.23 91.68,43.65 91.74,43.72 91.74,44.35 92.02,44.62 CPU1.BA34
  BOTTOM w0.152: 92.46,38.76 92.46,38.11 93.1,37.47 v3(93.37,37.47)
M_B_DQ34: length 28.5
  TOP w0.14: RAM4.F9 106.41,26.47 106.72,26.16 v3(106.72,26.07)
  L3 w0.114: v3(94.94,40.66) 96.66,38.94 96.66,35.43 100.19,31.89 100.48,31.89 100.57,31.81 106.63,31.81 107.41,31.03 107.41,30.8 107.41,30.8 107.41,30.63 107.41,26.74 106.74,26.07 v3(106.72,26.07)
  BOTTOM w0.076: CPU1.BC35 93.64,43.88 93.64,43.25 93.75,43.05 93.83,42.89 93.83,42.7 93.88,42.61 94.6,41.89 94.6,40.99 v3(94.94,40.66)
M_B_DQ35: length 28.1
  TOP w0.152: RAM4.E11 105.76,28.07 106.08,27.75 v3(106.08,27.66)
  L3 w0.114: v3(106.08,27.66) 105.67,28.07 105.67,29.56 104.97,30.26 104.65,30.26 104.42,30.03 98.97,30.03 94.49,34.5 94.49,35.78 94.45,35.99 94.52,36.11 94.52,39.83 v3(93.37,40.98)
  BOTTOM w0.076: v3(93.37,40.98) 93,41.34 93,41.42 92.49,41.93 92.49,42.99 92.48,42.99 92.43,43.05 92.41,43.12 92.41,43.34 92.43,43.39 92.43,43.39 92.44,43.4 92.44,43.69 92.4,43.78 92.4,44.39 92.39,44.4 92.39,44.64 92.6,44.84 CPU1.BC34
M_B_DQ36: length 25.6
  TOP w0.152: RAM4.E10 105.76,27.27 106.05,26.98 106.05,26.88 v3(106.05,26.87)
  L3 w0.114: v3(106.05,26.87) 105.34,27.58 105.34,28.44 104.93,28.86 104.61,28.86 103.85,29.62 103.67,29.62 103.64,29.65 103.32,29.65 103.29,29.62 102.75,29.62 102.69,29.69 102.37,29.69 102.3,29.62 98.85,29.62 94.13,34.35 94.13,35.74 94.05,36.06 94.13,36.17 94.13,36.86 94.15,36.89 94.15,38.44 v3(93.37,39.22)
  BOTTOM w0.076: CPU1.BA37 92.02,42.73 92.16,42.58 92.16,41.79 92.67,41.28 92.67,39.92 v3(93.37,39.22)
M_B_DQ37: length 26.9
  TOP w0.127: RAM4.F8 106.1,25.98 v3(106.1,26.06)
  L3 w0.114: v3(106.1,26.06) 106.12,26.06 106.12,26.04 106.08,26.04 105.57,26.56 105.37,26.56 104.65,27.27 103.09,27.27 102.19,28.17 102.19,28.56 101.74,29.01 98.94,29.01 93.7,34.26 93.7,35.98 93.66,36.13 93.7,36.18 93.7,37.21 93.78,37.3 93.78,37.64 93.75,37.68 93.75,37.84 93.78,37.88 93.78,38.23 93.75,38.26 v3(93.37,38.64)
  BOTTOM w0.076: v3(93.37,38.64) 93.3,38.64 92.51,39.43 92.51,41.2 92.42,41.29 92.42,41.3 91.99,41.72 91.99,42.51 91.76,42.75 91.76,43.03 91.78,43.07 91.85,43.18 91.85,43.38 CPU1.BA36
M_B_DQ38: length 27.2
  TOP w0.152: v3(106.73,26.87) 106.73,26.91 106.72,26.93 106.72,26.96 106.41,27.27 RAM4.F10
  L3 w0.114: v3(94.94,39.47) 96.29,38.11 96.29,35.15 96.37,35.07 96.37,34.95 99.79,31.53 100.33,31.53 100.43,31.42 106.49,31.42 107.21,30.71 107.21,27.35 v3(106.73,26.87)
  BOTTOM w0.076: CPU1.BC36 93.32,43.49 93.58,43.01 93.58,42.81 93.75,42.51 94.44,41.82 94.44,39.62 94.59,39.47 v3(94.94,39.47)
M_B_DQ39: length 24.9
  TOP w0.127: RAM4.F11 106.11,28.37
  TOP w0.14: 106.11,28.37 106.09,28.39 106.09,29 106.11,29.02 106.11,29.26 v3(106.82,29.97)
  L3 w0.114: v3(94.94,38.86) 95.92,37.87 95.92,34.99 96,34.92 96,34.73 99.57,31.16 100.18,31.16 100.29,31.04 106.35,31.04 106.82,30.58 v3(106.82,29.97)
  BOTTOM w0.076: CPU1.BC37 93.32,42.7 94.27,41.75 94.27,39.21 94.63,38.86 v3(94.94,38.86)
M_B_DQ40: length 31.4
  TOP w0.152: v3(111.95,25.17) 112.26,25.48 112.26,25.67 RAM4.R8
  L3 w0.114: v3(97.07,36.16) 97.07,35.95 100.72,32.3 106.66,32.3 108.72,30.24 108.72,28.32 109.1,27.94 109.1,26.83 109.87,26.06 109.92,25.95 110.45,25.43 111.69,25.43 v3(111.95,25.17)
  BOTTOM w0.076: CPU1.BE35 94.21,43.88 94.21,43.25 94.11,43.07 94.11,42.61 94.78,41.94 94.78,41.37 95.33,40.83 95.33,38.78 96.09,38.02 96.09,37.52 96.17,37.45 96.17,37.07 96.18,37.05
  BOTTOM w0.114: 96.18,37.05 v3(97.07,36.16)
M_B_DQ41: length 32.2
  TOP w0.152: v3(114,25.93) 113.98,25.93 113.88,26.04 113.34,26.04 112.91,26.47 RAM4.T9
  L3 w0.114: v3(114,25.93) 113.92,25.93 113.7,26.15 112.84,26.36 112.73,26.44 111.9,27.27 111.76,27.27 111.06,27.97 111.06,28.59 110.79,28.86 110.78,28.86 109.66,29.98 109.66,30.86 107.12,33.41 101.18,33.41 98.22,36.37 98.22,36.64 97.89,36.97 97.89,37.53 97.48,37.94 97.48,38.1 97.46,38.12 97.46,38.16 v3(97.09,38.53)
  BOTTOM w0.076: v3(97.09,38.53) 96.97,38.65 96.97,38.66 96.89,38.74 95.86,39.77 95.86,41.03 95.28,41.62 95.28,42.15 94.89,42.53 94.89,44.49 CPU1.BE34
M_B_DQ42: length 28.6
  TOP w0.127: RAM4.T11 113.34,28.5 113.34,28.5
  TOP w0.14: v3(114.04,28.75) 114.01,28.75 114.01,28.76 113.91,28.76 113.65,28.5 113.34,28.5
  L3 w0.114: v3(98.59,40.41) 98.62,40.38 104.62,40.38 107.26,37.74 108.24,37.74 110.2,35.78 110.2,34.43 113.05,31.57 113.05,29.74 v3(114.04,28.75)
  BOTTOM w0.076: CPU1.BG35 96.06,44.02 96.14,43.95 96.19,43.82 96.38,43.63 96.53,43.63 96.7,43.46 96.7,42.85 96.7,42.84 96.92,42.62 97.2,42.49 97.57,42.12 98.02,41.59 98.02,40.98 98.58,40.42 v3(98.59,40.41)
M_B_DQ43: length 31.6
  TOP w0.127: RAM4.R10 112.63,27.64 112.63,27.64
  TOP w0.152: 112.63,27.64 113.73,27.64 114.02,27.93 v3(114.15,27.93)
  L3 w0.114: v3(114.15,27.93) 112.69,29.39 112.69,31.42 109.83,34.27 109.83,35.63 108.09,37.37 107.11,37.37 104.7,39.78 101.63,39.78 101.22,39.36 99.05,39.36 v3(98.59,39.82)
  BOTTOM w0.076: CPU1.BG34 95.58,44.59 95.58,44.07 95.6,44.03 95.76,43.86 95.89,43.86 95.98,43.8 96.05,43.74 96.15,43.53 96.15,43.25 96.26,43.06 96.26,42.73 96.36,42.62 96.36,42.29 96.96,41.69 97.24,41.69 97.38,41.69 97.85,41.21 97.85,40.56 98.28,40.13 v3(98.59,39.82)
M_B_DQ44: length 30.5
  TOP w0.152: v3(113.16,25.19) 112.91,25.44 112.91,25.67 RAM4.T8
  L3 w0.114: v3(113.16,25.19) 113.16,25.52 112.6,25.86 112.52,26.16 111.43,27.25 109.87,27.25 109.51,27.61 109.51,28.14 109.33,28.32 109.33,30.27 109.33,30.67 106.96,33.04 101.03,33.04 97.85,36.21 97.85,36.49 97.48,36.86 97.48,37.56 v3(97.09,37.94)
  BOTTOM w0.076: v3(97.09,37.94) 97.1,37.94 96.7,38.35 96.7,38.5 96.68,38.52 95.7,39.5 95.7,40.96 95.11,41.55 95.11,42.08 94.53,42.66 CPU1.BE37
M_B_DQ45: length 30.3
  TOP w0.152: RAM4.R9 112.26,26.47 111.95,26.16 v3(111.95,26.08)
  L3 w0.114: v3(111.95,26.08) 111.54,25.67 110.49,25.67 110.09,26.07 110.05,26.18 109.31,26.92 109.31,28.05 109.13,28.23 109.13,30.35 106.81,32.67 100.88,32.67 97.48,36.06 97.48,36.33 97.07,36.75 v3(97.07,36.75)
  BOTTOM w0.076: 97.02,36.75 96.5,37.27 96.48,37.57 96.4,37.65 96.4,38.37 95.52,39.25 95.52,40.89 94.95,41.46 94.95,42.01 94.28,42.68 94.28,43.03 94.42,43.29 94.53,43.49 CPU1.BE36
  BOTTOM w0.114: 97.02,36.75 v3(97.07,36.75)
M_B_DQ46: length 30.9
  TOP w0.14: v3(113.97,26.78) 113.97,26.78 113.97,26.79 113.94,26.79 113.78,26.94 113.23,26.94 112.91,27.27 RAM4.T10
  L3 w0.114: v3(98.59,38.65) 98.76,38.83 101.2,38.83 101.79,39.41 104.55,39.41 106.96,37 107.94,37 109.46,35.48 109.46,34.12 112.32,31.27 112.32,28.41 113.94,26.79 113.97,26.79 113.97,26.78 v3(113.97,26.78)
  BOTTOM w0.076: CPU1.BG36 95.99,43.23 95.99,43.21 96.09,43.02 96.09,42.66 96.19,42.55 96.19,42.15 96.82,41.52 97.31,41.52 97.69,41.14 97.69,39.55 v3(98.59,38.65)
M_B_DQ47: length 27.7
  TOP w0.14: v3(111.83,30.52) 112.58,29.76 112.58,28.39 112.26,28.07 RAM4.R11
  L3 w0.114: v3(111.83,30.52) 111.44,30.91 111.44,31.01 108.88,33.57 108.88,35.54 107.86,36.56 103.95,36.56 103.29,35.9 102.79,35.9 102.48,36.21 102.48,36.26 100.69,38.04 v3(98.59,38.04)
  BOTTOM w0.076: CPU1.BG37 95.83,42.68 96.03,42.49 96.03,42.08 96.75,41.36 97.24,41.36 97.52,41.07 97.52,39.16 97.6,39.09 97.6,38.98
  BOTTOM w0.152: v3(98.59,38.04) 97.91,38.04 97.6,38.35 97.6,38.98
M_B_DQ48: length 25.2
  TOP w0.127: RAM4.B11 103.81,28.17 v3(103.49,28.49)
  L8 w0.114: v3(92.47,45.61) 92.47,45.2 92.5,45.16 92.5,44.52 94.53,42.49 94.53,40.84 94.52,40.83 94.52,35.52 94.49,35.49 94.49,33.54 99.12,28.91 103.07,28.91 v3(103.49,28.49)
  BOTTOM w0.152: CPU1.BA32 v3(92.47,45.61)
M_B_DQ49: length 27.6
  TOP w0.14: v3(102.53,29.3) 102.84,29.61 102.84,29.8 103.03,29.99 103.99,29.99 104.13,29.85 104.13,28.4 RAM4.C11
  L8 w0.114: v3(92.53,46.22) 92.54,46.22 92.54,46.11 92.89,45.76 92.89,44.42 94.79,42.52 94.79,41.39 95.47,40.71 95.47,33.09 99.26,29.3 v3(102.53,29.3)
  BOTTOM w0.152: CPU1.BA31 92.5,46.24 92.5,46.24 92.52,46.23 92.54,46.23 92.54,46.22 v3(92.53,46.22)
M_B_DQ50: length 29.2
  TOP w0.127: v3(103.48,26.06) 103.81,25.73 RAM4.B8
  L8 w0.114: v3(103.48,26.06) 103.5,26.06 103.91,26.47 104.29,26.47 104.65,26.82 105.1,26.82 105.61,27.34 105.61,30.2 104.46,31.35 101.48,31.35 97.87,34.96 97.87,41.84 97.21,42.5 96.93,42.5 95.21,44.23 95.21,44.6 94.63,45.18 94.63,45.19 94.6,45.22 94.6,45.75 94.22,46.13 v3(94.22,46.26)
  BOTTOM w0.152: CPU1.BD31 v3(94.22,46.26)
M_B_DQ51: length 27.3
  TOP w0.127: v3(104.13,26.85) 104.46,26.52 RAM4.C9
  L8 w0.114: v3(94.22,45.59) 94.22,45.32 94.4,45.14 94.4,45.13 94.43,45.11 94.43,45.1 95.01,44.52 95.01,44.03 96.08,42.96 96.08,42.88 96.33,42.63 96.33,42.29 97.12,41.5 97.13,41.5 97.51,41.12 97.51,34.8 101.33,30.98 104.54,30.98 105.41,30.11 105.41,27.42 105.02,27.03 104.27,27.03 104.13,26.89 104.13,26.85 v3(104.13,26.85)
  BOTTOM w0.152: CPU1.BD32 v3(94.22,45.59)
M_B_DQ52: length 28
  TOP w0.127: v3(104.13,27.69) 104.46,27.36 RAM4.C10
  L8 w0.114: v3(104.13,27.69) 103.74,28.08 99.43,28.08 94.13,33.38 94.13,37.12 94.15,37.15 94.15,42.49 92.3,44.34 92.3,45.06 92.08,45.28 92.08,45.83 92.09,45.84 92.14,45.89 92.14,46.65 v3(92.43,46.94)
  BOTTOM w0.152: CPU1.BA30 v3(92.43,46.94)
M_B_DQ53: length 28.5
  TOP w0.127: RAM4.B10 103.81,27.35 v3(103.48,27.68)
  L8 w0.114: v3(92.43,47.58) 91.93,47.08 91.93,46.77 91.93,46.77 91.93,46.49 91.93,46.48 91.93,45.97 91.88,45.92 91.88,45.17 92.08,44.97 92.08,44.15 93.8,42.44 93.8,41.39 93.78,41.37 93.78,37.3 93.76,37.27 93.76,33.23 99.31,27.68 v3(103.48,27.68)
  BOTTOM w0.152: CPU1.BA29 v3(92.43,47.58)
M_B_DQ54: length 30.1
  TOP w0.152: RAM4.B9 103.79,26.49 103.79,26.53 v3(103.46,26.86)
  L8 w0.114: v3(103.46,26.86) 103.45,26.86 103.45,26.85 103.86,27.26 104.96,27.26 105.2,27.51 105.2,30.03 104.62,30.61 101.18,30.61 96.63,35.16 96.63,41.22 95.87,41.98 95.87,42.88 94.34,44.41 94.34,44.78 93.83,45.29 93.83,47.01 v3(94.27,47.45)
  BOTTOM w0.152: v3(94.27,47.45) 94.27,47.46 93.83,47.71 CPU1.BD29
M_B_DQ55: length 32
  TOP w0.152: RAM4.C8 104.46,25.67 104.18,26.02 104.11,26.09 104.11,26.08 v3(104.12,26.08)
  L8 w0.114: v3(104.12,26.08) 104.11,26.08 104.11,26.09 104.2,26.09 104.57,26.46 104.61,26.46 106.87,26.46 107.13,26.73 107.14,26.75 107.14,27.84 106.92,28.06 106.62,28.06 106.36,28.32 106.36,29.73 104.34,31.76 101.6,31.76 98.69,34.66 98.69,37.17 99,37.47 99,41.01 97.29,42.71 97.02,42.71 95.41,44.31 95.41,44.68 94.83,45.27 94.83,45.81 94.59,46.44 94.48,46.58 v3(94.23,46.86)
  BOTTOM w0.152: CPU1.BD30 v3(94.23,46.86)
M_B_DQ56: length 28.7
  TOP w0.152: RAM4.M10 110.31,27.27 110.31,27.15 110.01,26.85 v3(109.98,26.85)
  L8 w0.114: v3(96.01,46.86) 96.01,46.73 96.51,46.23 96.51,45.49 96.58,45.3 97.06,44.83 97.06,44.78 98.98,42.86 98.98,42.32 100.09,41.2 100.09,37.47 100.63,36.92 100.63,35.87 101.12,35.39 101.12,34.74 102.91,32.95 106,32.95 106.22,32.73 108.9,30.05 108.9,28.34 109.33,27.91 109.33,27.5 v3(109.98,26.85)
  BOTTOM w0.152: CPU1.BG31 95.94,46.86 v3(96.01,46.86)
M_B_DQ57: length 29.8
  TOP w0.152: v3(110.63,26.08) 110.63,26.09 110.31,26.4 110.31,26.47 RAM4.M9
  L8 w0.114: v3(96.01,46.18) 96.01,45.59 96.86,44.74 96.86,44.69 98.77,42.77 98.77,42.23 99.86,41.14 99.86,36.53 99.75,36.42 99.75,34.74 101.91,32.58 105.85,32.58 108.58,29.85 108.58,28.34 109.1,27.81 109.1,27.18 110.2,26.08 v3(110.63,26.08)
  BOTTOM w0.152: v3(96.01,46.18) 95.72,45.89 CPU1.BG32
M_B_DQ58: length 25.6
  TOP w0.152: v3(110.63,28.47) 110.63,28.4 110.96,28.07 RAM4.N11
  L8 w0.114: v3(110.63,28.47) 110.03,29.07 110.03,31.46 109.69,31.8 109.69,31.97 108.68,32.98 108.68,33.14 109.06,33.51 109.06,33.67 108.89,33.83 108.73,33.83 108.36,33.46 108.2,33.46 107.73,33.93 107.73,36.13 107.46,36.4 106.49,36.4 102.27,40.62 102.27,41.25 99.29,44.23 98.91,44.23 97.88,45.26 v3(97.88,45.65)
  BOTTOM w0.152: CPU1.BK32 97.66,45.89 97.88,45.67 v3(97.88,45.65)
M_B_DQ59: length 27
  TOP w0.152: v3(110.64,27.67) 110.64,27.67 110.64,27.74 110.31,28.07 RAM4.M11
  L8 w0.076: v3(97.89,46.27) 97.89,46.16 98.25,45.8 98.25,45.5 98.23,45.49
  L8 w0.114: 98.23,45.49 99.29,44.43 101.22,44.43 103.1,42.55 103.1,40.37 106.78,36.68 107.7,36.68 108.13,36.25 108.13,35.21 110.92,32.43 110.92,31.63 111.02,31.53 111.02,28.04 v3(110.64,27.67)
  BOTTOM w0.152: v3(97.89,46.27) 97.62,46.54 CPU1.BK31
M_B_DQ60: length 33
  TOP w0.152: RAM4.M8 110.31,25.67 110.35,25.49 110.17,25.19 v3(109.99,25.15)
  L8 w0.114: v3(109.99,25.15) 109.61,25.46 109.6,25.46 109.5,25.56 109.37,25.56 109.28,25.6 108.88,25.88 108.33,26.43 108.24,26.47 107.96,26.47 107.88,26.5 107.64,26.74 107.58,26.98 107.58,29.76 105.13,32.21 101.76,32.21 99.37,34.6 99.37,37 99.58,37.2 99.58,41.03 99.37,41.23 99.37,41.31 96.52,44.16 96.27,44.16 96.03,44.4 96.03,44.65 95.62,45.06 95.62,47.26 95.69,47.64 v3(96.04,48.2)
  BOTTOM w0.152: v3(96.04,48.2) 95.68,47.84 CPU1.BG29
M_B_DQ61: length 30.1
  TOP w0.152: RAM4.N9 110.96,26.52 v3(110.63,26.85)
  L8 w0.114: v3(110.63,26.85) 110.22,27.26 109.86,27.26 109.54,27.59 109.54,27.99 109.18,28.35 109.18,30.88 106.74,33.32 103.06,33.32 101.49,34.9 101.49,36.11 101.69,36.31 101.69,36.84 100.4,38.12 100.4,41.18 99.65,41.93 99.65,42.47 97.34,44.78 96.91,45.83 96.91,45.85 96.81,46.07 96.81,46.23 96.39,46.65 96.39,47.11 v3(96.06,47.45)
  BOTTOM w0.152: CPU1.BG30 95.87,47.45 v3(96.06,47.45)
M_B_DQ62: length 28.4
  TOP w0.152: RAM4.N10 110.96,27.27 111.29,26.94 v3(111.29,26.85)
  L8 w0.076: v3(97.89,46.93) 97.89,46.9 98.26,46.54 98.26,46.05 98.58,45.73 98.58,45.46
  L8 w0.114: 98.58,45.46 99.4,44.63 101.31,44.63 103.3,42.64 103.3,40.74 107.03,37.01 107.89,37.01 108.5,36.41 108.5,35.36 111.29,32.58 v3(111.29,26.85)
  BOTTOM w0.152: CPU1.BK30 97.7,46.93 v3(97.89,46.93)
M_B_DQ63: length 31.2
  TOP w0.152: v3(111.28,26.08) 111.28,26.09 111.29,26.1 111.29,26.14 111.61,26.47 RAM4.P9
  L8 w0.076: 98.9,45.68 98.72,45.86 98.68,45.86 98.45,46.09 98.45,46.58 98.39,46.64 98.39,47.09 v3(97.9,47.58)
  L8 w0.114: 98.9,45.68 98.9,45.44 99.45,44.89 102.02,44.89 104.97,41.94 104.97,39.43 107,37.39 108.03,37.39 108.87,36.56 108.87,35.52 111.48,32.91 111.6,32.91 112.3,32.2 112.3,27.1 v3(111.28,26.08)
  BOTTOM w0.152: CPU1.BK29 97.64,47.84 v3(97.9,47.58)
M_B_DQS_DN0: length 20
  TOP w0.14: RAM3.G11 87.88,28.07 88.12,28.07 88.21,28.15 88.21,28.2 88.22,28.22 88.22,28.48 v3(88.22,28.48)
  L3 w0.114: v3(88.22,28.48) 88.22,28.48 88.22,28.22 87.88,27.88 87.58,27.88 87.08,28.37 87.08,31.02 86.5,31.6 86.5,33.01 86.26,33.25 86.21,33.25 86.09,33.36 86.09,33.59 86.21,33.7 86.26,33.7 86.5,33.94 86.5,40.18 86.77,40.45 86.96,40.45 v3(87.17,40.24)
  BOTTOM w0.076: CPU1.AP35 87.58,43.82 87.54,43.71 87.38,43.33 87.38,43.12 87.44,42.97 87.44,42.16 87.75,41.85 87.75,41.02 87.54,40.81 87.54,40.34 87.44,40.24 v3(87.17,40.24)
