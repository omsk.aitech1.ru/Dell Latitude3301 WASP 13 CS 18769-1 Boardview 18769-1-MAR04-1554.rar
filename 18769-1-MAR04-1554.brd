# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD6: length 27.6
  BOTTOM w0.114: VRAM1.K4 184.62,56.24 184.62,55.48 183.48,54.34 177.56,54.34 176.03,55.86 176.03,55.91 174.54,57.41 174.54,64.12 172.21,66.45 169.78,66.45 169.46,66.12 169.33,66.12 168.73,65.53 GPU1.F25
FBA_CMD7: length 25.4
  BOTTOM w0.114: VRAM1.K5 183.28,54.74 177.51,54.74 176.2,56.05 176.2,56.35 174.97,57.59 174.97,64.32 172.6,66.68 169.7,66.68 169.35,66.33 168.87,66.33 168.64,66.1
FBA_CMD8: length 27
  TOP w0.114: v2(166.36,64.42) 166.36,64.98 167.41,66.02 168.06,66.02 168.57,66.53 172.01,66.53 175.11,63.43 177.58,63.43 177.85,63.16 178.01,63.16 178.36,63.51 178.52,63.51 178.68,63.35 178.68,63.19 178.33,62.84 178.33,62.68 178.5,62.52 178.66,62.52 179,62.86 179.17,62.86 179.33,62.7 179.33,62.54 178.98,62.19 178.98,62.03 180.85,60.16 181.86,60.16 182.1,59.92 182.1,59.45 182.41,59.15 182.59,59.15 183.91,57.82 v2(183.91,56.97)
  BOTTOM w0.114: GPU1.F23 166.93,64.42 v2(166.36,64.42) ; VRAM1.J4 v2(183.91,56.97)
FBA_CMD9: length 31
  TOP w0.114: v2(165.8,64.99) 167.09,66.28 167.64,66.28 168.24,66.88 172.3,66.88 174.47,64.71 175.38,64.71 175.53,64.85 181.89,64.85 185.33,61.41 185.33,57.47 v2(183.14,55.28)
  BOTTOM w0.114: VRAM1.J5 183.5,55.64 v2(183.14,55.28) ; GPU1.G22 165.79,64.97 v2(165.8,64.99)
FBA_CMD10: length 25.7
  TOP w0.114: v2(183.08,56.95) 181.05,58.97 179.81,58.97 179.46,59.33 179.46,59.66 178.68,60.43 178.52,60.43 178.05,59.95 177.88,59.95 177.72,60.12 177.72,60.28 178.2,60.75 178.2,60.92 178.04,61.08 177.87,61.08 177.4,60.6 177.24,60.6 177.08,60.76 177.08,60.92 177.55,61.4 177.55,61.56 177.39,61.72 177.23,61.72 176.75,61.25 176.59,61.25 176.43,61.41 176.43,61.57 176.9,62.05 176.9,62.21 176.6,62.51 174.81,62.51 171.98,65.34 167.95,65.34 167.57,64.96 v2(166.95,64.96)
  BOTTOM w0.114: GPU1.G23 166.39,64.96 v2(166.95,64.96) ; VRAM1.H4 183.04,56.9 183.04,56.92 v2(183.08,56.95)
FBA_CMD11: length 26.2
  TOP w0.114: v2(182.28,55.28) 183.49,56.49 183.49,57.54 183.53,57.58 183.53,57.92 183.07,58.37 182.29,58.37 180.75,59.91 180.49,59.91 179.52,60.89 179.35,60.89 179.18,60.71 179.01,60.71 178.85,60.87 178.85,61.03 179.03,61.21 179.03,61.37 178.87,61.53 178.71,61.53 178.53,61.36 178.37,61.36 178.21,61.52 178.21,61.68 178.38,61.86 178.38,62.02 178.22,62.18 178.06,62.18 177.88,62 177.72,62 177.56,62.16 177.56,62.33 177.74,62.5 177.74,62.67 177.43,62.97 174.96,62.97 171.73,66.21 169.54,66.21 168.97,65.64 167.61,65.64 v2(167.5,65.53)
  BOTTOM w0.114: VRAM1.H5 182.7,55.7 v2(182.28,55.28) ; v2(167.5,65.53) GPU1.G24
FBA_CMD12: length 24
  BOTTOM w0.114: GPU1.F27 169.53,66.98 172.78,66.98 173.22,66.55 176.73,66.55 176.95,66.34 176.95,66.17 176.09,65.31 176.09,65.15 176.29,64.95 176.45,64.95 177.32,65.82 177.48,65.82 177.64,65.66 177.64,65.49 176.8,64.65 176.8,64.44 178.6,62.64 180.66,62.64 182.1,61.2 182.1,59.22 182.22,59.09 182.22,57.68 VRAM1.G3
FBA_CMD13: length 29.2
  TOP w0.114: R7820.1 180.61,61.39 181.41,60.59 182.04,60.59 182.58,60.05 v2(182.58,59.56)
  BOTTOM w0.114: 167.51,66.1 168.11,66.1 169.43,67.42 172.99,67.42 173.42,66.98 176.92,66.98 178.33,65.58 178.33,65.41 177.48,64.56 177.48,64.38 177.62,64.24 177.81,64.24 178.66,65.09 178.82,65.09 178.98,64.93 178.98,64.77 178.18,63.96 178.18,63.8 178.9,63.07 180.84,63.07 182.58,61.33 v2(182.58,59.56) 183.14,59 183.14,58.52 183.14,58.52 VRAM1.J2
FBA_CMD14: length 28.8
  TOP w0.114: v2(183.9,58.56) 183.9,60.62 182.99,61.53 R7816.2
  BOTTOM w0.114: GPU1.G27 169.26,67.85 173.17,67.85 173.6,67.42 177.1,67.42 179.67,64.85 179.67,64.69 178.88,63.89 178.88,63.73 179.04,63.57 179.2,63.57 180,64.36 180.16,64.36 180.33,64.19 180.33,63.61 180.43,63.51 180.66,63.51 181.01,63.51 183.9,60.62 v2(183.9,58.56) 183.9,57.76 VRAM1.J3
FBA_CMD15: length 24.3
  BOTTOM w0.114: VRAM1.L3 185.42,57.68 185.42,59.71 177.28,67.85 173.78,67.85 173.34,68.28 169.22,68.28 168.08,67.14 GPU1.G26
FBA_CMD16: length 35.7
  BOTTOM w0.114: GPU1.M24 164,68.47 164,69.13 166,71.12 166,72.69 165.81,72.88 165.13,72.88 165.01,72.99 165.01,74.22 164.9,74.33 164.57,74.33 164.45,74.22 164.45,73.46 164.34,73.35 164.13,73.35 164.02,73.46 164.02,74.67 164.31,74.96 168.23,74.96 170.94,77.67 170.94,80.05 171.06,80.17 171.28,80.17 171.4,80.05 171.4,78.58 171.51,78.47 171.73,78.47 171.86,78.59 171.86,79.57 171.95,79.66 172.2,79.66 172.31,79.55 172.31,78.86 172.43,78.75 175.4,78.75 175.51,78.86 175.51,79.07 175.63,79.18 175.86,79.18 175.97,79.07 175.97,78.86 176.09,78.75 176.31,78.75 176.43,78.86 176.43,79.07 176.54,79.18 176.77,79.18 176.89,79.07 176.89,78.86 177,78.75 177.69,78.75 177.81,78.87 177.81,79.76 177.98,79.93 177.98,81.29 177.6,81.67 VRAM4.L12
FBA_CMD17: length 38.6
  TOP w0.114: v2(163.43,68.47) 165.04,70.08 165.04,71.36 165.77,72.09 165.77,72.78 165.9,72.9 166.59,72.9 166.71,73.02 166.71,73.27 166.59,73.39 164.3,73.39 164.17,73.51 164.17,74.6 164.29,74.72 164.72,74.72 164.83,74.6 164.83,73.93 164.95,73.82 165.18,73.82 165.29,73.93 165.29,74.6 165.4,74.72 165.63,74.72 165.75,74.6 165.75,73.93 165.86,73.82 166.09,73.82 166.2,73.93 166.2,74.6 166.32,74.72 166.55,74.72 166.66,74.6 166.66,73.93 166.78,73.82 167,73.82 167.12,73.93 167.12,74.6 167.23,74.72 167.72,74.72 170.8,77.81 170.8,78.8 170.92,78.91 171.22,78.91 171.33,79.02 171.33,80.28 171.45,80.4 171.68,80.4 171.79,80.28 171.79,79.02 171.9,78.91 172.57,78.91 172.69,78.8 172.69,78.66 172.8,78.54 173.03,78.54 173.14,78.66 173.14,78.8 173.26,78.91 173.49,78.91 173.6,78.8 173.6,78.66 173.72,78.54 173.94,78.54 174.06,78.66 174.06,78.8 174.17,78.91 174.4,78.91 174.52,78.8 174.52,78.66 174.63,78.54 174.86,78.54 174.97,78.66 174.97,78.8 175.09,78.91 175.32,78.91 175.43,78.8 175.43,78.66 175.54,78.54 175.77,78.54 175.89,78.66 175.89,78.8 176,78.91 176.23,78.91 176.34,78.8 176.34,78.66 176.46,78.54 176.69,78.54 176.8,78.66 176.8,78.8 176.92,78.91 177.41,78.91 177.75,78.57 178.1,78.57 178.22,78.68 v2(178.22,79.51)
  BOTTOM w0.114: v2(178.22,79.51) 178.4,79.69 VRAM4.K10 ; GPU1.M23 163.44,68.46 v2(163.43,68.47)
FBA_CMD18: length 38.4
  TOP w0.114: v2(178.82,80.46) 178.82,78.96 178.98,78.79 179.32,78.79 179.43,78.68 179.43,78.36 179.31,78.24 172.53,78.24 172.23,77.93 172.07,77.93 171.88,78.11 171.72,78.11 171.56,77.95 171.56,77.79 171.74,77.61 171.74,77.45 171.58,77.28 171.42,77.28 171.24,77.47 171.08,77.47 170.91,77.31 170.91,77.14 171.1,76.96 171.1,76.8 170.93,76.64 170.77,76.64 170.59,76.82 170.43,76.82 170.27,76.66 170.27,76.5 170.45,76.31 170.45,76.15 170.29,75.99 170.13,75.99 169.94,76.17 169.78,76.17 169.62,76.01 169.62,75.85 169.8,75.67 169.8,75.51 169.64,75.34 169.48,75.34 169.3,75.53 169.14,75.53 168.97,75.37 168.97,75.2 169.16,75.02 169.16,74.86 168.99,74.7 168.83,74.7 168.65,74.88 168.49,74.88 168.33,74.72 168.33,74.56 168.51,74.37 168.51,74.21 168.35,74.05 168.19,74.05 168,74.23 167.84,74.23 167.68,74.07 167.68,73.91 167.86,73.73 167.86,73.57 167.7,73.4 167.54,73.4 167.44,73.5 167.28,73.5 167.12,73.34 167.12,73.18 167.41,72.89 167.4,72.49 167.22,72.32 166.34,72.32 166.23,72.2 166.23,72.03 166.4,71.87 167.34,71.87 167.45,71.76 167.45,71.53 167.34,71.41 166.29,71.41 166.18,71.3 166.18,71.07 166.29,70.96 167.34,70.96 167.45,70.84 167.45,70.61 167.34,70.5 166.83,70.5 166.71,70.38 166.71,69.61 166.6,69.5 166.46,69.5 165.78,70.17 165.62,70.17 165.47,70.02 165.47,69.86 166.21,69.11 166.21,68.95 166.04,68.77 165.88,68.77 165.25,69.4 165.09,69.4 164.93,69.24 164.93,69.08 165.55,68.45 165.55,68.29 v2(165.16,67.9)
  BOTTOM w0.114: 165.19,67.28 165.19,67.87 v2(165.16,67.9) ; VRAM4.K11 178.4,80.87 178.41,80.87 v2(178.82,80.46)
FBA_CMD19: length 38.8
  TOP w0.114: v2(164.61,67.29) 165.14,67.29 165.8,67.95 165.92,67.95 167.88,69.91 167.88,72.97 172.66,77.75 179.17,77.75 179.29,77.64 179.29,77.31 179.4,77.2 179.63,77.2 179.74,77.31 179.74,77.64 179.86,77.75 180.09,77.75 180.2,77.64 180.2,77.31 180.31,77.2 180.54,77.2 180.66,77.31 180.66,77.64 180.77,77.75 181,77.75 181.11,77.64 181.11,77.31 181.23,77.2 181.46,77.2 181.57,77.31 181.57,77.64 181.69,77.75 181.91,77.75 182.03,77.64 182.03,77.31 182.14,77.2 182.37,77.2 182.49,77.31 182.49,77.64 182.6,77.75 182.83,77.75 182.94,77.64 182.94,77.31 183.06,77.2 183.29,77.2 183.4,77.31 183.4,77.64 183.51,77.75 184.5,77.75 184.69,77.94 184.69,78.3 184.58,78.41 180.33,78.41 179.65,79.09 179.65,80.43 v2(179.61,80.47)
  BOTTOM w0.114: VRAM4.H11 180,80.86 v2(179.61,80.47) ; v2(164.61,67.29) 164.63,67.27 GPU1.K23
FBA_CMD20: length 37.2
  BOTTOM w0.114: VRAM4.H10 180,79.15 180.86,78.29 184.91,78.29 185.03,78.17 185.03,77.97 184.89,77.83 180.66,77.83 180.09,78.4 179.68,78.4 179.59,78.49 179.59,78.85 179.46,78.97 179.13,78.97 179.02,78.86 179.02,78.45 178.9,78.34 178.67,78.34 178.56,78.45 178.56,78.86 178.45,78.97 178.22,78.97 178.1,78.86 178.1,78.53 177.99,78.41 172.29,78.41 168.42,74.54 165.51,74.54 165.39,74.43 165.39,74.2 165.51,74.09 166.32,74.09 166.43,73.97 166.43,73.73 166.34,73.63 165.51,73.63 165.39,73.52 165.39,73.29 165.51,73.17 166.27,73.17 166.38,73.06 166.38,70.85 GPU1.M27
FBA_CMD21: length 36.2
  BOTTOM w0.114: VRAM4.G12 180.4,81.27 180.4,79.35 181.04,78.72 182.18,78.72 182.29,78.83 182.29,78.99 182.41,79.11 182.63,79.11 182.75,78.99 182.75,78.83 182.86,78.72 183.09,78.72 183.21,78.83 183.21,78.99 183.32,79.11 183.55,79.11 183.66,78.99 183.66,78.83 183.78,78.72 185.2,78.72 185.54,78.38 185.54,77.74 185.25,77.45 181.57,77.45 181.46,77.34 181.46,77.16 181.34,77.04 181.11,77.04 181,77.16 181,77.34 180.89,77.45 180.45,77.45 179.82,78.08 172.59,78.08 168.42,73.92 167.03,73.92 166.92,73.8 166.92,70.91 165.84,69.83 165.37,69.83 GPU1.M26
FBA_CMD22: length 34.7
  BOTTOM w0.114: GPU1.M25 165.21,69.04 165.74,69.58 165.87,69.58 166.66,70.36 167.21,70.36 167.37,70.53 167.37,73.31 167.5,73.44 167.74,73.44 167.86,73.32 167.86,70.34 168.01,70.19 168.2,70.19 168.31,70.3 168.31,73.3 168.45,73.44 168.63,73.44 168.77,73.3 168.77,71.02 168.93,70.87 169.15,70.87 169.25,70.97 169.25,74.14 172.92,77.81 179.46,77.81 180.32,76.95 180.32,75.59 VRAM4.H4
FBA_CMD23: length 35.8
  BOTTOM w0.114: VRAM4.H5 180.02,76.09 180.02,76.72 179.27,77.46 176.01,77.46 175.89,77.35 175.89,76.88 175.78,76.76 175.55,76.76 175.44,76.88 175.44,77.35 175.32,77.46 175.09,77.46 174.98,77.35 174.98,76.88 174.86,76.76 174.63,76.76 174.52,76.88 174.52,77.35 174.41,77.46 173.19,77.46 170.62,74.9 170.62,72.97 170.74,72.85 171.53,72.85 171.64,72.74 171.64,72.51 171.53,72.4 170.72,72.4 170.6,72.28 170.6,72.05 170.72,71.94 171.53,71.94 171.64,71.82 171.64,71.59 171.53,71.48 170.72,71.48 170.6,71.37 170.6,71.14 170.72,71.02 171.53,71.02 171.64,70.91 171.64,70.68 171.53,70.57 170.28,70.57 170.17,70.68 170.17,74 170.05,74.12 169.84,74.12 169.71,73.99 169.71,70.69 169.56,70.54 169.2,70.54 168.09,69.43 166.86,69.43 166.32,68.89 GPU1.K26
FBA_CMD24: length 42.2
  TOP w0.114: v2(164.63,66.15) 165.2,66.15 165.73,66.69 166.01,66.69 168.09,68.76 173.43,68.76 175.04,70.38 175.04,71.42 174.93,71.53 174.5,71.53 174.38,71.42 174.38,70.43 174.27,70.31 174.04,70.31 173.93,70.43 173.93,71.42 173.81,71.53 173.35,71.53 173.24,71.42 173.24,69.68 173.06,69.5 172.63,69.5 172.5,69.63 172.5,72.81 172.62,72.93 173.43,72.93 173.55,73.04 173.55,73.27 173.43,73.38 172.88,73.38 172.77,73.5 172.77,73.73 172.88,73.84 173.43,73.84 173.55,73.95 173.55,74.18 173.43,74.3 172.88,74.3 172.77,74.41 172.77,75.85 173.02,76.1 177.75,76.1 177.86,75.99 177.86,75.61 177.98,75.49 178.41,75.49 178.52,75.61 178.52,75.91 178.64,76.03 181.09,76.03 181.27,75.85 181.27,75.53 181.15,75.42 179.71,75.42 179.59,75.3 v2(179.59,74.87)
  BOTTOM w0.114: GPU1.K22 164.03,66.12 164.6,66.12 v2(164.63,66.15) ; v2(179.59,74.87) 179.2,75.26 VRAM4.J4
FBA_CMD25: length 37.1
  TOP w0.114: v2(165.19,66.73) 165.35,66.89 165.93,66.89 166.17,67.13 166.17,67.27 168.11,69.22 170.84,69.22 170.95,69.33 170.95,70.05 171.07,70.16 171.3,70.16 171.41,70.05 171.41,69.33 171.53,69.22 171.96,69.22 172.07,69.33 172.07,70.52 171.96,70.63 170.64,70.63 170.52,70.74 170.52,70.97 170.64,71.09 171.96,71.09 172.07,71.2 172.07,71.43 171.96,71.54 170.64,71.54 170.52,71.66 170.52,71.89 170.64,72 171.96,72 172.07,72.12 172.07,72.4 171.96,72.51 170.64,72.51 170.52,72.62 170.52,72.85 170.64,72.97 172.01,72.97 172.12,73.08 172.12,73.35 172.01,73.46 170.71,73.46 170.55,73.63 170.55,73.93 170.66,74.05 171.06,74.05 171.84,74.83 171.84,75.71 173.14,77.01 174.1,77.01 174.81,76.3 175.56,76.3 176.26,77.01 177.41,77.01 177.88,76.54 v2(179.61,76.54)
  BOTTOM w0.114: VRAM4.J5 179.2,76.14 v2(179.61,76.54) ; 165.19,66.15 v2(165.19,66.73)
FBA_CMD26: length 35.9
  TOP w0.114: v2(165.77,66.12) 167.98,68.33 173.61,68.33 175.48,70.2 175.48,71.65 175.59,71.76 175.82,71.76 175.93,71.65 175.93,70.2 176.05,70.08 176.28,70.08 176.39,70.2 176.39,71.65 176.5,71.76 176.73,71.76 176.85,71.65 176.85,70.2 176.96,70.08 177.22,70.08 177.36,70.22 177.36,71.1 177.47,71.22 177.67,71.22 177.79,71.33 177.79,71.56 177.67,71.67 177.47,71.67 177.36,71.79 177.36,72.02 177.47,72.13 177.67,72.13 177.79,72.25 177.79,72.47 177.67,72.59 177.47,72.59 177.36,72.7 177.36,73.36 176.95,73.77 174.05,73.77 173.88,73.94 173.88,74.29 174.04,74.45 177.53,74.45 178.04,73.94 178.68,73.94 178.8,74.06 v2(178.8,74.86)
  BOTTOM w0.114: v2(165.77,66.12) 166.14,66.49 166.14,67.1 166.32,67.28 166.32,67.28 ; v2(178.8,74.86) 178.4,75.26 VRAM4.K4
FBA_CMD27: length 35.7
  TOP w0.114: v2(165.76,67.3) 168.21,69.75 169.98,69.75 170.09,69.87 170.09,70.44 169.98,70.55 168.38,70.55 168.26,70.67 168.26,70.9 168.38,71.01 170,71.01 170.12,71.13 170.12,71.35 170,71.47 168.38,71.47 168.26,71.58 168.26,71.81 168.38,71.93 170,71.93 170.12,72.04 170.12,72.27 170,72.38 168.38,72.38 168.26,72.5 168.26,72.73 168.38,72.84 170,72.84 170.12,72.95 170.12,73.18 170,73.3 169.24,73.3 169.13,73.41 169.13,73.61 169.27,73.75 170,73.75 170.12,73.87 170.12,74.6 170.48,74.96 170.64,74.96 170.92,74.68 171.08,74.68 171.25,74.85 171.25,75.01 170.97,75.29 170.97,75.45 172.88,77.36 174.82,77.36 174.93,77.25 174.93,76.8 175.04,76.69 175.27,76.69 175.39,76.8 175.39,77.25 175.5,77.36 178.4,77.36 v2(178.71,77.05)
  BOTTOM w0.114: VRAM4.K5 178.4,76.74 v2(178.71,77.05) ; GPU1.J24 165.76,66.72 v2(165.76,67.3)
FBA_CMD28: length 34.5
  BOTTOM w0.114: GPU1.K27 166.89,68.98 166.94,69.03 168.19,69.03 169.25,70.08 171.98,70.08 172.09,70.2 172.09,71.62 172.23,71.76 172.43,71.76 172.55,71.65 172.55,70.2 172.66,70.08 172.89,70.08 173,70.2 173,71.32 173.12,71.43 173.35,71.43 173.46,71.32 173.46,70.2 173.58,70.08 173.8,70.08 173.92,70.2 173.92,71.32 174.03,71.43 174.49,71.43 174.6,71.32 174.6,69.72 174.72,69.6 174.95,69.6 175.06,69.72 175.06,71.32 175.18,71.43 175.41,71.43 175.52,71.32 175.52,69.71 175.65,69.58 175.87,69.58 175.98,69.69 175.98,71.34 176.1,71.46 176.29,71.46 176.44,71.3 176.44,69.68 176.54,69.58 176.78,69.58 176.9,69.69 176.9,71.6 176.98,71.68 177.24,71.68 177.36,71.57 177.36,70.35 177.47,70.24 177.7,70.24 177.81,70.35 177.81,71.76 177.26,72.31 177.26,74.13 177.6,74.47 VRAM4.L3
FBA_CMD29: length 39.5
  TOP w0.114: v2(178.78,73.25) 178.78,72.21 178.45,71.88 R7821.1
  BOTTOM w0.114: GPU1.K25 166.36,67.85 167.3,68.79 168.39,68.79 169.25,69.65 174.05,69.65 174.56,69.14 179.13,69.14 179.29,68.99 179.29,68.51 179.39,68.41 179.68,68.41 179.79,68.52 179.79,69.04 179.9,69.14 180.21,69.14 180.33,69.03 180.33,68.52 180.44,68.41 180.67,68.41 180.78,68.52 180.78,69.03 180.9,69.14 181.13,69.14 181.24,69.03 181.24,68.52 181.36,68.41 181.58,68.41 181.7,68.52 181.7,69.47 181.57,69.6 181.1,69.6 180.99,69.72 180.99,70.48 180.87,70.59 180.64,70.59 180.53,70.48 180.53,69.72 180.42,69.6 180.19,69.6 180.07,69.72 180.07,71.39 179.96,71.51 179.73,71.51 179.62,71.39 179.62,69.73 179.49,69.6 178.37,69.6 178.24,69.73 178.24,70.5 178.36,70.61 178.59,70.61 178.7,70.5 178.7,70.17 178.82,70.06 179.04,70.06 179.16,70.17 179.16,70.96 179.04,71.07 178.36,71.07 178.24,71.19 178.24,71.62 178.78,72.15 v2(178.78,73.25) VRAM4.J2
FBA_CMD30: length 39.8
  TOP w0.114: v2(179.59,74.06) 179.59,73.45 180.07,72.97 R7824.2
  BOTTOM w0.114: VRAM4.J3 179.59,74.08 v2(179.59,74.06) 179.59,72.52 182.21,69.91 182.59,69.91 182.82,69.91 183.05,69.68 183.05,68.06 182.93,67.95 182.7,67.95 182.59,68.06 182.59,69.33 182.47,69.45 182.25,69.45 182.13,69.33 182.13,67.61 182.25,67.49 182.93,67.49 183.05,67.38 183.05,67.15 182.93,67.04 181.79,67.04 181.67,67.15 181.67,67.84 181.56,67.95 179.53,67.95 179.41,67.84 179.41,67.61 179.53,67.49 181.1,67.49 181.22,67.38 181.22,67.15 181.1,67.04 179.32,67.04 178.95,67.41 178.95,68.06 178.3,68.71 174.33,68.71 173.82,69.22 169.2,69.22 168.39,68.42 GPU1.J27
FBA_CMD31: length 36.6
  BOTTOM w0.114: GPU1.J26 167.42,67.85 167.71,68.14 168.5,68.14 169.07,68.71 173.65,68.71 174.08,68.28 178.12,68.28 178.51,67.89 178.51,67.23 179.49,66.25 179.65,66.25 179.94,66.55 180.1,66.55 180.25,66.4 180.25,66.21 179.97,65.93 179.97,65.77 180.33,65.41 180.61,65.41 180.72,65.52 180.72,66.47 180.84,66.59 181.06,66.59 181.18,66.47 181.18,65.52 181.29,65.41 181.52,65.41 181.64,65.52 181.64,66.49 181.75,66.6 181.97,66.6 182.09,66.48 182.09,65.52 182.21,65.41 182.44,65.41 182.55,65.52 182.55,66.49 182.66,66.6 182.89,66.6 183.01,66.48 183.01,65.52 183.12,65.41 183.35,65.41 183.48,65.54 183.48,70.03 183.17,70.34 182.39,70.34 181.12,71.6 181.12,74.15 VRAM4.G3
FBA_D0: length 16
  L8 w0.089: v2(164.06,60.77) 165.78,60.77 166.23,60.32 166.23,59.92 170.01,56.14 v2(176.7,56.14)
  BOTTOM w0.114: VRAM1.A4 176.95,56.56 176.7,56.3 176.7,56.14 v2(176.7,56.14) ; GPU1.E18 164.1,60.81 v2(164.06,60.77)
FBA_D1: length 16.2
  L3 w0.089: v2(175.89,57.64) 168.85,57.64 167.37,59.12 167.16,59.12 166.66,59.62 166.66,59.88 165.17,61.37 v2(163.45,61.37)
  BOTTOM w0.114: GPU1.F18 164.01,61.37 v2(163.45,61.37) ; VRAM1.A2 176.67,58.16 176.1,57.59 175.94,57.59 v2(175.89,57.64)
FBA_D2: length 18.2
  L8 w0.089: v2(162.85,59.63) 163.4,59.63 163.87,60.1 165.29,60.1 166.46,58.93 166.72,58.93 167.49,58.16 167.49,57.9 169.74,55.66 176.99,55.66 v2(177.5,56.16)
  BOTTOM w0.114: VRAM1.B4 177.9,56.56 v2(177.5,56.16) ; v2(162.85,59.63) 162.87,59.62 163.44,59.62 GPU1.E16
FBA_D3: length 18.4
  L3 w0.089: v2(176.57,56.95) 176.5,56.88 169.04,56.88 167.17,58.76 166.67,58.76 166.5,58.93 166.46,58.93 164.22,61.17 163.81,61.17 163.53,60.89 v2(162.87,60.89)
  BOTTOM w0.114: VRAM1.B2 177.49,57.75 176.94,57.75 176.44,57.24 176.44,57.08 v2(176.57,56.95) ; GPU1.F17 163.44,60.81 162.96,60.81 v2(162.87,60.89)
FBA_D4: length 18.4
  L8 w0.089: v2(166.94,61.43) 167.53,61.43 167.91,61.05 168.24,61.05 168.47,61.27 168.82,61.27 169.51,60.58 174.33,60.58 176.53,58.38 179.85,58.38 181.1,57.12 181.1,56.56 v2(180.7,56.16)
  BOTTOM w0.114: v2(180.7,56.16) 180.3,56.56 VRAM1.E4 ; GPU1.D20 166.39,61.43 v2(166.94,61.43)
FBA_D5: length 17.2
  L8 w0.089: v2(180.71,58.56) 180.4,58.87 176.57,58.87 174.42,61.02 171.04,61.02 170.45,61.61 170.31,61.61 169.93,61.99 169.2,61.99 168.84,61.63 168.51,61.63 168.16,61.98 v2(166.36,61.98)
  BOTTOM w0.114: GPU1.D21 166.94,61.99 166.37,61.99 v2(166.36,61.98) ; VRAM1.E2 180.31,58.16 v2(180.71,58.56)
FBA_D6: length 23.1
  L8 w0.089: v2(164.62,62.56) 165.2,62.56 165.61,62.15 165.96,62.15 166.24,62.43 169.77,62.43 170.16,62.05 170.84,62.05 171.35,62.56 178.09,62.56 181.5,59.15 v2(181.5,56.16)
  BOTTOM w0.114: 165.19,62.56 165.19,62.56 164.62,62.56 v2(164.62,62.56) ; v2(181.5,56.16) 181.1,56.56 VRAM1.F4
FBA_D7: length 20.4
  L8 w0.089: v2(181.69,59.75) 181.15,59.75 180.85,60.05 180.85,60.3 178.23,62.91 172.63,62.91 172.52,62.8 171.23,62.8 170.7,62.27 170.4,62.27 169.96,62.72 165.95,62.72 v2(165.78,62.55)
  BOTTOM w0.114: GPU1.E21 166.38,62.56 165.78,62.56 v2(165.78,62.55) ; VRAM1.F2 181.14,58.16 181.48,58.5 181.48,59.54 v2(181.69,59.75)
FBA_D8: length 18.7
  L8 w0.089: v2(176.64,51.38) 168.66,51.38 164.88,55.16 164.88,55.5 163.98,56.4 163.98,57.08 162.85,58.2 v2(162.85,58.48)
  BOTTOM w0.114: v2(176.64,51.38) 177.06,50.96 VRAM1.A11 ; GPU1.E15 162.87,59.05 162.85,59.03 v2(162.85,58.48)
FBA_D9: length 19.8
  L8 w0.089: v2(162.84,57.34) 163.4,57.34 163.8,56.95 163.8,56.33 164.7,55.43 164.7,54.84 169.24,50.3 173.17,50.3 174.22,49.26 v2(175.72,49.26)
  BOTTOM w0.114: GPU1.D15 163.44,58.49 163.44,57.93 162.83,57.33 162.83,57.34 v2(162.84,57.34) ; VRAM1.A13 175.82,49.36 v2(175.72,49.26)
FBA_D10: length 20.4
  L8 w0.089: v2(162.25,59.04) 162.87,59.04 163.46,58.44 163.46,57.89 164.15,57.2 164.15,56.48 165.09,55.54 165.09,55.46 168.74,51.8 175.71,51.8 177.06,51.8 v2(177.5,51.36)
  BOTTOM w0.114: v2(177.5,51.36) 177.9,50.96 VRAM1.B11 ; GPU1.F15 162.28,59.65 162.26,59.63 162.26,59.05 v2(162.25,59.04)
FBA_D11: length 22.5
  L3 w0.089: v2(161.08,57.88) 161.71,57.88 162.09,58.26 162.42,58.26 162.59,58.08 164.17,58.08 164.4,58.32 165.12,58.32 175.42,48.02 v2(175.86,48.02)
  BOTTOM w0.114: v2(175.86,48.02) 176.78,48.94 177.48,48.94 VRAM1.B13 ; GPU1.F13 161.09,58.46 161.09,57.89 v2(161.08,57.88)
FBA_D12: length 30.1
  L8 w0.089: v2(162.83,56.19) 162.88,56.14 162.88,54.57 171.84,45.6 180.3,45.6 180.61,45.91 180.61,46.51 180.46,46.66 180.46,50.8 v2(179.9,51.36)
  BOTTOM w0.114: VRAM1.E11 180.3,50.96 v2(179.9,51.36) ; GPU1.C13 162.83,56.72 v2(162.83,56.19)
FBA_D13: length 23.6
  L8 w0.089: v2(163.37,55.61) 163.37,54.58 171.13,46.82 178.98,46.82 179.98,47.82 179.98,48.87 v2(179.89,48.96)
  BOTTOM w0.114: GPU1.B13 163.38,56.17 163.38,55.62 v2(163.37,55.61) ; VRAM1.E13 180.3,49.36 v2(179.89,48.96)
FBA_D14: length 33.8
  L8 w0.089: v2(180.7,51.37) 180.7,48.44 181.43,47.71 181.43,45.72 180.6,44.89 171.55,44.89 162.17,54.27 162.17,56.26 161.68,56.75 v2(161.68,57.28)
  BOTTOM w0.114: VRAM1.F11 181.1,50.97 v2(180.7,51.37) ; GPU1.E13 161.68,57.86 161.68,57.28 v2(161.68,57.28)
FBA_D15: length 29.3
  L8 w0.089: v2(181.03,47.49) 181.03,45.83 180.45,45.25 171.7,45.25 162.43,54.51 162.43,56.56 v2(162.26,56.74)
  BOTTOM w0.114: VRAM1.F13 180.76,49.02 180.76,47.76 v2(181.03,47.49) ; v2(162.26,56.74) 162.25,56.74 GPU1.D13
FBA_D16: length 37.8
  L3 w0.089: v2(190.99,50.56) 190.99,49.67 190.4,49.08 190.4,47.97 187.35,44.91 175.18,44.91 171.34,48.76 171.34,50.09 166.03,55.4 166.03,55.66 165.67,56.02 165.67,56.22 165.1,56.8 v2(164.57,56.8)
  BOTTOM w0.114: VRAM1.U11 189.95,51.01 190.54,51.01 v2(190.99,50.56) ; GPU1.B15 164.57,56.8 v2(164.57,56.8)
FBA_D17: length 36
  L3 w0.089: v2(190.42,49.77) 189.38,48.73 189.38,47.49 187.16,45.27 175.33,45.27 171.69,48.91 171.69,50.25 165.85,56.09 165.85,56.32 164.57,57.6 v2(164.57,57.92)
  BOTTOM w0.114: v2(190.42,49.77) 190.01,49.36 VRAM1.U13 ; v2(164.57,57.92) GPU1.C16
FBA_D18: length 41.2
  L3 w0.089: v2(163.95,55.06) 167.11,51.9 167.11,51.52 173.8,44.82 173.8,44.35 174.01,44.14 188.04,44.14 191.42,47.52 191.42,50.73 190.79,51.36 v2(188.7,51.36)
  BOTTOM w0.114: VRAM1.T11 v2(188.7,51.36) ; v2(163.95,55.06) GPU1.A13
FBA_D19: length 36.5
  L3 w0.089: v2(190.81,48.84) 190.81,47.88 187.49,44.56 175.04,44.56 170.72,48.87 170.72,50.1 165.49,55.32 165.49,55.63 v2(165.49,55.63)
  BOTTOM w0.114: GPU1.A15 165.6,56.33 165.6,55.74 165.49,55.63 v2(165.49,55.63) ; VRAM1.T13 189.51,48.95 190.2,48.95 190.31,48.84 v2(190.81,48.84)
FBA_D20: length 30.3
  L3 w0.089: v2(166.33,58.53) 167.14,58.53 169.15,56.53 174.26,56.53 176.29,54.5 183.36,54.5 184.67,53.19 184.67,52.17 185.43,51.41 185.43,49.26 186.13,48.57 186.46,48.57 186.71,48.82 186.71,50.98 v2(187.1,51.36)
  BOTTOM w0.114: v2(166.33,58.53) 166.32,58.53 GPU1.B18 ; v2(187.1,51.36) 186.7,50.96 VRAM1.N11
FBA_D21: length 27.3
  L3 w0.089: v2(167.09,57.99) 168.91,56.17 173.92,56.17 176.28,53.81 183.8,53.81 184.5,53.11 184.5,50.88 185.1,50.27 185.1,49.34 186.05,48.39 186.55,48.39 v2(187.13,48.97)
  BOTTOM w0.114: VRAM1.N13 187.09,48.97 v2(187.13,48.97) ; GPU1.A18 166.89,58.2 v2(167.09,57.99)
FBA_D22: length 27.2
  L3 w0.089: v2(168.52,58.54) 168.52,58.32 168.92,57.92 169.33,57.92 169.45,58.04 175.94,58.04 176.07,58.18 176.64,58.18 176.73,58.27 176.73,58.51 176.82,58.6 176.99,58.6 177.08,58.51 177.08,58.27 177.17,58.18 177.35,58.18 177.44,58.27 177.44,58.51 177.53,58.6 177.71,58.6 177.79,58.51 177.79,58.27 177.88,58.18 178.06,58.18 178.15,58.27 178.15,58.51 178.24,58.6 178.42,58.6 178.51,58.51 178.51,58.27 178.59,58.18 178.77,58.18 178.86,58.27 178.86,58.51 178.95,58.6 179.13,58.6 179.22,58.51 179.22,58.27 179.31,58.18 180.42,58.18 181.01,57.59 181.65,57.59 185.9,53.33 185.9,50.94 v2(186.27,50.57)
  BOTTOM w0.114: VRAM1.M11 185.9,50.94 v2(186.27,50.57) ; GPU1.A19 168.03,58.54 v2(168.52,58.54)
FBA_D23: length 28.8
  L3 w0.089: v2(165.74,60.24) 167.04,58.94 167.3,58.94 169,57.24 176.05,57.24 176.17,57.36 180.86,57.36 181.9,56.33 181.9,55.99 182.14,55.76 183.22,55.76 185.61,53.37 185.61,49.65 v2(186.29,48.97)
  BOTTOM w0.114: GPU1.C19 165.75,60.24 165.75,60.24 v2(165.74,60.24) ; v2(186.29,48.97) 186.29,48.97 VRAM1.M13
FBA_D24: length 29.7
  L3 w0.089: v2(171.22,61.61) 171.33,61.5 172.25,61.5 174.46,63.71 187.9,63.71 191.62,59.98 191.62,57.31 v2(190.68,56.36)
  BOTTOM w0.114: VRAM1.U4 190.48,56.56 v2(190.68,56.36) ; v2(171.22,61.61) 170.75,62.08 170.75,62.21 170.32,62.63 GPU1.B24
FBA_D25: length 27.6
  L3 w0.089: v2(190.46,58.16) 190.76,58.46 190.76,59.83 187.91,62.68 187.91,62.68 187.71,62.89 174.94,62.89 174.65,62.89 172.72,60.96 170.59,60.96 170.45,60.81 169.9,60.81 v2(168.68,62.03)
  BOTTOM w0.114: VRAM1.U2 v2(190.46,58.16) ; GPU1.C23 v2(168.68,62.03)
FBA_D26: length 30.9
  L3 w0.089: v2(171.51,62.16) 171.87,62.51 172.33,62.51 174.52,64.71 187.4,64.71 191.98,60.13 191.98,57.1 190.74,55.86 189.8,55.86 v2(189.5,56.16)
  BOTTOM w0.114: v2(189.5,56.16) 189.1,56.56 VRAM1.T4 ; v2(171.51,62.16) 171.04,62.63 GPU1.A25
FBA_D27: length 28.4
  L3 w0.089: v2(191.2,58.14) 191.2,59.91 187.75,63.35 174.61,63.35 172.46,61.21 v2(170.28,61.21)
  BOTTOM w0.114: GPU1.A24 170.26,61.91 170.26,61.21 170.27,61.21 170.27,61.2 170.28,61.2 v2(170.28,61.21) ; VRAM1.T2 189.54,58.6 190.74,58.6 v2(191.2,58.14)
FBA_D28: length 27.3
  L3 w0.089: v2(169.19,60.25) 169.39,60.45 169.75,60.45 170.24,60.45 170.33,60.36 173.14,60.36 174.4,61.63 182.7,61.63 182.84,61.76 187.7,61.76 189.03,60.44 189.03,58.05 v2(187.11,56.13)
  BOTTOM w0.114: GPU1.A21 168.65,60.3 168.69,60.25 169.18,60.25 169.18,60.25 v2(169.19,60.25) ; v2(187.11,56.13) 186.7,56.54 VRAM1.N4
FBA_D29: length 22.9
  L3 w0.089: v2(187.1,58.55) 187.1,59.68 185.73,61.05 183.13,61.05 183,60.91 174.82,60.91 173.38,59.48 172.03,59.48 171.94,59.39 168.96,59.39 v2(168.05,60.3)
  BOTTOM w0.114: v2(168.05,60.3) 168.08,60.32 GPU1.B21 ; v2(187.1,58.55) 186.7,58.16 VRAM1.N2
FBA_D30: length 22.7
  L3 w0.089: v2(186.29,56.96) 185.58,57.67 185.58,58.25 184.87,58.97 175.73,58.97 175.53,58.77 168.86,58.77 168.68,58.94 168.36,58.94 168,59.3 167.32,59.3 166.94,59.67 v2(166.94,60.23)
  BOTTOM w0.114: v2(186.29,56.96) 185.9,56.56 VRAM1.M4 ; v2(166.94,60.23) 166.92,60.25 GPU1.C20
FBA_D31: length 22.8
  L3 w0.089: v2(186.3,58.55) 186.3,58.98 184.59,60.69 183.28,60.69 183.14,60.56 174.97,60.56 173.53,59.12 168.66,59.12 167.51,60.27 v2(167.51,60.86)
  BOTTOM w0.114: v2(186.3,58.55) 185.91,58.16 VRAM1.M2 ; GPU1.C21 v2(167.51,60.86)
FBA_D32: length 15.7
  L8 w0.089: v2(172.3,75.57) 171.85,75.57 169.3,73.03 165.24,73.03 163.75,71.54 162.99,71.54 v2(160.52,69.07)
  BOTTOM w0.114: GPU1.R22 160.52,69.07 v2(160.52,69.07) ; v2(172.3,75.57) 172.61,75.27 172.8,75.27 VRAM4.U4
FBA_D33: length 13.5
  L8 w0.089: v2(171.63,73.98) 169.67,72.01 165.7,72.01 164.98,71.29 164.33,71.29 164.22,71.18 163.21,71.18 162.26,70.23 v2(162.26,69.62)
  BOTTOM w0.114: v2(171.63,73.98) 172.07,73.54 172.67,73.54 172.8,73.67 VRAM4.U2 ; v2(162.26,69.62) 162.25,69.63 GPU1.R24
FBA_D34: length 18
  L8 w0.089: v2(159.55,69.62) 160.54,69.62 162.67,71.75 162.67,71.81 163.3,72.44 163.36,72.44 164.28,73.36 168.9,73.36 171.51,75.98 172.88,75.98 v2(173.18,75.67)
  BOTTOM w0.114: v2(159.55,69.62) 159.7,69.62 159.7,69.63 GPU1.T22 ; VRAM4.T4 173.6,75.27 173.59,75.27 v2(173.18,75.67)
FBA_D35: length 15.5
  L8 w0.089: v2(172.29,73.98) 171.87,74.4 171.31,74.4 169.56,72.65 165.11,72.65 163.82,71.36 163.14,71.36 161.67,69.89 v2(161.67,69.1)
  BOTTOM w0.114: GPU1.R23 161.68,69.66 161.68,69.12 v2(161.67,69.1) ; v2(172.29,73.98) 172.36,74.05 173.22,74.05 VRAM4.T2
FBA_D36: length 18
  L8 w0.089: v2(176.37,75.69) 176.02,75.33 176.02,72.9 175.6,72.49 175.6,72.17 175.32,71.89 174.77,71.89 172.33,69.44 166.62,69.44 166.21,69.85 164.26,69.85 v2(163.95,70.15)
  BOTTOM w0.114: VRAM4.N4 176.37,75.64 v2(176.37,75.69) ; GPU1.N25 164.01,70.1 163.96,70.15 v2(163.96,70.15)
FBA_D37: length 13.8
  L8 w0.089: v2(164.57,70.72) 164.69,70.59 166.43,70.59 166.79,70.95 170.55,70.95 172.47,72.87 174.17,72.87 174.42,73.12 174.42,73.43 174.65,73.67 175.19,73.67 v2(175.6,73.26)
  BOTTOM w0.114: VRAM4.N2 176,73.67 175.6,73.27 v2(175.6,73.26) ; GPU1.N26 v2(164.57,70.72)
FBA_D38: length 21
  L8 w0.089: v2(162.83,69.02) 163.46,69.02 163.6,68.87 164.78,68.87 165.02,68.64 173.72,68.64 177.59,72.5 177.59,75.24 v2(177.19,75.63)
  BOTTOM w0.114: VRAM4.M4 177.13,75.6 177.23,75.6 177.23,75.62 177.18,75.62 177.18,75.63 v2(177.19,75.63) ; GPU1.N23 162.87,68.96 162.83,69.01 v2(162.83,69.02)
FBA_D39: length 16.7
  L8 w0.089: v2(163.44,69.6) 163.74,69.29 165.95,69.29 166.21,69.04 173.29,69.04 176.42,72.17 v2(176.42,73.25)
  BOTTOM w0.114: v2(163.44,69.6) 163.44,69.04 163.44,69.04 GPU1.N24 ; VRAM4.M2 176.8,73.63 v2(176.42,73.25)
FBA_D40: length 20.6
  L3 w0.089: v2(171.51,80.96) 167.11,76.56 162.97,76.56 160.31,73.9 159.7,73.9 159.49,74.11 159.16,74.11 158.93,73.88 158.93,73.54 159.73,72.74 159.73,72.4 159.37,72.03 v2(159.37,71.38)
  BOTTOM w0.114: GPU1.V23 159.93,71.41 159.4,71.41 v2(159.37,71.38) ; VRAM4.U11 172.8,80.87 172.14,80.87 172.05,80.96 v2(171.51,80.96)
FBA_D41: length 22.2
  L8 w0.089: v2(171.54,81.74) 171.07,81.28 171.07,77.83 168.41,75.16 162.52,75.16 160.62,73.26 160.62,72.88 159.52,71.78 159.2,71.78 158.76,71.34 v2(158.76,70.82)
  BOTTOM w0.114: VRAM4.U13 172.8,82.47 172.76,82.42 171.9,82.42 171.54,82.07 v2(171.54,81.74) ; v2(158.76,70.82) 158.77,70.82 159.34,70.82 GPU1.V22
FBA_D42: length 20.4
  L3 w0.089: v2(160.56,70.21) 160.56,70.71 160.1,71.17 160.1,71.67 160.49,72.06 160.49,73.49 162.85,75.85 167.68,75.85 172.29,80.46 v2(173.2,80.46)
  BOTTOM w0.114: v2(173.2,80.46) 173.6,80.87 VRAM4.T11 ; GPU1.T23 161.12,70.22 160.58,70.22 v2(160.56,70.21)
FBA_D43: length 21.4
  L3 w0.089: v2(173.2,82.07) 172.57,81.44 172.57,81.4 167.37,76.21 163.2,76.21 163.18,76.18 162.88,76.18 160.29,73.59 160.29,72.27 159.77,71.75 159.77,71.21 159.35,70.8 v2(159.35,70.21)
  BOTTOM w0.114: v2(173.2,82.07) 173.6,82.47 VRAM4.T13 ; v2(159.35,70.21) 159.37,70.22 159.93,70.22 GPU1.U22
FBA_D44: length 26.1
  L8 w0.089: v2(159.33,73.71) 159.33,74.29 160.84,75.8 161.79,75.8 162.24,76.26 167.99,76.26 169.65,77.92 169.65,82.01 170.54,82.9 174.55,82.9 176,81.46 176,80.87 v2(176.4,80.47)
  BOTTOM w0.114: VRAM4.N11 176,80.87 176,80.87 v2(176.4,80.47) ; v2(159.33,73.71) 159.34,73.7 GPU1.Y24
FBA_D45: length 25.3
  L8 w0.089: v2(176.41,82.87) 175.95,82.87 174.58,84.23 172.38,84.23 171.86,83.71 170.33,83.71 168.91,82.29 164.81,82.29 161.53,79.01 161.53,78.39 160.23,77.09 160.17,77.09 159,75.92 158.61,75.92 158.17,75.48 v2(158.17,74.87)
  BOTTOM w0.114: v2(176.41,82.87) 176.4,82.87 VRAM4.N13 ; GPU1.AA24 158.74,74.3 v2(158.17,74.87)
FBA_D46: length 29.3
  L8 w0.089: v2(158.78,72.01) 158.59,72.68 158.38,72.89 158.38,73.33 158.57,73.52 158.88,75.02 159.82,75.96 161.48,76.2 161.89,76.61 167.27,76.61 168.67,78.01 169.24,82.11 170.39,83.26 174.97,83.26 176.9,81.33 v2(177.19,80.48)
  BOTTOM w0.114: v2(177.19,80.48) 177.19,80.48 VRAM4.M11 ; GPU1.Y22 158.75,71.98 v2(158.78,72.01)
FBA_D47: length 29.4
  L8 w0.089: v2(158.14,72.54) 157.49,73.19 157.49,75.99 157.98,76.48 158.17,76.48 159.58,77.88 159.9,77.88 164.66,82.64 168.75,82.64 170.18,84.07 171.71,84.07 172.23,84.59 176.38,84.59 v2(177.14,83.83)
  BOTTOM w0.114: VRAM4.M13 176.8,82.47 177.19,82.85 177.19,83.78 v2(177.14,83.83) ; v2(158.14,72.54) 158.18,72.58 158.18,73.17 GPU1.AA23
FBA_D48: length 40.3
  L3 w0.089: v2(159.3,78.29) 159.3,81.16 166.38,88.24 183.16,88.24 186.5,84.9 186.5,83.55 186.42,83.46 v2(186.42,82.82)
  BOTTOM w0.114: v2(186.42,82.82) 186.54,82.7 186.54,81.7 185.71,80.87 185.6,80.87 VRAM4.A11 ; GPU1.AD27 159.3,77.82 v2(159.3,78.29)
FBA_D49: length 40.2
  L3 w0.089: v2(158.74,75.49) 158.74,75.91 158.74,75.91 158.74,76.83 159.29,77.38 159.29,77.38 159.72,77.8 159.85,77.8 160.64,78.59 160.64,81.5 166.67,87.53 182.87,87.53 185.25,85.15 v2(185.25,84.81)
  BOTTOM w0.114: GPU1.AB25 v2(158.74,75.49) ; VRAM4.A13 185.6,82.59 186.55,83.54 186.55,84.74 186.17,85.12 185.56,85.12 v2(185.25,84.81)
FBA_D50: length 42.8
  L3 w0.089: v2(158.11,77.18) 158.11,80.48 166.23,88.6 183.31,88.6 186.86,85.05 186.86,82.66 186.53,82.33 185.95,82.33 185.2,81.58 v2(185.2,81.27)
  BOTTOM w0.114: v2(158.11,77.18) 158.11,77.18 158.11,77.16 GPU1.AD26 ; v2(185.2,81.27) 184.8,80.87 VRAM4.B11
FBA_D51: length 39.6
  L3 w0.089: v2(186.08,84.34) 186.08,84.83 183.01,87.89 166.52,87.89 160.13,81.49 160.13,78.54 158.14,76.55 v2(158.14,76.08)
  BOTTOM w0.114: v2(158.14,76.08) GPU1.AC25 ; VRAM4.B13 185.17,82.84 185.17,83.38 186.08,84.28 v2(186.08,84.34)
FBA_D52: length 35.6
  L3 w0.089: v2(182.8,81.28) 183.5,81.98 183.5,84.86 181.9,86.47 167.11,86.47 161.71,81.06 161.71,78.16 160.34,76.79 v2(160.34,76.69)
  BOTTOM w0.114: GPU1.AA27 160.63,75.62 160.63,76.48 160.41,76.69 v2(160.34,76.69) ; VRAM4.E11 182.4,80.88 v2(182.8,81.28)
FBA_D53: length 33.4
  L3 w0.089: v2(182.8,82.85) 182.8,83.27 183.15,83.62 183.15,84.71 181.75,86.11 167.26,86.11 162.06,80.91 162.06,78.01 160.74,76.68 160.74,76.52 160.5,76.29 160.34,76.29 159.88,75.82 v2(159.88,75.44)
  BOTTOM w0.114: v2(159.88,75.44) GPU1.AA26 ; VRAM4.E13 182.4,82.47 182.78,82.85 v2(182.8,82.85)
FBA_D54: length 36.1
  L3 w0.089: v2(161.02,75.39) 161.18,75.54 161.25,75.54 162.98,77.27 162.98,80.14 168.24,85.4 180.76,85.4 181.19,84.97 181.19,82.66 181.57,82.28 v2(181.57,79.16)
  BOTTOM w0.114: VRAM4.F11 181.6,80.87 181.26,80.53 181.26,79.79 181.57,79.48 v2(181.57,79.16) ; v2(161.02,75.39) 161.1,75.39 161.28,75.21 161.28,74.38 161.06,74.16 161.06,73.68
FBA_D55: length 33.3
  L3 w0.089: v2(182,82.86) 182.77,83.63 182.77,84.54 181.55,85.76 168.1,85.76 162.42,80.08 162.42,77.22 162.28,77.08 162.28,77.07 161.44,76.24 161.3,76.24 159.9,74.84 v2(159.9,74.3)
  BOTTOM w0.114: v2(182,82.86) 181.61,82.47 VRAM4.F13 ; v2(159.9,74.3) GPU1.Y25
FBA_D56: length 32
  L3 w0.089: v2(165.34,72.25) 165.3,72.2 165.3,71.58 165.18,71.46 165.18,71.12 166.99,69.32 172.51,69.32 172.53,69.35 184.2,69.35 186.51,71.66 186.51,72.71 185.79,73.44 185.79,73.88 v2(186.8,74.89)
  BOTTOM w0.114: VRAM4.A4 186.41,75.27 v2(186.8,74.89) ; GPU1.R26 163.38,71.36 164,71.36 164.31,71.67 164.31,71.84 164.77,72.3 165.29,72.3 v2(165.34,72.25)
FBA_D57: length 30.5
  L3 w0.089: v2(163.36,71.94) 164.17,71.13 164.17,70.55 165.73,68.99 184.34,68.99 186.87,71.52 186.87,72.99 v2(186.19,73.67)
  BOTTOM w0.114: v2(186.19,73.67) 185.6,73.67 VRAM4.A2 ; GPU1.T25 162.78,71.36 v2(163.36,71.94)
FBA_D58: length 28.6
  L3 w0.089: v2(165.58,71.29) 166.59,70.29 184.63,70.29 186.16,71.81 186.16,72.57 184,74.72 184,75.06 184.64,75.7 v2(185.2,75.7)
  BOTTOM w0.114: v2(165.58,71.29) 165.14,70.84 GPU1.N27 ; v2(185.2,75.7) 185.2,75.67 VRAM4.B4
FBA_D59: length 26
  L3 w0.089: v2(185.11,71.37) 184.39,70.65 168.03,70.65 165.98,72.7 165.14,72.7 165.04,72.6 164.83,72.6 164.55,72.88 164.55,72.89 v2(164.54,72.89)
  BOTTOM w0.114: VRAM4.B2 184.8,73.67 184.41,73.28 184.41,72.7 184.61,72.5 184.61,71.87 v2(185.11,71.37) ; GPU1.R27 164.03,71.92 164.65,72.54 164.65,72.78 v2(164.54,72.89)
FBA_D60: length 28.4
  L3 w0.089: v2(182.79,74.87) 183.95,76.03 183.95,76.86 183,77.81 171.04,77.81 168.73,75.49 162.8,75.49 161.61,74.3 v2(161.61,73.69)
  BOTTOM w0.114: VRAM4.E4 182.4,75.27 v2(182.79,74.87) ; GPU1.V26 161.63,73.67 v2(161.61,73.69)
FBA_D61: length 27.1
  L3 w0.089: v2(182.8,74.07) 182.4,74.47 181.85,74.47 181.62,74.7 181.62,75.03 181.85,75.27 182.12,75.27 182.39,75.54 182.39,76.51 182.38,76.52 182.38,76.72 181.65,77.45 171.19,77.45 168.88,75.14 163.92,75.14 163.9,75.16 162.8,75.16 162.24,74.6 v2(162.24,74.25)
  BOTTOM w0.114: v2(162.24,74.25) 162.24,73.72 GPU1.V27 ; VRAM4.E2 182.4,73.67 v2(182.8,74.07)
FBA_D62: length 20.9
  L3 w0.089: v2(163.36,74.76) 171.76,74.76 172.09,74.43 178.93,74.43 178.97,74.47 180.8,74.47 v2(181.2,74.87)
  BOTTOM w0.114: VRAM4.F4 181.6,75.27 v2(181.2,74.87) ; GPU1.W27 162.42,75.04 163.06,75.04 163.33,74.76 v2(163.36,74.76)
FBA_D63: length 23.2
  L3 w0.089: v2(161.04,73.11) 161.9,73.11 163.14,74.36 163.53,74.36 163.57,74.4 169.53,74.4 170.38,73.55 173.72,73.55 173.84,73.67 179.42,73.67 179.43,73.66 179.76,73.66 179.76,73.66 181.6,73.66 v2(182,73.27)
  BOTTOM w0.114: VRAM4.F2 181.6,73.67 v2(182,73.27) ; v2(161.04,73.11) GPU1.W25
FBA_DQM0: length 15.5
  L8 w0.089: v2(179.12,57.78) 178.82,58.08 170.51,58.08 169.3,59.29 167.26,59.29 166.54,60.01 166.54,60.57 v2(166.31,60.81)
  BOTTOM w0.114: VRAM1.D2 v2(179.12,57.78) ; v2(166.31,60.81) GPU1.D19
FBA_DQM1: length 24.8
  L8 w0.089: v2(162.25,57.86) 162.25,57.36 164.35,55.27 164.35,54.19 171.36,47.18 178.42,47.18 179.11,47.87 v2(179.11,48.95)
  BOTTOM w0.114: VRAM1.D13 179.5,49.34 v2(179.11,48.95) ; GPU1.D14 162.84,57.89 162.81,57.86 162.26,57.86 162.26,57.86 v2(162.25,57.86)
FBA_DQM2: length 29.6
  L3 w0.089: v2(166.74,57.46) 168.54,55.67 173.54,55.67 175.95,53.25 182.2,53.25 183.67,51.78 184.04,51.78 184.28,51.54 184.28,51.17 184.3,51.15 184.3,49.6 185.69,48.21 187.14,48.21 v2(187.88,48.96)
  BOTTOM w0.114: v2(166.74,57.46) 166.1,57.46 165.16,58.4 GPU1.C17 ; VRAM1.P13 187.5,49.34 v2(187.88,48.96)
FBA_DQM3: length 26
  L3 w0.089: v2(188.6,60.26) 187.46,61.4 182.98,61.4 182.85,61.27 174.55,61.27 173.29,60.01 170.53,60.01 170.18,59.65 169.22,59.65 168.54,60.33 168.54,60.42 168.08,60.88 v2(168.08,61.45)
  BOTTOM w0.114: GPU1.C22 v2(168.08,61.45) ; VRAM1.P2 187.9,58.56 187.9,59.61 188.54,60.26 v2(188.6,60.26)
FBA_DQM4: length 14.6
  L8 w0.089: v2(174.82,73.27) 174.24,72.69 172.91,72.69 170.51,70.29 164.4,70.29 164.13,70.55 163.79,70.55 163.49,70.25 v2(162.85,70.25)
  BOTTOM w0.114: v2(162.85,70.25) 162.85,69.64 GPU1.P24 ; v2(174.82,73.27) 174.82,73.29 175.2,73.67 VRAM4.P2
FBA_DQM5: length 22.7
  L8 w0.089: v2(174.82,82.08) 174.34,82.55 170.85,82.55 170.24,81.94 170.24,81.84 170.24,81.83 170.24,78 168.14,75.9 162.29,75.9 159.89,73.5 v2(159.89,73.15)
  BOTTOM w0.114: VRAM4.P13 175.2,82.46 v2(174.82,82.08) ; v2(159.89,73.15) 159.91,73.15 159.91,73.13 159.93,73.11 GPU1.W24
FBA_DQM6: length 36.3
  L3 w0.089: v2(183.98,84.59) 183.98,84.92 182.08,86.82 166.97,86.82 161.35,81.21 161.35,78.31 159.31,76.26 v2(159.31,74.85)
  BOTTOM w0.114: v2(159.31,74.85) GPU1.AA25 ; v2(183.98,84.59) 183.54,84.16 183.54,83.07 183.2,82.73 VRAM4.D13
FBA_DQM7: length 27
  L3 w0.089: v2(162.27,71.91) 162.27,73.08 163.26,74.07 163.26,74.07 163.31,74.13 163.64,74.13 163.7,74.07 166.02,74.07 168.3,71.79 178.34,71.79 178.67,72.12 179.21,72.12 179.48,71.85 181.74,71.85 181.88,71.99 182.46,71.99 182.99,71.46 v2(182.99,71.43)
  BOTTOM w0.114: v2(182.99,71.43) 182.99,71.66 182.79,71.86 182.79,73.26 183.2,73.67 VRAM4.D2 ; GPU1.U25 162.23,71.95 v2(162.27,71.91)
FBA_EDC0: length 15.7
  L8 w0.089: v2(165.19,61.96) 165.78,61.96 168.09,59.65 174.68,59.65 v2(175.83,58.5)
  BOTTOM w0.114: VRAM1.C2 178.35,58.51 176.62,58.51 176.61,58.5 v2(175.83,58.5) ; v2(165.19,61.96) 165.19,61.96 165.19,61.37
FBA_EDC1: length 22.3
  L8 w0.089: v2(178,47.99) 177.55,47.53 174.63,47.53 172.57,49.59 169.45,49.59 164.53,54.51 164.53,55.35 163.4,56.48 v2(163.4,56.78)
  BOTTOM w0.114: GPU1.C15 163.96,57.87 163.96,57.35 163.4,56.79 v2(163.4,56.78) ; VRAM1.C13 178.32,48.98 178.32,48.3 v2(178,47.99)
FBA_EDC2: length 32.4
  L3 w0.089: v2(166.01,56.73) 166.03,56.72 166.03,56.18 166.32,55.89 166.69,55.89 175.84,46.74 180.38,46.74 181.5,45.62 186.03,45.62 188,47.59 188,48.2 188.28,48.48 188.28,49.36 v2(187.88,49.76)
  BOTTOM w0.114: 165.14,57.92 165.14,57.45 165.85,56.73 v2(166.01,56.73) ; v2(187.88,49.76) 188.28,49.36 VRAM1.R13
FBA_EDC3: length 26.1
  L3 w0.089: v2(189.55,60.12) 189.55,60.55 187.56,62.53 174.79,62.53 172.89,60.63 172.17,60.63 169.72,60.63 169.48,60.87 v2(168.65,60.87)
  BOTTOM w0.114: v2(189.55,60.12) 189.55,60.08 188.71,59.24 188.71,58.57 VRAM1.R2 ; v2(168.65,60.87) 168.64,60.87 GPU1.B22
FBA_EDC4: length 13
  L8 w0.089: v2(163.38,70.78) 164.07,70.78 164.4,71.12 164.74,71.12 164.96,70.89 166.02,70.89 166.54,71.4 170.37,71.4 172.24,73.27 v2(174,73.27)
  BOTTOM w0.114: GPU1.R25 162.83,70.78 v2(163.38,70.78) ; v2(174,73.27) VRAM4.R2
FBA_EDC5: length 22.5
  L8 w0.089: v2(171.03,82.12) 170.59,81.68 170.59,77.85 168.29,75.54 162.47,75.54 160.29,73.36 160.29,72.98 159.87,72.56 v2(159.33,72.56)
  BOTTOM w0.114: VRAM4.R13 174.05,82.82 171.73,82.82 v2(171.03,82.12) ; v2(159.33,72.56) 159.37,72.52 GPU1.W23
FBA_EDC6: length 36.5
  L3 w0.089: v2(184.64,84.64) 184.48,84.79 184.48,85.36 182.66,87.18 166.82,87.18 161,81.36 161,78.52 v2(159.89,77.4)
  BOTTOM w0.114: GPU1.AB26 159.31,76.25 159.89,76.82 v2(159.89,77.4) ; v2(184.64,84.64) 184.69,84.59 184.69,83.76 184.43,83.5 184.43,83.12 184,82.69 VRAM4.C13
FBA_EDC7: length 26.2
  L3 w0.089: v2(183.71,71.61) 183.71,71.18 183.53,71 168.13,71 165.41,73.73 v2(163.48,73.73)
  BOTTOM w0.114: VRAM4.C2 184,73.67 183.61,73.28 183.61,72.35 183.71,72.25 v2(183.71,71.61) ; GPU1.T26 162.82,72.4 163.48,73.06 v2(163.48,73.73)
FBA_MF1: length 4
  TOP w0.102: R8111.1 181.43,61.43 181.82,61.04 182.34,61.04 v1(182.7,60.68) 183.12,60.27 v2(183.45,60.27)
  BOTTOM w0.102: v2(183.45,60.27) 183.45,60.3 183.47,60.3 183.47,59.97 183.5,59.94 VRAM1.J1
FBA_MF4: length 3.1
  TOP w0.102: v2(178.93,71.68) 179.36,71.68 179.46,71.58 v1(179.46,71.3) 179.46,70.61 R8210.2
  BOTTOM w0.102: v2(178.93,71.68) 179.2,71.95 VRAM4.J1
FBA_SEN0: length 9.8
  TOP w0.102: R8110.1 184.67,44.71 v1(184.67,46.55) 184.67,46.56 v2(185.17,47.07)
  L8 w0.102: v2(185.17,47.07) 185.38,47.28 185.38,51.24 184.24,52.38 v2(183.73,52.38)
  BOTTOM w0.102: VRAM1.J10 183.5,52.25 183.63,52.38 v2(183.73,52.38)
FBA_SEN2: length 8.8
  L8 w0.102: v2(179.67,84.97) 179.67,84.18 179.97,83.88 179.97,80.68 180.01,80.64 180.01,80.3 179.77,80.06 179.44,80.06 179.24,79.86 v2(179.24,79.41)
  BOTTOM w0.102: R8209.1 178.66,85.3 v1(178.84,85.12) 178.99,84.97 v2(179.67,84.97) ; v2(179.24,79.41) 179.2,79.45 VRAM4.J10
FBA_VREF_FET_L: length 3.5
  BOTTOM w0.508: R8104.2 172,54.79 Q8101.D 171.5,55.56 v1(171.5,56.43)
FBA_VREFC0: length 77.5
  L3 w0.508: v2(178.8,83.65) 178.89,83.65 179.4,83.13 179.4,82.2 180.22,81.38 180.22,79.31 181.22,78.31 184.28,78.31 188.74,73.86 v2(188.74,66.59) ; v2(184.43,47.19) 184.47,47.15 184.47,46.56 184.19,46.28 182.1,46.28 181.71,46.67 181.71,48.84 180.94,49.61 176.75,49.61 175.07,51.29 v2(175.07,53.45)
  L8 w0.508: v2(184.43,47.19) 184.43,46.73 185.1,46.06 189.57,46.06 192.14,48.62 192.14,52.33 191.3,53.17 191.3,55.34 191.83,55.88 191.83,58.73 189.82,60.74 189.82,65.5 v2(188.74,66.59)
  BOTTOM w0.254: v2(178.8,83.65) 179.18,83.27 179.2,83.27 VRAM4.J14
  BOTTOM w0.356: v2(184.43,47.19) 184.43,47.61 183.88,48.15 183.88,48.18 VRAM1.J14
  BOTTOM w0.508: 175.07,53.45 v2(175.07,53.45) ; 175.07,53.45 175.07,52.44 R8106.2 ; 175.07,53.45 175.05,53.45 174.52,53.97 R8107.1 174.26,53.93 R8104.1 ; v2(178.8,83.65) 178.63,83.81 178.62,83.81 178.61,83.81 178.11,83.81 178.1,83.81 178.09,83.81 177.71,84.2 177.71,85.04 v1(177.45,85.3) C8202.1 176.03,85.94 C8126.1
FBA_WCK01: length 21.5
  L8 w0.089: v2(165.16,59.65) 164.62,59.11 164.62,58.69 166.02,57.29 166.08,57.29 168.55,54.82 172.71,54.82 173.14,54.39 173.14,54.07 173.34,53.87 173.67,53.87 174.28,54.48 179.42,54.48 179.64,54.71 179.64,55.91 v2(179.9,56.17)
  BOTTOM w0.102: v2(165.16,59.65) 165.19,59.69 165.19,60.24 ; v2(179.9,56.17) 179.51,56.56 VRAM1.D4
FBA_WCK01#: length 21.6
  L8 w0.089: v2(165.72,59.08) 165.59,58.95 165.3,58.95 165.08,59.17 164.94,59.17 164.81,59.03 164.81,58.77 166.1,57.48 166.16,57.48 168.63,55.01 172.79,55.01 173.33,54.47 173.33,54.15 173.42,54.06 173.59,54.06 174.2,54.67 179.34,54.67 179.45,54.78 179.45,56.15 179.36,56.24 179.18,56.24 v2(179.1,56.16)
  BOTTOM w0.102: v2(165.72,59.08) 165.76,59.12 GPU1.C18 ; VRAM1.D5 179.5,56.06 179.4,56.16 v2(179.1,56.16)
FBA_WCK23: length 36.8
  L8 w0.089: v2(187.9,56.15) 185.63,53.89 183.5,53.89 182.88,53.27 182.88,52.27 183.36,51.78 184.04,51.78 184.29,51.53 184.29,50.37 183.96,50.04 183.05,50.04 180.06,53.03 174.81,53.03 174.57,53.26 168.91,53.26 165.61,56.57 165.61,56.81 164.9,57.52 164.4,57.52 164.17,57.75 164.17,59.46 v2(164.02,59.61)
  BOTTOM w0.102: 164.6,59.65 164.06,59.65 v2(164.02,59.61) ; v2(187.9,56.15) 187.5,56.55 VRAM1.P4
FBA_WCK23#: length 36.9
  L8 w0.089: v2(187.92,55.35) 187.7,55.57 187.58,55.57 185.71,53.7 183.58,53.7 183.07,53.19 183.07,52.34 183.44,51.97 184.12,51.97 184.47,51.62 184.47,51.62 184.49,51.6 184.49,50.29 184.04,49.85 182.97,49.85 179.98,52.84 174.73,52.84 174.49,53.07 168.84,53.07 165.42,56.49 165.42,56.73 164.82,57.33 164.33,57.33 163.98,57.67 163.98,58.97 163.9,59.05 v2(163.44,59.05)
  BOTTOM w0.102: VRAM1.P5 187.51,55.76 v2(187.92,55.35) ; GPU1.D16 v2(163.44,59.05)
FBA_WCK45: length 28.7
  L8 w0.102: v2(161.08,70.78) 161.26,71.52 161.26,71.52 161.47,71.72 161.47,72 162.29,72.83 163.2,72.83 164.21,73.84 168.42,73.84 172.97,78.39 173.55,78.39 173.77,78.17 173.77,77.4 173.87,77.3 174.07,77.3 174.17,77.4 174.17,78.17 174.39,78.39 178,78.39 178.22,78.17 178.22,77.8 178,77.58 175.74,77.58 175.61,77.45 v2(175.61,75.68)
  BOTTOM w0.114: GPU1.T24 161.09,70.79 v2(161.08,70.78) ; v2(175.61,75.68) VRAM4.P4
FBA_WCK45#: length 28.7
  L8 w0.102: v2(161.67,71.35) 161.67,71.64 161.67,71.64 161.67,71.92 162.38,72.62 163.28,72.62 164.3,73.64 168.51,73.64 173.06,78.19 173.46,78.19 173.56,78.08 173.56,77.31 173.78,77.09 174.16,77.09 174.38,77.31 174.38,78.08 174.48,78.19 177.91,78.19 178.02,78.08 178.02,77.88 177.91,77.78 175.65,77.78 175.41,77.54 175.41,76.22 175.27,76.08 175.07,76.08 174.97,76.18 174.97,76.31 174.87,76.41 174.64,76.41 174.54,76.31 174.54,75.93 v2(174.77,75.69)
  BOTTOM w0.114: VRAM4.P5 174.83,75.7 174.76,75.7 174.76,75.69 v2(174.77,75.69) ; v2(161.67,71.35) 161.63,71.39 GPU1.U24
FBA_WCK67: length 30.5
  L8 w0.089: v2(183.55,76.7) 183.55,77.85 183.05,78.35 179.41,78.35 178.82,78.95 172.69,78.95 168.1,74.36 163.27,74.36 162.49,73.58 162.29,73.58 161.36,72.64 160.78,72.64 160.45,72.31 160.45,71.89 v2(160.5,71.4)
  BOTTOM w0.102: GPU1.V24 160.5,71.4 v2(160.5,71.4) ; VRAM4.D4 183.2,75.62 183.55,75.96 v2(183.55,76.7)
FBA_WCK67#: length 30.5
  L8 w0.089: v2(182.78,76.69) 182.59,76.88 182.59,77.06 182.68,77.14 183.27,77.14 183.36,77.23 183.36,77.77 182.97,78.16 179.33,78.16 178.74,78.76 172.77,78.76 168.18,74.17 163.35,74.17 162.57,73.39 162.37,73.39 161.44,72.45 160.86,72.45 160.64,72.23 160.64,71.9 160.64,71.87 160.72,71.79 160.9,71.79 v2(161.06,71.95)
  BOTTOM w0.102: GPU1.V25 160.84,72.55 160.74,72.44 160.74,72.3 v2(161.06,71.95) ; VRAM4.D5 183.2,76.33 183.14,76.39 183.14,76.62 183.07,76.69 v2(182.78,76.69)
FBA_ZQ0: length 5.1
  TOP w0.254: v2(183.73,47.24) v1(183.73,45.61) 183.73,44.76 R8108.1
  BOTTOM w0.152: 183.11,48.05 183.11,48.97 VRAM1.J13
  BOTTOM w0.203: v2(183.73,47.24) 183.73,47.44 183.11,48.05
FBA_ZQ3: length 4.4
  BOTTOM w0.178: 179.57,83.47 179.59,83.45 179.59,83.09 179.47,82.96 179.47,82.77 179.2,82.51 VRAM4.J13
  BOTTOM w0.254: 179.57,83.47 179.57,83.91 180.22,84.56 v1(180.22,84.86) 180.22,85.13 179.44,85.92 R8213.1
FFS_INT1: length 89.5
  TOP w0.102: v1(124.22,79.84) 124.39,79.84 124.65,79.58 v2(124.65,79.41)
  L3 w0.102: v2(140.84,84.85) 142.01,86.02 142.01,86.74 141.37,87.38 140.43,87.38 140.22,87.17 134.4,87.17 132.19,84.97 132.19,81.71 128.14,77.65 122.9,77.65 122.29,78.26 122.29,79.4 123.03,80.14 123.92,80.14 v2(124.65,79.41)
  L5 w0.102: v2(124.65,79.41) 124.55,79.51 124.15,79.51 124.14,79.51 123.78,79.51 123.77,79.51 123.03,79.51 122.29,78.77 122.29,78.09 124.08,76.31 125.49,76.31 126.07,75.72 126.07,71.76 124.5,70.19 124.5,66.65 120.05,62.2 113.28,62.2 111.89,63.59 109.01,63.59 108.65,63.23 108.65,62.22 108.9,61.97 108.98,61.97 109.58,61.37 109.58,59.89 109.85,59.62 110.22,59.62 110.56,59.28 110.56,58.43 109.66,57.52 108.13,57.52 107.15,56.54 107.15,55.74 107.41,55.48 110.1,55.48 110.47,55.11 110.47,53.73 110.14,53.4 108.65,53.4 v2(108.17,52.91)
  BOTTOM w0.102: v2(140.84,84.85) 140.86,84.83 R7005.2 ; CPU1.CG22 107.91,52.66 v2(108.17,52.91)
FFS_INT2: length 73.2
  TOP w0.102: v2(143.73,83.01) 143.33,83.4 v1(143.14,83.4)
  L5 w0.102: v2(129.2,59.92) 129.2,60.81 129.97,61.58 130.85,61.58 133.68,58.74 134.29,58.74 134.95,58.08 134.95,57.51 134.93,57.49 135.17,57.25 135.17,57.25 135.42,57 135.42,57 135.47,56.95 136.95,56.95 136.97,56.98 137.88,56.98 138.38,56.48 140.91,56.48 141.73,57.3 141.73,57.66 141.48,57.92 141.39,57.92 140.78,58.52 140.78,60.44 142.2,61.86 142.2,71.57 142.02,71.75 142.02,75.18 142.81,75.96 142.81,76.59 142.17,77.23 142.17,79.35 143.73,80.9 v2(143.73,83.01)
  L6 w0.102: v2(108.19,58.09) 108.65,57.63 109.24,57.63 109.25,57.63 112.67,57.63 112.89,57.85 114.1,57.85 114.53,57.42 116.73,57.42 116.91,57.6 118.03,57.6 118.94,58.51 122.74,58.51 123.17,58.94 126.45,58.94 127.43,59.92 v2(129.2,59.92)
  BOTTOM w0.102: CPU1.CH12 108.56,58.46 v2(108.19,58.09) ; R2044.2 128.73,60.39 v2(129.2,59.92) ; v2(143.73,83.01) 143.65,83.09 143.65,84.08 144.55,84.98 144.55,86.18 R7006.2
FP1_USB20_CON_N: length 15.2
  BOTTOM w0.102: v1(135.67,8.24) 135.5,8.24 ; 135.5,8.24 135.5,10.7 135.75,10.95 135.9,10.95 136,10.85 ED9201.1 ED9201.10 136,9.1 136.08,9.02 136.08,8.44 137.05,7.47 140.95,7.47 141.21,7.74 141.21,8.57 141.35,8.71 FP1.3 ; 135.5,8.24 135.5,6.47 R9209.2
FP1_USB20_CON_P: length 15.4
  BOTTOM w0.102: v1(135.08,7.1) 135.27,7.1 ; 135.27,7.1 135.27,10.79 135.66,11.18 135.99,11.18 136.16,11.01 136.31,11.01 136.32,11.01 136.36,11.01 136.5,10.87 ED9201.2 ED9201.9 136.5,9.11 136.31,8.92 136.31,8.54 137.15,7.7 140.86,7.7 140.99,7.83 140.99,8.57 140.85,8.71 FP1.4 ; 135.27,7.1 135.27,6.39 R9210.2
FP1_USB20_N: length 84.6
  L3 w0.089: v2(136.54,4.42) 136.48,4.42 136.28,4.62 136.28,4.88 135.27,5.89 131.31,5.89 129.8,4.39 124.97,4.39 124.01,5.35 123.09,5.35 122.07,6.37 122.07,8.81 122.19,8.93 122.19,25.14 122.4,25.34 122.4,25.35 123.2,26.16 123.2,32.41 123.2,33.17 123.46,33.43 123.46,37.88 123.38,37.95 123.38,44.86 122.91,45.33 122.91,50.29 121.4,51.81 120.89,51.81 117.09,55.62 114,55.62 112.48,57.13 112.48,57.58 110.32,59.75 109.25,59.75 107.8,61.19 107.8,61.5 107.72,61.58 107.72,61.99 v2(107.24,62.47)
  BOTTOM w0.102: CPU1.CG5 107.59,62.83 107.25,62.49 107.25,62.47 v2(107.24,62.47) ; v2(136.54,4.42) 135.8,5.15 R9209.1
