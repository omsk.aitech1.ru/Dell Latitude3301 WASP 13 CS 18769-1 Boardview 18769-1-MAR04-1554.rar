# Allegro board 18769-1-MAR04-1554.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1V_VCCGT: length 11.1
  TOP w0.305: PR4686.1 45.43,60.51 v2(45,60.94)
  L5 w0.508: v2(45,60.94) 45.83,60.94 46.51,60.25 48.08,60.25 49.19,59.15 49.19,57.91 50.3,56.79 v4(50.3,55.73)
  BOTTOM w0.254: CPU1.P2 75.51,65.78 v2(75.38,65.91) ; CPU1.K2 v2(73.06,65.88)
  vias: v1(75.27,60.25) v2(67.51,58.1) v2(67.51,56.22) v2(67.51,55.28) v2(67.45,54.33) v2(68.16,59.04) v2(68.16,56.22) v2(68.16,55.28) v2(68.81,59.04) v2(68.81,58.1) v2(68.81,56.22) v2(68.81,55.28) v2(68.81,54.34) v2(69.46,59.04) v2(69.46,58.1) v2(69.46,56.22) v2(69.46,55.28) v2(69.46,54.34) v2(70.11,59.04) v2(70.11,56.22) v2(70.11,55.28) v2(70.76,59.04) v2(70.76,58.1) v2(70.76,56.22) v2(70.76,55.28) v2(70.76,54.34) v2(71.23,62.53) v2(71.41,59.04) v2(71.41,58.1) v2(71.41,56.22) v2(71.41,55.28) v2(71.41,54.34) v2(72.06,59.04) v2(72.06,56.22) v2(72.06,55.28) v2(72.73,59.04) v2(72.73,58.1) v2(72.73,56.21) v2(72.78,54.33) v2(73.52,59.39) v2(74.14,59.55) v2(74.74,59.35) v2(76.06,59.46) v2(76.77,59.46) v2(77.48,59.36) v2(78.78,59.34) v2(78.81,55.43) v2(78.79,54.12) v2(78.81,52.91) v2(78.83,51.99) v4(50.3,54.77) v4(50.28,53.78) v4(50.28,52.81) v4(51.47,55.96) v4(52.54,55.94) v4(53.53,53.6) v4(53.53,52.63) v4(53.53,51.54) v4(53.56,55.55) v4(53.56,54.59) v4(54.8,55.58) v4(54.8,54.62) v4(54.78,53.62) v4(54.78,52.66) v4(56.6,57.59) v4(56.6,56.62) v4(56.58,55.63) v4(56.58,54.67) v4(57.85,57.61) v4(57.85,56.65) v4(57.82,55.66) v4(57.82,54.69) v4(59.25,57.79) v4(59.25,56.82) v4(59.27,59.75) v4(59.27,58.78) v4(60.52,59.77) v4(60.52,58.81) v4(60.49,57.82) v4(60.49,56.85)
1V_VCCIO: length 3.3
  TOP w0.254: R401.1 87.08,59.7 v2(87.08,59.24)
  BOTTOM w0.203: CPU1.BP16 99.59,56.29 99.5,56.29 99.5,56.31 v2(99.54,56.31)
  BOTTOM w0.254: CPU1.BP18 99.88,55.1 99.48,55.51 v2(99.48,55.6) 99.59,55.6 CPU1.BP16
  vias: v1(108.38,78.16) v2(85.14,51.25) v2(85.59,50.8) v2(86.05,51.25) v2(86.5,50.8) v2(96.04,48.86) v2(96.07,51.25) v2(96.53,50.8) v2(96.99,51.25) v2(97.02,48.85) v2(98.98,56.01) v4(103.18,77.6) v4(104.02,77.57) v4(104.85,77.62) v4(107.54,78.39) v4(107.77,79.2) v4(108.53,78.85)
1V_VCCIO_R:
  vias: v1(111.35,82.52)
1V_VCCSA:
  vias: v1(96.63,76.54) v2(96.15,61.18) v2(96.15,59.75) v2(97.07,59.72) v2(97.44,50.8) v2(97.71,51.54) v2(97.98,61.16) v2(98.06,52.26) v2(98.62,51.9) v2(98.81,51.25) v3(97.09,61.12) v4(98.72,74.86) v4(98.77,76.81) v4(98.77,75.85) v4(99.63,74.78) v4(99.68,76.71) v4(99.68,75.8) v4(99.81,77.65) v4(101,77.6)
1V_VCCST_CPU: length 138.7
  TOP w0.254: v2(140.84,86.94) 140.61,87.17 R4036.2 138.58,87.17 C807.1 ; v2(101.62,59.85) 101.61,59.85 101.5,59.75 101.1,59.75 C806.1 100.94,59.62 C805.1 99.91,59.62 99.68,59.85 99.6,59.85 99.29,60.16 99.29,60.65 99.3,60.66 99.3,61.31 99.64,61.64 99.64,65.97 v2(99.98,66.32) ; v2(50.78,68.34) 50.66,68.46 PG4601.1
  L3 w0.254: v2(140.84,86.94) 140.6,86.94 140.41,86.75 140.23,86.75 134.38,86.73 132.5,84.84 132.5,81.59 128.19,77.27 127.37,77.27 v2(125.64,75.54)
  L5 w0.254: v2(94.53,72.7) 94.5,72.68 78.28,72.68 77.17,71.57 77.07,71.57 76.6,71.11 67.44,71.11 v2(67.25,70.92) ; v2(99.98,66.32) 100.91,65.39 109.12,65.39 114.4,70.68 121.94,70.68 123.45,72.2 123.45,73.36 v2(125.64,75.54)
  L8 w0.254: v2(99.98,66.32) 99.47,66.32 97.63,68.16 97.63,70.89 95.82,72.7 v2(94.53,72.7)
  BOTTOM w0.152: CPU1.BP2 99.94,65.7 99.95,65.73 99.96,66.02 v2(99.98,66.32)
  BOTTOM w0.254: v2(94.53,72.7) 96.17,72.7 97.11,73.64 C801.2 97.12,74.4 R308.1 ; v2(101.62,59.85) 101.62,59.69 CPU1.BT11 CPU1.BR11 CPU1.BP11 ; R723.1 67.86,70.3 v2(67.25,70.92) 66.91,70.58 R727.1 66.18,70.21 66.15,70.21 66.06,70.11 65.37,70.11 65.34,70.14 63.76,70.14 63.5,70.4 63.5,70.43 63.12,70.81 R726.1 62.93,71.02 61.85,71.02 61.52,70.69 61.52,69.24 62.16,68.6 62.16,65.27 59.54,62.65 56.83,62.65 52.95,66.53 52.95,67.57 52.33,68.19 51.97,68.19 v1(51.91,68.13) 51.71,68.34 v2(50.78,68.34)
1V_VCCST_CPU_R:
  vias: v1(140.25,84.77)
1V_VCCSTG: length 66.3
  TOP w0.254: C802.2 94.34,64.62 95.42,65.7 v2(95.42,66.02) 94.4,67.04 94.24,67.04 93.87,67.4 93.87,69.41 93.9,69.43 93.9,70.51 93.89,70.52 93.89,73.44 94.02,73.56 94.02,73.57 94.17,73.72 94.17,74.21 94.6,74.64 v2(94.6,76.38) ; v2(107.45,76.79) 106.84,77.41 v1(106.84,78.92) 106.84,79.56 107.03,79.75 R4043.2
  L5 w0.254: v2(94.6,76.38) 94.63,76.36 95.51,76.36 98.3,73.57 104.24,73.57 v2(107.45,76.79) ; v2(67.34,68.83) 68.75,67.41 71.6,67.41 72.39,66.62 83.04,66.62 83.17,66.49 86.51,66.49 86.94,66.92 88.94,66.92 89.19,67.17 90.62,67.17 91.58,66.21 91.74,66.21 92.39,65.56 94.95,65.56 95.42,66.03 v2(95.42,66.02)
  BOTTOM w0.254: R310.1 67.34,69.09 v2(67.34,68.83) 67.37,68.79 R301.1 ; CPU1.BG3 CPU1.BG2 CPU1.BG1 95.69,65.75 v2(95.42,66.02)
1V_VGA_CORE: length 46.5
  L3 w0.508: v4(159.09,41.64) 158.92,41.47 158.92,40.78 156.83,38.69 156.83,34.82 154.56,32.54 154.56,32.52 154.12,32.09 152.94,32.09 152.37,32.65 150.84,32.65 148.37,30.18 143.05,30.18 141.49,28.62 141.49,27.39 140.74,26.64 v2(140.74,26.08) ; v2(152.11,77.01) 152.22,76.9 155.65,76.9 156.63,75.92 156.63,69.99 157.65,68.97 157.65,66.74 v2(157.74,66.65)
  BOTTOM w0.381: PR8577.2 140.73,26.49 140.73,26.09 v2(140.74,26.08)
  BOTTOM w0.508: v2(152.11,77.01) 152.06,76.96 150.06,76.96 R8624.1
  vias: v1(157.85,40.06) v2(135.58,45.92) v2(135.59,45.22) v2(135.6,44.41) v2(142.91,56.6) v2(147.05,59.11) v2(148.2,60.23) v2(148.2,59.13) v2(149.31,61.35) v2(149.34,60.2) v2(149.39,59.06) v2(149.36,57.92) v2(150.49,59.03) v2(150.53,57.87) v2(150.58,56.75) v2(151.62,59.1) v2(151.65,60.2) v2(151.68,56.72) v2(152.83,56.7) v2(152.91,54.41) v2(152.92,53.15) v2(153.52,65.15) v2(154.05,54.39) v2(154.22,64.36) v2(154.84,63.8) v2(154.96,66.58) v2(155.23,54.39) v2(156.33,68.01) v2(156.27,65.18) v2(156.32,62.38) v2(156.27,59.53) v2(157.72,63.8) v2(157.72,60.93) v2(157.68,59.56) v2(159.12,62.4) v2(159.19,65.27) v2(160.41,66.56) v2(160.57,65.15) v2(160.61,63.85) v2(161.11,65.87) v2(161.83,65.2) v4(136.54,45.14) v4(136.54,44.23) v4(136.55,46) v4(141.24,45.34) v4(141.24,44.43) v4(141.26,47.07) v4(141.25,46.21) v4(142.13,47.1) v4(142.12,46.23) v4(142.1,45.37) v4(142.1,44.46) v4(143.04,47.07) v4(143.03,46.21) v4(143.01,45.34) v4(143.01,44.43) v4(143.85,44.48) v4(144.01,47.42) v4(144.95,47.42) v4(144.87,44.48) v4(145.1,58.93) v4(145.81,58.32) v4(145.81,47.42) v4(145.86,44.48) v4(146.49,57.66) v4(146.84,46.18) v4(146.82,45.32) v4(146.82,44.4) v4(146.85,47.05) v4(147.31,56.98) v4(147.74,45.34) v4(147.74,44.43) v4(147.76,47.07) v4(147.76,46.21) v4(148.09,56.19) v4(148.64,46.18) v4(148.62,45.32) v4(148.62,44.4) v4(148.67,47.05) v4(148.78,55.53) v4(149.54,54.87) v4(149.49,47.42) v4(150.43,47.42) v4(151.3,47.42) v4(152.13,47.46) v4(153,47.4) v4(153.15,46.49) v4(153.17,45.57) v4(153.23,44.56) v4(154.14,46.23) v4(154.17,45.32) v4(154.22,44.3) v4(155,41.14) v4(155.11,45.19) v4(155.13,44.28) v4(155.18,43.26) v4(155.17,42.12) v4(156.41,42.4) v4(157.28,41.8) v4(157.6,42.99) v4(158.19,41.08) v4(158.28,42.35)
1V_VGA_EN_B: length 4.8
  BOTTOM w0.102: U8604.2 147.57,78.92 146.74,79.75 146.11,79.75 146.1,79.75 145.62,79.75 R8617.2 145.22,80.15 145.22,80.74 145.78,81.3 v1(145.78,81.32)
1V_VGA_EN_OR: length 5
  TOP w0.102: R8524.2 141.84,83.68 142.25,83.27 v1(142.25,82.39) 142.32,82.32 v2(142.98,82.32)
  BOTTOM w0.102: R8523.2 142.98,83.41 v2(142.98,82.32) Q8509.2
1V_VGA_EN_R: length 22
  TOP w0.102: C8603.1 148.91,80.82 v2(149.69,81.6)
  L5 w0.102: v2(137.4,86.05) 137.4,85.59 139.99,83.01 v2(140.96,83.01)
  L6 w0.102: v2(140.96,83.01) 141.14,83.01 141.78,83.65 144.84,83.65 146.47,82.02 146.47,81.87 146.74,81.6 v2(149.69,81.6)
  BOTTOM w0.102: v2(140.96,83.01) 140.83,83.14 v1(140.83,83.93) 141.6,83.93 R8523.1 ; Q8615.2 149.35,80.82 149.69,81.16 v2(149.69,81.6) 149.69,81.97 R8615.2 ; PU8603.7 v2(137.4,86.05)
1V_VGA_EN_Y: length 10.4
  BOTTOM w0.102: R8615.1 150.74,82.44 150.78,82.48 151.14,82.48 151.44,82.18 151.44,81.69 151.6,81.54 151.6,81 150.2,79.6 149.07,79.6 148.85,79.38 148.85,77.84 148.22,77.21 U8604.4 148.22,76.32 v1(147.58,75.68)
1V_VGA_S0: length 0.9
  BOTTOM w0.508: R8618.1 150.96,81.46 150.96,81.67 v2(150.96,82.05)
  vias: v1(160.97,83.14) v2(134.58,88.45) v2(135.26,88.45) v2(160.49,85.4)
1V_VGA_S0_DISCHG: length 2.3
  BOTTOM w0.102: Q8615.3 149.42,80.17 150.3,81.05 R8618.2
1V_VGA_S0_PG: length 102.8
  TOP w0.102: v2(145,84.84) 145,84.56 145.34,84.22 R8531.1 144.85,83.41 PR8623.2 144.12,83.41 143.08,84.45 v1(142.52,84.45) 141.71,84.45 R8524.1
  L3 w0.102: v2(189.22,39.25) 189.22,38.91 187.49,37.18 187.49,33.77 185.46,31.74 175.07,31.74 172.31,34.51 172.31,34.8 170.6,36.5 170.6,37.13 170.48,37.24 170.48,44.51 170.37,44.63 170.37,44.66 167.91,47.12 165.77,47.12 164.87,48.01 164.87,48.37 165.94,49.44 165.94,50.48 162.6,53.82 161.07,53.82 158.37,56.52 157.7,56.52 153.57,60.65 153.57,64.55 155.37,66.35 155.37,66.97 155.21,67.13 155.21,71.04 155.62,71.44 155.62,73.36 154.98,73.99 151.08,73.99 145.66,79.42 145.66,79.62 144.7,80.57 144.21,80.57 143.76,81.03 143.76,81.62 144.02,81.89 144.02,81.89 145,82.87 v2(145,84.84)
  BOTTOM w0.102: v2(189.22,39.25) 188.89,39.58 187.13,39.58 186.83,39.27 186.22,39.27 D8601.2
1V_VREF_CPU: length 5.9
  BOTTOM w0.203: U2401.95 18.97,11.59 18.77,11.38 18.11,11.38 17.7,11.8 16.28,11.8 v1(15.98,12.11)
  BOTTOM w0.305: R2402.2 15.22,12.13 C2406.1 15.92,12.17 v1(15.98,12.11)
3V5V_CT1: length 2.1
  BOTTOM w0.203: U4001.12 63.45,11.67 v1(63.35,11.56) 63.24,11.67 62.72,11.67 C4001.1
3V5V_CT2: length 2.2
  BOTTOM w0.203: U4001.10 63.82,10.87 63.59,10.64 ; C4002.1 62.7,10.35 63.3,10.35 v1(63.3,10.34)
  BOTTOM w0.254: 63.59,10.64 63.59,10.63 v1(63.3,10.34)
3V5V_S0_ON: length 4.4
  BOTTOM w0.127: U4001.3 66.74,11.67 66.83,11.76 67.2,11.76 67.39,11.56 R4010.2 68.04,11.47 C4003.1 68.01,10.77 v1(67.25,10.77) 66.93,10.77 66.83,10.87 U4001.5
3V_5V_DSW_OK: length 245.3
  TOP w0.102: PR5310.1 28.11,48.31 v1(28.38,48.58) 28.41,48.62 28.97,48.62 v2(29.22,48.37) ; R2514.2 167.97,34.03 168.97,35.02 v2(168.97,35.22) 168.97,35.31 169.71,36.05 170.84,36.05 172.49,34.4 D2503.3
  L3 w0.102: v2(168.97,35.22) 168.97,35.54 168.82,35.69 168.82,37.65 164.38,42.09 164.38,46.42 163.48,47.32 163.48,47.34 163.17,47.64 163.17,48.49 161.25,50.41 161.25,51.1 159.99,52.35 158.14,52.35 157.84,52.66 157.55,52.66 157.13,53.07 156.44,53.07 155.52,53.98 155.06,53.98 154.82,54.22 154.82,54.56 154.94,54.68 154.94,54.7 155.02,54.78 155.02,57.7 151.66,61.05 151.66,65.3 153.25,66.88 153.25,68.63 152.44,69.44 152.07,69.44 151.87,69.24 151.53,69.24 151.29,69.48 151.29,70.43 147.03,74.7 147.03,74.97 144.06,77.94 144.06,78.84 142.43,80.47 142.43,81.89 141.76,82.56 v2(141.76,82.9)
  L5 w0.102: v3(30.79,64.12) 30.79,63.57 30.19,62.97 30.19,61.29 30.43,61.04 30.82,61.04 32.22,62.44 34.48,62.44 35.21,63.17 35.65,63.17 35.9,62.92 35.9,62.29 33.92,60.31 33.92,57.89 32.75,56.73 32.75,56.03 32.27,55.55 32.27,53.57 28.84,50.14 28.84,48.75 v2(29.22,48.37) ; v2(141.76,82.9) 141.76,82.97 139.34,85.39 138.85,85.39 137.75,86.49 132.98,86.49 130.67,88.81 124.16,88.81 v2(123.71,88.36) 123.29,88.78 120.86,88.78 120.8,88.84 120.45,88.84 120.23,88.63 64.25,88.63 62.9,87.28 62.9,84.01 60.74,81.85 v2(60.74,77.15)
  L8 w0.102: v2(60.74,77.15) 62.06,77.15 63.89,75.33 63.89,74 63.48,73.59 62.2,73.59 61.35,74.43 58.82,74.43 58.51,74.13 54.51,74.13 53.92,74.71 52.56,74.71 51.79,75.49 43.64,75.49 42.41,74.25 42.41,73.87 43.23,73.04 43.23,72.36 43.22,72.34 43.22,72.2 42.72,71.7 42.47,71.7 37.68,66.91 34.28,66.91 33.65,66.28 31.23,66.28 30.96,66.02 30.96,65.46 31.22,65.2 31.22,64.46 30.88,64.12 v3(30.79,64.12)
  BOTTOM w0.102: PR5210.1 123.61,87.81 123.61,88.27 123.71,88.36 v2(123.71,88.36) ; v2(168.97,35.22) 168.97,35.64 169.43,36.1 170.08,36.1 U2502.4
3V_5V_EN: length 150.2
  TOP w0.127: R4006.1 16.42,26.42 R4009.1 16.82,25.81 v2(16.1,25.81) 15.36,25.81 14.47,24.92 14.47,22.74 14.03,22.3 14.03,21 13.66,20.63 12.69,20.63 12.22,21.1 D4001.A 10.6,21.46 10.6,26.63 11.75,27.78 C4009.1 ; v2(78.99,3.29) 79.14,3.29 79.74,2.69 PR4556.1 80.02,2.69 80.19,2.85 80.19,4.01 79.39,4.8 79.39,5.92 77.58,7.73 61.54,7.73 58.82,10.45 45.4,10.45 v2(44.32,11.54)
  L5 w0.127: v2(44.32,11.54) 44.67,11.19 44.67,9.35 44.27,8.95 42.23,8.95 41.84,9.33 41.84,9.61 40.39,11.06 35.69,11.06 34.65,12.1 33.91,12.1 32.7,13.31 32.7,15.06 31.05,16.7 26.79,16.7 24.33,19.17 24.33,19.43 22.72,21.04 22.71,21.04 19.72,24.02 19.72,24.17 18.76,25.14 16.78,25.14 v2(16.1,25.81)
  BOTTOM w0.127: R4502.2 85.19,11.4 85.19,12.18 85.51,12.49 85.51,12.86 85.25,13.12 84.86,13.12 83.91,12.17 82.76,12.17 80.37,14.55 47.2,14.55 45.69,13.03 v1(45.69,12.53) 45.32,12.53 v2(44.32,11.54) ; v2(78.99,3.29) 78.99,3.46 78.7,3.75 78.56,3.75 78.16,4.16 PU4551.12
3V_5V_POK#: length 2.8
  TOP w0.254: v1(126.71,62.94) 127.28,63.51 Q1701.3 Q1701.2 127.17,64.5 R1726.2
3V_5V_PWRGD: length 196.3
  TOP w0.102: PR4505.2 85.97,7.93 v2(85.21,7.93) 85.21,11.52 v2(86.36,12.68) ; v2(130.24,65.13) 130.66,65.13 131.38,64.42 131.74,64.42 133.12,63.03 133.12,62.45 132.54,61.87 132.13,61.87 130.45,60.18 130.43,60.18 129.68,59.43 129.68,59.08 128.71,58.11 128.71,57.59 127.93,56.81 127.93,54.68 128.36,54.26 128.36,54.24 128.45,54.14 128.45,52.47 128.88,52.04 128.88,47.82 128.52,47.46 128.52,45.31 128.46,45.25 128.46,41.03 126.84,39.41 126.84,31.11 125.38,29.65 125.38,28.54 123.66,26.83 123.66,22.8 123.83,22.63 123.83,19.88 124.06,19.64 124.07,19.64 124.32,19.39 124.32,18.36 v2(123.73,17.77) ; v2(130.24,65.13) 129.5,64.39 Q1701.5 ; v2(130.24,65.13) 129.3,66.07 R1727.2 ; R4503.2 81.47,6.43 81.04,6.86 80.42,6.86 v2(80.38,6.9) 80.38,7.36 78.67,9.07 74.7,9.07 72.9,10.86 v2(72.9,11.14) ; v2(172.13,33.53) 173.36,32.29 D2503.1
  L3 w0.102: v2(132.6,58.34) 132.68,58.42 132.68,63.21 132.27,63.62 132.17,63.62 130.66,65.13 v2(130.24,65.13)
  L6 w0.102: v2(85.21,7.93) 84.14,6.86 81.93,6.86 81.89,6.9 v2(80.38,6.9) ; v2(132.6,58.34) 133.23,57.71 133.23,57.42 133.52,57.14 135.04,57.14 135.35,56.83 136.24,56.83 136.41,56.66 136.43,56.66 136.79,56.3 136.79,56.28 136.95,56.11 137.88,56.11 138.64,56.88 138.88,56.88 139.29,57.29 v2(139.35,57.29)
  L8 w0.102: v2(86.36,12.68) 87.13,13.44 90.08,13.44 91.54,11.98 108.06,11.98 108.39,11.65 117.67,11.65 118.36,10.95 119.55,10.95 120.58,11.98 120.58,13.89 121.99,15.3 121.99,16.01 123.75,17.77 123.73,17.77 v2(123.73,17.77) ; v2(172.13,33.53) 172.1,33.56 172.1,34.14 171.88,34.36 171.88,34.69 171.37,35.2 171.37,44.55 168.86,47.05 162.19,47.05 158.58,50.67 158.05,50.67 154.99,53.73 152.92,53.73 152.85,53.79 142.88,53.79 142.79,53.7 142.43,53.7 139.35,56.79 v2(139.35,57.29)
  BOTTOM w0.102: v2(85.21,7.93) 85.47,7.93 85.87,7.53 PU4501.10 84.93,7.35 v1(84.67,7.09) 84.86,6.9 PU4501.9 ; ED1704.1 72.9,12.29 v2(72.9,11.14)
5V_AUX_S5: length 11.6
  TOP w0.305: PG4565.2 75.29,2.69 75.13,2.85 75.13,2.88 75.01,2.99 v2(75.01,3.16)
  TOP w0.508: PR4552.1 81.21,4.88 v2(81.67,5.34) 82.08,4.93 v1(82.08,4.78)
  L8 w0.508: v2(75.01,3.16) 75.01,2.98 75.51,2.47 76.83,2.47 76.87,2.43 79.86,2.43 80.37,2.94 80.37,4.16 81.55,5.34 v2(81.67,5.34)
5V_FAN_VCC:
  vias: v1(191.3,38.29) v2(190.03,38.66) v2(190.72,38.18)
5V_HDMI: length 3.8
  TOP w0.508: 12.47,63.1 HDMI1.18 11.83,63.66
  BOTTOM w0.508: C5710.1 14.16,63.68 12.41,63.68 HDMI1.18
  vias: v1(15.28,59.31)
5V_KB_BL: length 1
  TOP w0.508: v2(21.92,10.1) 21.56,9.74 AFTP6529.1
5V_S0: length 109.5
  TOP w0.305: v4(62.45,9.23) 62.4,9.28 EC8952.1 ; v2(22.32,6.73) 22.32,5.95 EC8954.1 ; R2703.2 188.06,7.39 EC8953.1
  TOP w0.508: v2(188.94,8.27) R2703.2
  L3 w0.508: v4(181.36,24.97) 179.54,24.97 178.62,24.05 176.88,24.05 176.06,24.88 169.93,24.88 169.89,24.91 167.73,24.91 167.27,24.46 165.35,24.46 165.23,24.58 162.75,24.58 162.45,24.87 162.42,24.87 161.94,25.35 161.94,26.84 v2(161.78,26.99) 161.37,26.99 158.48,24.11 154.81,24.11 154.14,23.44 152.06,23.44 v2(151.69,23.81)
  L5 w0.508: v2(147.09,31.18) 152.1,31.18 152.12,31.16 156.82,31.16 157.1,30.88 158.98,30.88 160.39,29.48 160.39,28.39 v2(161.78,26.99) ; v2(151.69,23.81) 151.06,24.44 149.53,24.44 148.84,23.76 148.84,23.52 147.7,22.38 145.91,22.38 145.91,22.38 143.92,22.38 143.92,22.38 139.64,22.38 139.03,22.99 138.37,22.99 136.51,24.85 129.36,24.85 126.63,22.12 126.63,17.94 125.43,16.74 v2(124.8,16.74)
  BOTTOM w0.305: v2(124.8,16.74) 124.59,16.54 R6510.1
  BOTTOM w0.356: v2(16.17,42.19) 16.17,41.79 v1(16.47,41.48)
  BOTTOM w0.381: D5701.3 13.58,67.89 13.58,67.2 13.67,67.11 13.67,66.36 14.99,65.04 15.29,65.04 15.65,64.68 15.65,64.31 16.42,63.53 16.42,62.94 16.85,62.51 16.85,61.85 15.89,60.89 v2(15.4,60.89)
  BOTTOM w0.508: PR8556.1 146.57,32.14 147.08,31.63 147.08,31.18 v2(147.09,31.18) ; v2(16.17,42.19) 16.28,42.08 20.55,42.08 21.22,42.75 C5701.1 21.49,43.3 Q5703.G
  vias: v2(15.4,60.24) v2(21.77,7.21) v2(193.63,36.29) v2(194.62,37.74) v2(194.62,37.11) v4(61.57,9.3) v4(63.29,9.22) v4(64.12,9.17) v4(182.2,24.97) v4(183.03,24.95)
5V_S5: length 326.5
  TOP w0.305: PR4703.1 67.27,85.46 PC4777.1 66.66,84.85 v2(66.38,84.85) ; C4031.1 133.93,84.19 v2(134,84.12) U4006.3 ; PR4635.2 48.77,57.39 v2(49.07,57.09) ; v2(108.87,86.83) 108.87,86.77 108.78,86.67 C4043.1 108.73,86.15 U4003.3 ; EC8918.1 24.23,65.41 v2(23.48,66.16) ; v4(172.66,7.7) 171.53,8.83 AFTP6608.1 171.36,9.16 171.03,9.16 170.31,9.87 EC8927.1 ; v2(101.95,85.41) 101.82,85.54 PC5001.1 ; v2(103.49,84.79) PU5002.6
  TOP w0.381: v2(100.19,35.84) 100.32,35.71 C4032.1 100.23,34.22 U4002.3
  TOP w0.508: v2(122.29,88.32) 122.29,86.92 122.61,86.6 v2(122.61,84.19) ; PR8559.1 149.4,27.85 150.19,27.85 150.28,27.76 150.42,27.76 150.45,27.74 v2(150.6,27.74)
  L3 w0.508: v2(66.38,84.85) 66.29,84.85 65.72,84.28 65.72,83.19 66.29,82.63 66.29,74.62 65.58,73.92 65.3,73.92 v2(64.97,73.59) ; v2(101.95,85.41) 98,81.47 89.16,81.47 87.59,83.04 87.59,84.74 86.6,85.73 v2(86.19,85.73)
  L5 w0.457: v2(11.9,64.83) 12.25,64.83 13.01,65.58 13.01,65.7 13.17,65.87 13.17,66.83 12.49,67.52 12.45,67.52 12.1,67.87 11,67.87 10.39,68.48 v2(9.13,68.48) ; v3(25.1,60.73) 24.94,60.73 23.47,62.2 v2(23.47,63.43)
  L5 w0.508: v2(100.19,35.84) 101.25,34.79 102.31,34.79 104.03,33.08 111.54,33.08 111.54,33.07 111.96,33.07 114.8,30.23 114.8,25.67 114.08,24.95 v2(114.08,24.5) ; v2(39.76,46.69) 38.6,46.69 37.48,47.81 36.41,47.81 34.58,49.64 v2(29.27,49.64) ; v2(67.02,11.31) 66.37,10.67 v4(66.37,9.22) 63.25,12.33 50.98,12.33 v2(50.51,11.86) ; v2(134,84.12) 133.77,83.9 132.35,83.9 129.43,86.82 123.13,86.82 122.29,87.66 v2(122.29,88.32) 120.7,86.74 110.24,86.74 110.15,86.83 v2(108.87,86.83)
  L6 w0.457: v2(29.26,44.4) 29.26,46.85 28.61,47.5 28.61,48.68 29.27,49.34 v2(29.27,49.64) 30.17,50.53 30.17,55.49 27.91,57.75 27.25,57.75 26.44,58.56 26.44,59.07 25.12,60.4 25.12,60.71 v3(25.1,60.73) ; 29.09,39.41 29.09,38.34 29.1,38.33 29.1,37.72 30.14,36.67 30.14,34.99 29.22,34.08 29.22,32.1
  L6 w0.508: v2(150.6,27.74) 150.68,27.65 152.07,27.65 153.28,28.86 159.56,28.86 161.19,30.49 162.08,30.49 162.68,29.9 170.06,29.9 170.33,29.62 171.71,29.62 172.49,28.83 173.89,28.83 174.43,28.3 v2(174.74,28.3) ; 42.6,59.8 42.24,60.16 42.24,64.2 45.83,67.8 45.83,69.86 v2(45.1,70.59) ; 42.6,59.8 42.6,57.31 41.41,56.11 39.64,56.11 39.03,55.5 39.03,49.51 39.76,48.77 v2(39.76,46.69) ; 42.6,59.8 42.68,59.72 45.41,59.72 48.04,57.09 v2(49.07,57.09) ; v2(120.58,22.24) 120.58,22.02 119.55,21 117.93,21 114.43,24.5 v2(114.08,24.5) ; v2(29.26,44.4) 29.09,44.23 29.09,39.41 ; v2(28.48,31.35) 29.19,32.06 29.19,32.08 29.22,32.1
  L8 w0.508: v2(86.19,85.73) 85.69,86.24 67.77,86.24 v2(66.38,84.85) ; v2(50.86,70.64) 50.86,70.31 50.36,69.81 45.83,69.81 45.1,70.54 v2(45.1,70.59)
  BOTTOM w0.203: v2(67.02,11.31) 66.97,11.27 U4001.4 ; PU4801.29 40.53,48.02
  BOTTOM w0.305: PU4701.29 v2(66.38,84.85) ; v2(86.19,85.73) PR4713.1 86.83,85.04 PC4766.1 86.98,85.18 PU4702.29 ; U7201.H10 24.66,61.06 24.75,61.06 25.09,60.73 v3(25.1,60.73) ; 122.67,84.13 123.28,83.52 PU5201.21 ; EC8919.1 51.02,12.37 v2(50.51,11.86)
  BOTTOM w0.356: PR5101.1 29.95,43.73 PC5151.1 v2(29.26,44.4)
  BOTTOM w0.381: R4303.1 30.12,50.48 v2(29.27,49.64)
  BOTTOM w0.457: 9.25,70.38 9.25,68.61 v2(9.13,68.48)
  BOTTOM w0.508: 122.67,84.13 v2(122.61,84.19) ; PC5102.1 28.06,30.92 v2(28.48,31.35) 28.53,31.3 PU5151.6 ; Q6402.E 7.17,70.74 8.25,70.74 8.37,70.62 9.02,70.62 9.78,69.86 10.53,69.86 Q6401.E ; PR4610.1 45.25,70.44 v2(45.1,70.59) ; v2(174.74,28.3) 174.74,28.19 176.7,26.23 176.7,23.26 176.7,23.26 176.7,22.73 176.7,18.26 176.36,17.92 176.36,17.27 176.35,17.26 176.35,16.74 176.49,16.59 176.49,15 175.98,14.49 174,14.49 173.49,13.98 173.49,11.13 172.97,10.61 172.97,9.64 ; PC4866.1 40.63,47.36 39.96,46.69 v2(39.76,46.69) 39.54,46.46 PR4804.2 ; Q6505.E 50.29,12.09 50.51,11.87 v2(50.51,11.86) ; v2(122.29,88.32) 122.28,88.32 121.65,87.69 PC5202.1
  vias: v1(65.75,4.13) v2(13.77,55.73) v2(13.77,55.07) v2(13.78,54.44) v2(22.95,65.82) v2(122.81,4.29) v4(65.84,2.76) v4(66.79,2.76) v4(67.65,2.76) v4(68.52,2.72) v4(69.42,2.76) v4(70.25,2.82) v4(173.5,7.68)
19V_AD+: length 244.7
  TOP w0.254: v2(69.96,9.26) 69.96,9.27 v1(69.45,9.78)
  TOP w0.508: 155.66,21.66 155.66,20.01 v2(155.67,20.01) ; 155.66,21.66 PD4408.1 ; 155.66,21.66 154.81,20.81 154.54,20.81 154.23,20.5 153.26,20.5 153.26,20.5 151.43,20.5 150.73,21.2 150.73,21.26 150.59,21.39 150.59,21.6 150.07,22.12 150.07,22.36 149.81,22.62 141.6,22.62 140.51,23.72 139.27,23.72 PR4437.1
  L5 w0.508: v2(54.67,11.57) 58.96,11.57 60.83,9.69 60.83,8.99 61.39,8.44 69.13,8.44 v2(69.96,9.26)
  L6 w0.508: v2(54.67,11.57) 53.1,13.14 39.68,13.14 37.4,15.42 35.89,15.42 32.47,18.84 32.47,26.73 31.81,27.39 31.81,27.92 32.18,28.29 32.26,28.29 32.59,28.62 32.59,33.18 32.36,33.42 32.36,36.66 30.82,38.19 30.82,39.72 31.78,40.68 31.78,41.76 32.98,42.96 32.98,49.08 35.23,51.33 35.23,57.38 32.42,60.18 32.42,65.76 31.84,66.35 31.83,66.35 29.88,68.29 29.88,76.88 v4(28.26,78.51) ; v2(69.96,9.26) 83.48,9.26 83.89,9.68 89.97,9.68 90.46,10.17 95.72,10.17 99.08,6.82 120.96,6.82 122.52,5.26 129.29,5.26 129.33,5.22 131.29,5.22 131.9,5.83 131.99,5.92 148.59,5.92 151.82,9.16 157.03,9.16 158.23,10.36 158.23,11.12 158.76,11.65 158.76,15.72 158.07,16.41 158.03,16.41 157.66,16.78 157.66,18.3 155.95,20.01 v2(155.67,20.01)
  BOTTOM w0.508: PD4401.1 155.73,20.07 v2(155.67,20.01) ; C4306.1 24.62,70.95 24.62,74.87 v4(28.26,78.51)
19V_AD_JK: length 32.6
  TOP w0.508: v2(31.64,53.55) 30.59,54.59 30.53,54.59 29.52,55.59 v1(29.52,55.78) 29.52,56.07 R4376.1
  L5 w0.305: v2(33.46,60.08) 33.46,59.25 31.31,57.09 31.31,56.22 31.64,55.89 v2(31.64,53.55)
  L6 w0.305: v4(32.35,78) 32.04,77.69 31.47,77.69 30.54,76.76 30.54,68.58 31.79,67.34 31.79,67.32 32.1,67.01 32.12,67.01 33.74,65.38 33.74,61.39 34,61.14 34,60.61 v2(33.46,60.08)
19V_DCBATOUT: length 67
  TOP w0.381: PR8561.1 137.84,25.2 137.63,25.41
  TOP w0.508: PC4439.1 143.84,11.93 145.94,11.93 v2(146.15,12.15) ; v4(83.16,3.63) 83.79,3 PC4501.1 ; v2(146.28,20.2) 146.28,20.45 144.9,21.82 141.32,21.82 140.24,22.9 140.14,22.9 140.13,22.92 138.19,22.92 137.63,23.47 137.63,25.41 134.76,25.41 131.94,28.22 130.8,28.22
  L3 w0.508: v2(157.34,20.03) 156.56,20.81 147.01,20.81 146.4,20.2 146.28,20.2 v2(146.28,20.2) ; v4(130.19,11.48) 130.19,11.29 131.6,9.89 142.42,9.89 143.53,11 145.64,11 146.15,11.51 v2(146.15,12.15)
  BOTTOM w0.203: PU4401.3 148.69,13.68 148.65,13.64 148.6,13.64 148.17,13.21 148.17,12.78 147.33,11.94 146.35,11.94 v2(146.15,12.15) ; v2(157.34,20.03) 157.34,20.19 157.63,20.48 PD4401.2
  BOTTOM w0.305: v2(146.28,20.2) 146.28,20.2 146.42,20.34 PR4485.1 ; v4(135.69,60.34) 135.69,60.97 EC8911.1
  BOTTOM w0.508: v4(64.83,78.86) 64.83,78.54 EC8912.1
  vias: v1(79.9,8.62) v2(37,59.85) v2(37.1,59.21) v2(37.65,59.83) v2(37.78,59.21) v2(86.12,4.3) v2(86.93,4.3) v2(128.08,11.8) v2(128.69,11.37) v2(155.28,36.2) v2(155.47,35.18) v2(155.52,34.42) v4(40.23,38.83) v4(41.05,38.65) v4(42.73,71.16) v4(42.97,70.34) v4(43.69,71.07) v4(63.96,78.86) v4(64.07,79.76) v4(64.86,80.03) v4(65.55,79.55) v4(76.81,87.18) v4(77.72,87.18) v4(78.6,87.18) v4(81.29,3.65) v4(82.26,3.62) v4(87.64,3.66) v4(88.48,3.63) v4(89.32,3.61) v4(96.69,87.35) v4(97.6,87.33) v4(98.58,87.35) v4(111.2,13.52) v4(111.97,13.91) v4(112.7,13.49) v4(128.17,12.97) v4(128.66,12.27) v4(129.31,82.34) v4(129.35,11.74) v4(130.18,82.33) v4(131.04,82.32) v4(131.01,11.7) v4(134.84,34.98) v4(134.84,34.02) v4(134.89,37.75) v4(134.86,36.81) v4(134.86,35.9) v4(135.8,59.42) v4(136.64,58.96) v4(136.7,59.85) v4(137.58,59.62) v4(137.68,60.52) v4(154.81,36.77) v4(154.83,35.62) v4(154.8,33.86) v4(154.87,34.76) v4(155.97,36.61) v4(186.4,37.39) v4(186.42,36.5) v4(186.45,35.51) v4(186.42,34.5)
19V_DCBATOUT_LCD: length 1.5
  BOTTOM w0.203: 38.7,70.54 39,70.24 39.38,70.24 39.72,69.9 R6619.2
  vias: v1(38.35,74.38) v4(38.57,77.27) v4(38.57,76.38) v4(38.82,80.7) v4(38.85,79.84) v4(39.41,77.32) v4(39.61,80.22)
19V_DCBATOUT_LCD_SEN: length 108.7
  L5 w0.127: v2(39.05,69.09) 38.99,69.16 38.38,69.16 38.33,69.21 37.76,69.77 37.76,74.37 41.93,78.55 47.65,78.55 47.73,78.63 51.63,78.63 51.7,78.55 54.79,78.55 54.89,78.66 58.48,78.66 60.63,76.5 63.27,76.5 64.1,75.67 64.1,73.57 64.43,73.23 64.69,73.23 64.78,73.14 65.15,73.14 65.24,73.23 76.59,73.23 77.6,74.24 92.57,74.24 93.97,75.65 95.6,75.65 98.12,73.13 110.81,73.13 111.57,73.89 111.57,74.66 112.48,75.58 112.48,76.96 112.92,77.4 118.29,77.4 119.49,76.2 119.49,75.24 120.38,74.35 120.63,74.35 120.92,74.07 120.92,73.65 v2(121.31,73.26)
  BOTTOM w0.127: v1(121.47,72.65) 121.47,73.1 v2(121.31,73.26) 120.92,73.65 120.92,74.58 121.22,74.88 121.81,74.88 121.95,74.74 121.95,74.56 121.85,74.46 CN1.2 ; v2(39.05,69.09) 39.16,69.09 39.27,68.98 40.21,68.98 40.41,69.19 R6618.1
19V_DCBATOUT_R_SEN: length 72.4
  TOP w0.127: v1(130.67,42.73) 130.92,42.48 v2(131.19,42.48) ; R6624.1 125.81,9.99 125.93,10.12 v2(125.93,10.1)
  L3 w0.127: v2(131.19,42.48) 131.19,42.47 130.55,41.83 130.55,34.47 129.98,33.9 129.98,31.34 129.41,30.76 129.41,26.03 126.85,23.47 126.85,14.51 126.28,13.94 126.28,10.45 v2(125.93,10.1)
  L8 w0.127: v2(124.67,72.13) 124.53,71.99 124.53,65.91 124.13,65.51 124.13,64.78 124.71,64.2 124.71,58.26 124.67,58.23 124.67,57.08 131.66,50.09 131.66,47.99 132.09,47.56 132.09,42.54 131.79,42.24 131.46,42.24 131.23,42.48 v2(131.19,42.48)
  BOTTOM w0.127: v2(124.67,72.13) 125.22,72.68 125.22,73.14 125.05,73.31 CN1.18
19V_DCBATOUT_SEN: length 72.9
  TOP w0.127: R6625.1 126.24,9.48 126.33,9.56 126.33,9.57 v2(126.32,9.57) ; v2(131.25,41.84) 131.16,41.84 130.81,41.5 v1(130.81,41.5)
  L3 w0.127: v2(131.25,41.84) 130.91,41.84 130.78,41.71 130.78,34.37 130.21,33.81 130.21,31.24 129.64,30.67 129.64,25.93 127.07,23.37 127.07,14.41 126.51,13.84 126.51,9.97 126.32,9.79 v2(126.32,9.57)
  L8 w0.127: v2(131.25,41.84) 131.71,41.84 132.31,42.44 132.31,47.66 131.89,48.08 131.89,50.19 124.9,57.17 124.9,58.13 124.94,58.17 124.94,64.3 124.36,64.88 124.36,65.41 124.76,65.81 124.76,71.46 v2(125.43,72.13)
  BOTTOM w0.127: v2(125.43,72.13) 125.45,72.15 CN1.20
20V_VCCPD_VBUS: length 5.7
  L5 w0.508: 8.49,31.8 8.49,31.8 USB1.B9 ; 7.69,34.91 USB1.B4 8.2,34.4
  L8 w0.305: USB1.B4 7.86,34.4 8.32,33.94 ; 8.48,31.97 8.31,31.8 USB1.B9
  BOTTOM w0.305: USB1.B9 7.74,31.85 USB1.A4 ; USB1.A9 7.74,34.35 USB1.B4
  vias: v1(13.32,34.31) v2(12.42,31.37) v2(13.07,31.34) v2(19.9,57.13) v2(20.28,56.6) v4(19.17,57.02) v4(25.62,72.43) v4(25.62,71.36) v4(26.37,71.72) v4(26.46,72.56)
20V_VCCPD_VBUS_L: length 12.5
  TOP w0.305: v1(23.06,60.87) 22.77,61.16 v4(22.21,61.16)
  L6 w0.508: v4(22.21,61.16) 22.01,61.36 22.01,63.97 20.47,65.51 v2(20.47,66.87)
  BOTTOM w0.508: R7216.1 24.42,67.59 24.28,67.73 24.28,67.73 24.25,67.75 R7217.1 23.62,67.75 23.59,67.73 23.46,67.73 23.23,67.5 23.23,67.37 22.34,66.48 20.87,66.48 v2(20.47,66.87)
+3V_1D8V_AVDD: length 1.7
  TOP w0.203: U2701.33 183.71,18.04 183.78,18.11 183.78,18.13 184.14,18.49 184.16,18.49 184.6,18.93
  vias: v1(185.09,19.04)
+3V_1D8V_DVDD: length 8.2
  TOP w0.203: U2701.1 180.22,17.12 179.84,17.5 ; v2(179.34,13.8) 179.7,14.16 U2701.8
  L8 w0.508: v2(178.52,18.65) 178.97,18.2 178.97,14.16 v2(179.34,13.8) v2(179.34,12.48)
  vias: v1(178.8,17.97)
+5V_AVDD: length 3.9
  TOP w0.203: U2701.20 184.83,12.67 185.24,12.26
  TOP w0.508: C2707.1 186.72,8.29 R2703.1 ; C2706.1 186.4,11.86 v1(185.98,12.28) 185.96,12.26 185.24,12.26
+5V_PVDD: length 3.1
  TOP w0.203: U2701.34 183.31,18.17 184.02,18.88 184.02,19.01 ; U2701.39 181.31,17.97 181.11,18.17 180.97,18.17 180.45,18.69
  vias: v1(181.3,19.91)
DV3318_ANA_CORE:
  vias: v1(5.34,10.33)
DV3318_S_PAD:
  vias: v1(6.75,9.55)
DVSS: length 3.9
  TOP w0.102: R2716.2 177.21,12.39 v1(177.82,12.39) 178.13,12.69 178.6,12.69 178.9,12.98 180.05,12.98 180.22,13.16 U2701.10
GND: length 2095.4
  TOP w0.127: v2(101.58,53.01) 101.56,53.03 C1114.2 ; v2(128.77,62.37) 128.77,62.54 127.95,63.36 127.95,64.81 127.72,65.04 Q1701.1 ; PC4417.2 152.48,19.93 151.03,19.93 PQ4418.4 ; EC2901.2 160.97,8.9 160.87,8.8 160.87,6.38 161.09,6.16 161.11,6.16 161.43,5.84 161.43,5.82 161.66,5.59 v2(161.66,5.39) ; v2(26.07,21.26) 26.89,20.44 27.58,20.44 27.91,20.76 27.91,20.83 28.25,21.17 29.96,21.17 30.07,21.06 31.36,21.06 C2413.2 ; C2721.2 177.04,18.5 v2(177.67,17.87) ; v2(98.81,46.94) 98.35,46.49 98.35,44.02 v3(100.04,42.34) 100.04,41.34 101.32,40.07 102.24,39.14 102.24,38.2 102.74,37.7 v2(102.74,37.65) 102.31,37.22 102.31,36.37 102.81,35.87 103.08,35.87 103.34,35.61 103.34,35.24 103.27,35.17 103.27,34.25 103.48,34.03 108.98,34.03 R1723.2 109.15,34.67 108.55,35.27 108.55,36.3 107.51,37.35 106.93,37.35 103.69,40.58 102.96,40.58 101.7,41.84 101.7,44.37 v2(100.67,45.4) 100.67,45.57 R503.2 ; RAM2.T12 74.81,29.08 73.74,30.15 73.53,30.15 v3(73.4,30.27)
  TOP w0.14: v3(114.11,29.37) 113.95,29.21 113.25,29.21 112.91,28.87 RAM4.T12 ; RAM3.T12 93.73,28.87 93.73,29.2 94.06,29.52 94.06,29.53 94.06,29.54 94.06,29.8 94.06,29.81 94.06,30.07 v3(94.07,30.08)
  TOP w0.152: 23.93,13.23 23.93,13.58 24.61,14.26 Q2408.S
  TOP w0.178: RAM1.B12 46.58,32.61 46.91,32.94 46.91,33.28 47.01,33.39 47.01,33.64 47.01,33.64 47.01,33.64 v3(47.02,33.64)
  TOP w0.203: R1603.1 105.97,64.28 104.61,64.28 R1602.1 104.1,63.46 v2(104.43,63.13) ; v4(57.19,77.12) 57.78,76.53 C5515.2 ; RAM2.M12 72.21,29.06 v3(71.91,29.36) ; C4034.2 132.45,81.69 v2(133.24,80.9) ; v2(167.87,9.94) 167.95,9.85 168.91,9.85 EC8927.2 ; RAM4.R4 RAM4.T4 RAM4.T5 ; PQ4452.4 134.7,3.04 135.08,2.66 135.08,2.34 135.69,1.74 PQ4452.1 ; v2(118.53,51.23) 118.32,51.5 117.55,52.27 116.42,52.27 R2114.2 ; EC8948.2 18.29,57.08 19.06,56.3 v3(19.22,56.3) ; RAM2.D8 67.01,25.67 67.01,25.57 v3(67.31,25.27) ; R6103.1 168.76,22.07 169.76,22.07 171.6,23.91 FSW1.5 172.33,27.38 172.99,27.38 FSW1.4 ; PQ44B1.1 148.84,2.15 149.68,3 v3(149.68,3.02) ; RAM4.T5 112.91,24.07 ; RAM4.T5 113.28,22.9 v3(113.89,22.9) ; RAM4.T5 RAM4.R5 ; RAM3.M12 91.13,28.87 91.13,29.24 v3(91.39,29.49) ; EC2702.2 EC2701.2 192.34,8.98 192.36,8.95 v2(192.38,8.95) ; v2(19.45,28.95) 18.61,28.11 C2414.2 ; v2(152.06,13.27) 152.18,13.15 152.18,12.62 PR4410.2 ; PC4508.1 84.41,9.85 84.41,12.02 v2(85.07,12.68) 84.5,13.24 82.77,13.24 80.01,10.48 ED4304.1 ; RAM4.P12 111.61,28.87 111.62,28.88 111.62,29.14 v3(111.82,29.34) ; 126.06,50.08 125.62,50.08 125.39,50.31 RN2009.1 ; 126.06,50.08 RN2009.2 127.05,50.74 127.36,51.05 127.36,52.37 126.48,53.26 v2(126.48,53.74) 126.88,54.15 ED1703.2 ; 126.06,50.08 126.16,50.08 126.35,49.89 126.35,49.76 R1527.2 126.6,49.5 126.6,48.6 126.17,48.17 R2101.1 ; v2(161.45,29.86) 161.16,30.14 160.57,30.14 PR44C3.2 ; PR4413.2 149.66,12.9 v2(150.03,13.27) ; 108.72,88.12 108.7,88.1 108.7,87.39 107.86,86.55 C4043.2 ; EC8946.2 120.41,18.02 120.71,18.32 v2(120.71,18.33) ; v2(28.97,26.6) 28.97,26.6 28.97,26.78 27.43,28.32 C2415.2 ; C2219.2 112.24,63.05 113.61,63.05 v2(113.82,63.26) ; C2224.2 102.2,50.02 v2(102.2,50.49) ; PC4451.1 144.98,7.7 C9201.2 ; C2204.2 v2(106.89,51.96) ; U7002.8 194.49,31.37 194.7,31.58 195.29,31.58 195.62,31.24 v2(195.62,30.97) 195.49,31.1 U7002.7 ; v2(150.03,15.3) 149.49,15.3 147.35,17.44 147.35,17.92 147.69,18.27 147.73,18.27 148.21,18.74 148.21,18.76 PQ4418.1 ; v3(73.39,29.35) 73.51,29.23 RAM2.P12 ; v2(11.17,39.07) 11.18,39.06 R7119.2 ; C2411.2 17.89,14.04 19.92,14.04 19.97,13.99 20.37,13.99 20.45,14.07 21.6,14.07 22.19,13.48 C2429.2 ; EC8947.2 126.66,81.19 v2(126.08,80.61) ; v2(45.78,57.71) 45.78,58.4 PR4655.1 45.55,59.34 PC4644.2 ; RAM3.D8 85.93,25.67 85.93,25.6 v3(85.61,25.27) ; PR4461.2 152.69,19.54 PC4417.2 153.18,19.23 PC4416.2 154.29,18.81 v3(154.99,18.81) ; DB3.4 31.9,8.54 32.28,8.16 33.51,8.16 33.99,8.64 v2(33.99,8.8) ; v2(90.26,7.17) 90.49,7.4 90.49,8.74 EC8925.2 ; v2(11.16,36.61) 11.18,36.62 R7120.2 ; 110.93,29.36 110.43,28.87 RAM4.M12 ; RAM4.B2 103.81,20.91 v3(104.17,21.27) 104.17,21.38 RAM4.C3 ; EC8909.2 41.85,70.72 v2(42.1,70.72) 41.39,71.42 41.39,71.5 41.31,71.58 41.31,71.66 40.91,72.06 R5558.2 ; v3(106.08,22.05) 106.41,22.38 RAM4.F4 ; R502.2 98.8,50.36 v2(98.32,50.83) 97.88,50.39 C803.1 ; C6105.2 169.93,14.85 168.62,14.85 C6109.2 ; U7002.5 195.36,30.05 v2(195.62,30.31) 195.38,30.55 U7002.6 ; R2735.2 178.61,9.78 C2741.2 177.13,10.52 v2(177.11,10.54) ; RAM1.E4 48.21,25.9 v3(48.21,25.83) ; R1501.2 124.63,36.68 v2(124.26,37.05) ; v2(100.9,50.46) 100.25,50.46 R304.1 99.58,51.14 C2201.2 ; RAM4.D8 105.11,25.67 105.42,25.36 v3(105.42,25.15) ; v3(103.48,29.26) 103.48,29.2 RAM4.B12 ; v2(161.45,15.89) 161.59,15.75 161.59,13.58 158.83,10.82 158.83,9.97 EC2902.2 ; v2(100.66,48.82) 100.42,48.58 R501.2 ; v3(162.84,29.01) 159.47,29.01 159.26,28.81 PQ44A1.1 ; v2(125.42,5.97) 125.45,5.95 125.45,5.88 125.84,5.5 EC6501.2 ; ED7304.8 ED7304.3 ; PQ4415.1 141.7,3.46 141.75,3.41 v3(141.75,3.4) 142.29,2.86 PC44B2.2 142.76,3.21 144.18,3.21 144.42,3.45 PQ44B1.4 ; v2(14.29,66.99) 14.73,66.55 16.04,66.55 16.25,66.76 C6402.2 ; PQ4415.4 139.71,5.23 139.25,4.77 138.69,4.77 PC4432.2 138.15,5.27 v2(137.3,4.43) ; v3(92.5,29.44) 92.5,29.2 92.43,29.13 92.43,28.87 RAM3.P12 ; 116.92,22.59 C6318.2
  TOP w0.254: RAM3.G3 87.88,21.67 87.88,21.74 v3(87.56,22.07) 87.88,22.39 RAM3.G4 ; RAM2.M4 72.52,22.78 v3(72.52,22.88) 72.52,22.96 72.21,23.27 RAM2.M5 ; RAM3.L6 90.81,23.74 v3(90.81,23.67) ; RAM4.M6 110.31,24.07 110.64,23.74 v3(110.64,23.67) ; v3(67.34,22.87) 67.34,22.95 RAM2.E5 ; v3(86.91,22.07) 86.91,22.15 RAM3.F4 ; v3(66.04,23.67) 66.36,23.99 RAM2.C6 ; RAM4.C6 104.46,24 v3(104.14,23.68) ; RAM4.G4 107.06,22.47 106.74,22.07 ; RAM2.N5 72.86,23.27 73.17,22.96 v3(73.17,22.88) ; RAM2.C3 66.04,21.35 v3(66.04,21.27) 65.71,20.94 RAM2.B2 ; v3(110.64,22.87) 110.64,22.94 110.31,23.27 RAM4.M5 ; v3(75.14,21.27) 75.14,21.34 74.81,21.67 RAM2.T3 ; v3(84.96,22.87) 85.28,23.19 RAM3.C5 ; RAM3.G8 88.2,25.99 v3(88.2,26.06) 87.88,26.38 87.88,26.47 RAM3.G9 ; 71.56,26.47 71.27,26.14 71.27,26.06 v3(71.25,26.06) ; 71.56,26.47 RAM2.L9 ; 71.56,26.47 71.25,26.85 v3(71.22,26.88) 71.21,26.89 71.21,26.9 70.91,27.27 RAM2.K10 ; 112.26,24.07 111.85,24.48 111.37,24.48 110.96,24.07 ; 112.26,24.07 RAM4.R6 ; 112.26,24.07 112.91,24.07 RAM4.T6 ; v3(94.06,22.07) 94.06,22.14 RAM3.T4 ; v3(70.59,22.07) 70.59,22.14 70.26,22.47 RAM2.J4 ; v3(106.83,25.16) 107.08,25.61 RAM4.G8 107.33,25.94 107.33,26.2 107.06,26.47 RAM4.G9 ; v3(91.46,22.07) 91.46,22.14 RAM3.M4 ; v3(67.99,22.87) 68.31,23.19 RAM2.F5 ; RAM2.R5 74.16,23.27 74.16,23.19 v3(74.47,22.88) ; RAM4.B5 103.49,22.95 v3(103.49,22.87) ; RAM3.N5 92.11,22.94 v3(92.11,22.87) ; v3(84.96,23.67) 85.28,23.99 RAM3.C6 ; v3(111.28,25.04) 111.28,25.34 111.61,25.67 RAM4.P8 ; RAM3.T2 93.74,20.87 v3(94.06,21.27) 94.06,21.34 RAM3.T3 ; RAM4.G3 107.06,21.67 106.74,22.04 106.74,22.07 ; v3(69.27,26.87) 69.27,26.78 68.96,26.47 RAM2.G9 ; C7202.1 29.62,65.23 29.71,65.14 v3(29.85,65.14) ; v3(56,33.03) 56,32.93 55.68,32.61 RAM1.T12 ; RAM2.T4 74.81,22.47 75.14,22.14 v3(75.14,22.07) ; RAM3.N4 92.11,22.14 v3(92.11,22.07) ; v3(67.34,23.67) 67.34,23.75 RAM2.E6 ; RAM3.B6 84.63,24.07 84.31,23.74 v3(84.31,23.67) ; RAM4.N5 110.96,23.27 111.29,22.94 v3(111.29,22.87) ; RAM3.K10 89.83,27.27 ; 89.83,27.27 89.83,27.21 v3(89.5,26.87) ; 89.83,27.27 90.48,26.62 90.48,26.47 RAM3.L9 ; RAM2.R4 74.16,22.47 74.49,22.14 v3(74.49,22.07) ; RAM3.T5 94.06,22.94 v3(94.06,22.87) ; v3(104.14,22.87) 104.14,22.95 RAM4.C5 ; v3(88.96,29.34) 89.18,29.12 89.18,28.87 RAM3.J12 ; RAM1.C3 47.23,25.41 46.91,25.73 v3(46.91,25.79) ; RAM3.P3 92.76,21.34 v3(92.76,21.27) ; RAM2.M6 72.21,24.07 72.54,23.74 v3(72.54,23.67) ; RAM4.F5 106.09,22.95 v3(106.09,22.87) ; v3(108.04,27.66) 107.71,27.33 RAM4.H10 ; RAM3.R5 93.41,22.94 v3(93.41,22.87) 93.09,22.47 RAM3.R4 ; v3(92.1,25.19) 92.1,25.34 92.43,25.67 RAM3.P8 ; RAM3.E4 86.58,22.47 86.26,22.14 v3(86.26,22.07) 85.94,21.67 RAM3.D3 ; RAM3.G6 87.88,23.99 v3(87.56,23.67) ; v3(73.18,25.19) 73.18,25.34 RAM2.P8 ; v3(88.23,26.87) 88.23,26.97 RAM3.H10 ; RAM3.B12 84.63,28.87 84.63,28.91 v3(84.3,29.25) ; RAM4.F12 106.41,28.87 106.45,28.96 106.45,28.99 v3(106.81,29.35) ; v2(13.41,36.8) 13.74,37.13 ED7301.8 ED7301.3 ; RAM2.N4 72.86,22.47 72.92,22.39 v3(73.19,22.07) 73.51,21.67 RAM2.P3 ; v3(88.86,22.05) 88.86,22.14 89.18,22.47 RAM3.J4 ; RAM4.T4 RAM4.T3 RAM4.T2 ; v3(51.78,23.52) 51.78,24.61 RAM1.K2 ; RAM2.F6 67.99,23.75 v3(67.99,23.67) ; RAM3.D12 85.93,28.87 85.93,29.28 v3(86.02,29.36) ; RAM2.B5 65.39,22.95 v3(65.39,22.87) ; RAM3.E6 86.26,23.75 v3(86.26,23.67) ; C1230.2 69.89,31.78 69.89,30.49 69.96,30.42 v3(69.96,29.29) 70.26,28.98 RAM2.J12 ; v3(74.49,23.67) 74.49,23.74 74.16,24.07 RAM2.R6 ; RAM3.M5 91.46,22.94 v3(91.46,22.87) ; v3(106.1,23.68) 106.1,23.76 RAM4.F6 ; RAM4.N4 110.96,22.47 111.29,22.14 v3(111.29,22.07) ; v3(74.48,21.26) 74.48,21.2 74.81,20.87 RAM2.T2 ; v3(107.55,20.4) 107.71,20.56 RAM4.H2 ; RAM3.E5 86.58,23.27 86.26,22.94 v3(86.26,22.87) ; RAM2.N6 72.86,24.07 73.19,23.74 v3(73.19,23.67) ; v3(66.04,22.87) 66.36,23.19 RAM2.C5 ; RAM1.J12 51.13,32.61 51.13,33 v3(51.53,33.39) 51.57,33.44 C1215.2 ; v3(94.06,23.67) 94.06,23.74 RAM3.T6 ; 110.96,24.07 RAM4.N6 ; 110.96,24.07 111.29,23.74 v3(111.29,23.67) ; RAM2.T6 74.81,24.07 75.14,23.74 v3(75.14,23.67) ; v3(84.31,22.87) 84.31,22.95 RAM3.B5 ; RAM1.B2 46.58,24.61 46.94,24.25 v3(46.94,24.21) ; RAM3.L8 90.76,25.39 v3(90.76,25.2) ; RAM3.F5 87.23,23.19 v3(86.91,22.87) ; v3(54.77,33.07) 54.38,32.68 54.38,32.61 RAM1.P12 ; RAM2.D3 67.01,21.67 v3(67.34,22.07) 67.34,22.15 RAM2.E4 ; RAM3.R6 93.41,23.74 v3(93.41,23.67) ; v3(52.85,33.05) 53.08,32.82 53.08,32.61 RAM1.M12 ; v3(108.68,26.87) 109.01,27.21 RAM4.K10 ; v3(105.45,23.68) 105.45,23.76 RAM4.E6 ; v3(105.44,22.87) 105.44,22.95 RAM4.E5 ; v3(71.89,23.67) 71.89,23.74 71.56,24.07 RAM2.L6 ; RAM3.C3 84.96,21.35 v3(84.96,21.27) ; v3(109.92,24.54) 109.92,24.33 RAM4.L6 ; RAM3.F12 87.23,28.87 87.23,28.96 v3(87.54,29.27) 87.96,29.69 87.96,30.33 87.77,30.53 C1330.2 ; 111.96,22.07 111.96,22.02 111.61,21.67 RAM4.P3 ; 111.96,22.07 111.96,22.12 112.26,22.42 112.26,22.47 RAM4.R4 ; 111.96,22.07 v3(111.96,22.07) ; RAM4.B6 103.48,23.74 v3(103.48,23.69) ; RAM3.F6 87.23,24.07 86.91,23.74 v3(86.91,23.67) ; RAM2.G8 69.07,25.56 v2(69.22,25.2) ; v3(104.76,21.28) 105.11,21.62 RAM4.D3 ; RAM4.K2 109.01,20.87 v3(109.01,20.35) ; RAM2.T5 74.81,23.27 75.12,22.96 v3(75.12,22.88) ; v3(108.71,22.07) 108.72,22.07 108.72,22.08 108.69,22.08 108.69,22.14 108.36,22.47 RAM4.J4 ; v3(106.75,23.68) 107.06,23.99 RAM4.G6 ; RAM2.B6 65.39,23.75 v3(65.39,23.67) ; v3(48.21,25.83) 47.88,25.5 47.88,25.41 RAM1.D3 ; RAM2.G3 v3(68.66,22.07) 68.96,22.38 RAM2.G4 ; v2(16.64,44.7) 16.47,44.53 ED7304.8 ; v3(69.96,20.37) 69.96,20.52 69.61,20.87 RAM2.H2 ; RAM4.J12 108.36,29.02 108.41,29.07 108.41,29.11 108.44,29.14 108.44,29.48 108.04,29.87 v3(108.01,29.87) 108.01,30.44 107.84,30.61 C1315.2 ; v3(71.36,25.21) 71.36,25.47 RAM2.L8 ; v3(91.46,23.67) 91.46,23.74 RAM3.M6 ; v2(49.96,24.11) 50.46,24.61 RAM1.H2 ; v3(110.42,30.38) 110.46,30.38 110.93,29.91 110.93,29.36 ; v3(23.03,77.4) 23.03,76.69 R7411.2 ; 106.74,22.07 v3(106.74,22.05) ; RAM3.H2 88.33,20.4 v3(88.33,20.27) ; v3(89.79,20.37) 89.83,20.41 RAM3.K2 ; RAM2.K2 70.54,20.5 v3(70.54,20.4) ; v3(68.64,23.67) 68.96,23.99 RAM2.G6 ; v3(67.99,22.07) 67.99,22.15 RAM2.F4 ; v3(69.28,27.66) 69.61,27.33 RAM2.H10 ; v3(109.33,26.06) 109.66,26.39 RAM4.L9 ; RAM4.M4 110.31,22.47 110.63,22.15 v3(110.63,22.08) ; RAM3.N6 92.11,23.74 v3(92.11,23.68) ; v3(68.41,29.39) 68.31,29.29 RAM2.F12 ; RAM4.L8 109.33,25.34 v3(109.33,25.15) ; 104.85,29.87 105.27,29.45 105.27,29.03 105.11,28.87 RAM4.D12 ; v3(106.08,22.05) 106.07,22.05 106.07,22.05 105.76,22.47 RAM4.E4
  TOP w0.305: v3(69.2,53.34) 69.2,52.81 C1107.2 ; FC8916.2 133.1,61.94 134.67,61.94 FC8915.2 136.3,61.64 v2(136.64,61.98) ; C1323.2 72.48,31.63 72.48,29.88 71.96,29.36 v3(71.91,29.36) ; ED5504.2 108.8,59.59 v2(108.8,59.09) ; R8604.2 186.93,39.43 v2(186.65,39.71) ; PC5115.2 33.17,43.5 33.6,43.93 v4(33.82,43.93) ; C4007.2 93.4,34.56 FC8971.2 93.22,35.98 EC8940.2 91.86,35.98 C1140.2 92.06,36.21 92.06,36.99 91.67,37.38 v3(91.55,37.38) ; EC8926.2 65.59,11.54 v2(65.32,11.27) 65.17,11.41 EC8944.2 ; v2(68.81,57.18) 68.52,56.89 66.88,56.89 PC1065.2 PC1064.2 PC1051.2 PC1047.2 62.9,56.57 PC1056.2 ; RAM3.B2 84.96,21.2 v3(84.96,21.27) ; v2(23.69,26.56) 23.69,26.67 24.53,27.51 C2418.1 24.67,27.41 26.13,27.41 DB1.16 ; v2(77.85,47.56) 77.93,47.48 C1139.2 ; v2(189.29,15.83) 189.24,15.77 C2709.1 ; C806.2 100.19,58.69 C805.2 99.53,58.71 v2(99.45,58.78) 99.43,58.76 C1112.2 ; C4035.2 89.92,34.97 C1343.2 89.93,35.58 v3(89.99,35.64) ; v2(61.82,33.8) 61.85,33.83 FC8936.2 62.52,33.79 R1225.2 63.29,33.82 FC8935.2 64.07,33.84 R1223.2 ; C1106.2 72.17,54.24 v2(72.06,54.35) ; C8040.2 157.86,65.05 v2(158.43,64.47) ; R7245.1 27.93,61.77 27.87,61.77 27.8,61.69 26.87,61.69 R7202.2 26.91,61.2 v3(26.91,60.63) ; C1109.2 97.57,56.72 PC1072.2 99.2,57.43 C1112.2 ; v2(163.54,11.71) 163.59,11.66 163.59,9.68 EC2903.2 EC2904.2 ; PC5114.2 32.9,39.88 v2(32.74,40.04) ; C1253.2 C1338.2 97.27,21.37 v2(96.99,21.65) ; C1132.2 86.75,36.11 C1138.2 86.1,36.17 85.98,36.29 v3(85.87,36.29) ; v2(140.19,83.68) 139.94,83.43 C4012.2 138.6,83.47 U4006.5 ; PQ4405.4 152.54,22.55 152.49,22.6 v3(152.37,22.6) 152.3,22.52 152.3,21.87 PR4438.2 ; v2(15.28,61.99) ED5703.8 ED5703.3 ; 48.82,75.95 48.28,75.41 FC8947.2 48.28,74.91 48.02,74.65 v2(48.02,74.48) ; C1313.2 96.59,23.88 C1142.2 ; C1313.2 96.72,23.74 C1371.2 ; C1313.2 96.61,23.42 96.69,23.34 96.69,22.54 96.27,22.12 v2(96.27,22.02) ; 79.11,0.83 79.07,0.87 PR4502.2 ; R720.2 88.18,64.06 88.68,63.56 v2(88.68,63.17) ; C6105.2 170.27,14.12 C6110.2 170.33,13.44 v2(171.44,13.44) C2740.2 ; FC8929.2 FC8930.2 ; FC8929.2 23.36,42.2 C7117.2 ; FC8929.2 23.73,42.66 v2(23.05,43.34) ; v2(142.54,48.78) 142.49,48.83 Q7907.4 ; EC8945.2 60.03,75.91 59.61,75.48 58.51,75.48 C5515.2 ; C2720.2 176.35,19.14 C2721.2 ; PR44C1.2 158.09,31.56 PC44C3.2 158.65,31 159.73,31 160.23,30.5 160.23,30.26 PR44C3.2 ; C2525.2 169.83,34.87 v3(169.83,35.47) ; v4(34.68,43.94) 34.8,44.06 FC8950.2 36.84,42.99 FC8949.2 ; C6308.2 114.45,17.18 114.3,17.33 v2(114.01,17.33) ; RAM2.D12 67.01,29.46 66.49,29.98 v3(66.46,29.98) ; R2108.1 109.4,55.96 v2(108.92,55.96) 108.92,55.64 C2222.2 ; EC5504.2 v4(57.19,77.12) ; R7123.2 11.09,29.22 v2(10.88,29.42) ; PC4631.2 38.57,61.12 v2(38.21,60.76) ; C2714.2 184.97,20.96 185.38,21.37 185.38,21.38 v2(185.36,21.38) ; C1141.2 77.43,35.58 v3(77.36,35.65) ; EC8941.2 101.15,33.18 FC8970.2 ; EC8941.2 100.85,33.4 C4032.2 ; EC8941.2 101.11,33.54 101.27,33.7 101.27,33.96 101.29,33.96 101.29,33.94 v2(101.29,33.94) 101.1,34.13 R1525.2 ; Q2510.S 24.65,12.51 23.93,13.23 22.22,13.23 C2429.2 ; v2(17.61,53.65) ED5701.8 ED5701.3 ; C1231.2 63.49,25.38 EC8931.2 63.74,24.72 v2(63.33,24.31) ; v2(148.66,10.05) 147.72,9.11 PC4440.2 ; v2(194.35,12.41) 193.03,12.41 R2706.2 ; v2(148.22,63.76) 148.48,63.5 C7614.2 ; v2(158.76,54.35) 159.66,54.35 C8037.2 C7905.2 ; v2(15.79,31.12) ED7302.3 ED7302.8 ; v2(15.74,34.5) 15.74,34.28 15.2,33.74 R7141.2 ; PC5001.2 101.86,87.52 PU5002.4 102.99,87.11 103.63,86.47 v2(103.74,86.47) ; C1103.2 69.94,47.5 v2(69.55,47.9) ; ED5702.3 ED5702.8 v2(17.11,50.47) ; U4003.5 108.08,82.42 107.38,81.72 C4010.2 106.85,81.23 v2(106.79,81.17) ; C7630.2 157.5,68.71 v2(157.04,68.71) 156.47,69.28 C7616.2 ; v2(163.15,16.34) 163.14,16.34 163.14,16.32 163.39,16.07 163.39,15.51 EC8924.2 ; v3(83.27,37.19) 83.43,37.19 C1131.2 ; v2(112.11,12.79) 112.16,12.85 EC4310.2 ; C1355.2 80.91,35.89 v3(81.57,35.89) ; FSW1.6 FSW1.7 172.22,20.19 172.22,19.72 172.29,19.65 v2(172.29,19.67) ; v2(42.76,39.01) 42.63,39.01 42.14,39.5 EC8908.2 ; C1112.2 99.43,57.17 100.24,56.36 ; v2(92.87,50.83) 93.38,50.32 C1133.2 93.36,49.88 PC1084.2 ; v3(140.29,51.3) 140.32,51.26 140.32,50.68 Q7907.1 ; v2(186.1,74.77) 186.1,74.95 186.57,75.42 186.58,75.42 186.77,75.62 C8226.2 ; C4006.2 104.53,32.06 C1324.2 104.79,31.24 104.86,31.17 104.86,29.87 104.85,29.87 v3(104.81,29.87) ; PR8632.2 178.81,34.76 PC8616.2 ; C2414.2 18.12,28.06 C7115.2 17.84,27.87 17.47,27.5 16.62,27.5 R4006.2 ; R7223.2 33.06,60.51 v2(33.46,60.91) 32.77,61.61 C7211.2 31.76,63.04 C7201.1 ; v2(161.45,29.86) 161.45,30.82 161.02,31.25 161.02,31.78 PC44C1.2 ; v2(177.11,10.54) 177.05,10.6 176.36,10.6 175.82,10.05 C2723.2 175.75,9.84 C2739.2 ; v3(110.42,30.38) 110.09,30.71 C1326.2 C1219.2 ; PQ4405.1 154.57,24.2 v2(155.58,23.19) ; RN7202.4 25.95,64.27 25.74,64.48 25.74,65.09 v2(25.79,65.15) 26,64.94 RN7202.3 26.61,65.19 27.14,65.72 27.14,65.8 27.3,65.95 Q7404.4 ; C1354.2 101.06,23.1 v2(100.99,23.1) ; PC5004.2 101.77,83.59 v2(101.92,83.44) ; v3(73.57,35.1) 73.57,34.36 C1137.2 ; v2(31.89,56.72) 31.67,56.94 R4377.2 ; v3(75.42,35.55) 75.89,35.55 C1275.2 ; U9101.23 181.71,27.66 181.71,27.66 181.71,27.66 181.51,27.45 181.5,27.45 C9113.2 ; v2(53.33,80.14) 53.33,79.99 53.99,79.32 EC5503.2 53.97,78.94 R5512.2 ; R601.1 80.5,60.04 80.94,59.6 v2(80.94,59.46) ; C4302.2 32.38,80.17 v2(32.38,81.39) 32.38,81.78 EC8943.2 ; v2(52.62,77.5) 52.03,76.91 ED5503.2 ; PC4424.1 143.93,10.64 142.42,10.64 141.96,11.1 PC4439.2 141.96,12.33 142.32,12.68 143.99,12.68 v2(144.27,12.96) ; U6402.3 9.59,69.98 v2(10.1,70.49) ; PR4417.2 152.23,14.11 v2(152.06,14.28) ; v2(59.4,23.8) 59.52,23.93 C1214.2 C1329.2 58.84,24.29 C1279.2 ; C5556.2 38.01,82.33 v2(38.42,82.74) ; C1104.2 67.99,53.33 v3(68.01,53.35) ; EC2710.2 174.68,15.05 175.67,15.05 175.86,14.87 ; v3(94.07,30.08) 93.36,30.79 C1220.2 ; C1804.2 103.59,37.04 v2(103.78,37.23) ; C6106.2 170.45,31.68 169.8,32.33 169.04,32.33 C6111.2 ; C2405.2 18.87,11.9 18.27,11.3 v2(17.44,11.3) ; USB1.22 3.03,40.26 3.09,40.31 ; v2(127.42,46.31) 127.56,46.45 C2610.2 ; v2(36.73,69.84) 35.9,69.01 34.94,69.01 34.65,69.3 34.65,69.5 34.63,69.52 34.63,70.2 34.59,70.24 EL4304.2 ; PC1081.2 88.36,49.76 C1135.2 87.32,50.67 v2(87.43,50.78) ; C1369.2 57.95,20.79 C1268.2 ; EC2711.2 173.73,18.12 173.73,17.2 v2(173.82,17.12) 174.12,17.42 EC2709.2 174.62,17.31 EC2706.2 ; v2(188.45,59.57) 188.54,59.49 C8209.2 ; ED7303.3 ED7303.8 12.72,42.54 12.18,43.09 v2(11.81,43.09) ; v3(25.05,61.44) 25.17,61.32 R7236.2 ; v3(154.99,18.81) 155.07,18.73 PC4419.2 ; FC8967.2 92.07,6.28 FC8931.2 91.03,6.53 v2(90.26,6.53) ; EC8952.2 61.47,10.11 58.51,13.07 57.32,13.07 v2(57.32,13.08) ; v2(21.07,64.01) 21.09,63.99 23.29,63.99 23.79,64.5 EC8918.2 ; v3(94.94,37.13) 95.04,37.13 95.82,36.36 95.82,35.15 96.1,34.87 U4002.5 ; C6504.2 23.82,5.99 24.28,5.53 C2517.2 24.93,5.43 v2(24.98,5.38) ; C2220.2 105.94,61.19 v2(106.36,61.19) 106.37,61.2 v2(107.21,61.2) 107.23,61.19 R1601.1 ; R7122.2 11.77,31.97 11.71,32.02 11.71,32.3 11.67,32.34 11.67,32.52 v2(11.67,32.52) 11.67,33.4 R7330.2 ; FSW1.5 171.69,28.19 171.69,29.52 170.74,30.47 v2(170.38,30.47) ; v3(28,60.66) 28,60.05 C7210.2 ; v2(22.29,69.31) 21.87,69.73 20.3,69.73 20.12,69.54 Q7406.4 ; PR4406.2 152.44,15.68 v2(152.06,15.3) ; PQ44A1.4 160.65,27.27 160.01,26.63 159.06,26.63 v3(158.78,26.35) ; PR4426.2 157.45,13.25 157.76,13.55 157.76,14.23 157.59,14.39 v2(157.59,15.05) 156.36,15.05 PC4420.2 ; v2(39.17,9.94) 39.98,10.75 C8903.2 ; v2(182.89,32.54) 182.89,32.01 182.84,31.96 U9101.16 ; v2(25.56,34.3) 25.71,34.45 EC8922.2 ; HDMI1.20 11.23,50.61 11.24,50.6 ; v2(141.39,26.04) 141.39,26.5 PC8566.2 ; Q1701.4 129.83,63.74 v2(130.63,64.55) 131.35,63.83 PC8612.2 130.68,61.78 130.68,61.37 130.68,61.37 130.68,60.92 130.68,60.92 130.68,60.88 130.31,60.51 Q1702.4 ; CARD1.13 11.74,19.24 11.34,19.65 11.34,19.66 10.72,20.28 v2(10.35,20.28) ; v2(65.32,75.44) 65.65,75.44 66.03,75.82 FC8946.2 66.77,76.09 FC8945.2 ; C1108.2 98.81,54.91 C1128.2 98.81,54.03 C2223.2 98.96,53.89 v2(99.56,53.89) ; C1312.2 73.47,31.45 73.47,30.33 v3(73.4,30.27) ; C7212.2 26.99,59.7 27.63,59.06 29.53,59.06 v2(29.6,59.13) ; v2(75.91,11.49) 75.91,10.64 C8902.2 ; RAM2.B12 65.71,28.94 v3(65.39,29.26) ; v2(18.71,21.9) 19.11,21.5 19.95,21.5 20.22,21.77 R2454.2 ; 82.31,49.26 82.28,49.23 82.28,48.04 81.8,47.56 C1136.2 ; C804.2 77.72,36.87 v3(77.34,36.87) ; Q7404.1 25.65,68.35 v2(25.18,68.81) 24.88,69.12 24.6,69.12 24.6,69.12 Q7405.4 ; v2(186.93,23.47) 186.89,23.47 Q4001.S 184.98,22.32 C2713.2 ; C2208.2 105.68,73.66 105.68,73.66 105.98,73.35 109.7,73.35 v2(110.38,74.04) ; v2(26.93,71.23) 26.93,71.13 27.3,70.76 R7409.2
  TOP w0.33: RAM1.D12 47.88,32.61 47.88,33.33 48.26,33.71 v3(48.37,33.71) ; RAM1.J4 51.13,26.21 v3(50.8,25.81) ; RAM1.F12 49.18,32.61 49.18,33.22 49.71,33.76 v3(49.86,33.76)
  TOP w0.356: PC5108.2 34.28,39.71 33.69,39.71 PC5103.2 33.36,40.04 v2(32.74,40.04)
  TOP w0.508: H5.1 10.94,44.5 ; H5.1 4.66,44.5 ; H5.1 7.8,41.36 ; H5.1 7.8,47.64 ; R1201.2 v2(43.9,19.33) 44.13,19.11 C1370.2 44.67,19.18 R1202.2 ; C7006.2 192.23,33.42 C2605.2 194.42,35.36 EC8949.2 194.44,35.36 194.44,34.98 v2(194.76,34.66) ; C7006.2 193.08,32.57 C7005.2 ; C7006.2 191.05,33.08 AFTP2604.1 ; C1268.2 58.46,20.83 v2(58.64,21.01) 58.86,21.24 C1265.2 ; PR5155.2 36.74,33.94 v2(36.18,33.94) ; R9131.2 190.17,27.21 v2(190.17,26.98) ; C1253.2 96.81,19.02 96.81,18.25 95.7,17.15 C1269.2 ; 8.14,37.57 USB1.20 9.23,38.36 ; EC8907.2 104.56,76.15 104.56,75.97 104.54,75.95 v2(104.54,75.56) 104.62,75.49 C2209.2 105.19,74.88 C2208.2 ; C2412.2 25.16,28.32 C2415.2 ; LED1.3 4,69.43 4.84,68.59 v2(6.14,68.59) ; EC4306.2 86.94,14.3 89.89,14.3 91.02,13.17 v2(91.02,13.11) ; v2(60.9,18.5) 61.12,18.5 61.78,17.84 R1204.2 R1203.2 ; v2(60.9,18.5) 60.14,18.5 C1372.2 ; v2(60.9,18.5) C1356.2 60.9,20.43 C1278.2 ; C9109.2 180.3,26.43 v2(180.35,26.48) C9112.2 180.36,27.12 C9113.2 v2(181.17,26.43) ; R9804.2 v2(176.73,27.99) ; v2(16.45,8.79) 16.77,9.12 17.23,9.12 AFTP2507.1 ; C1245.2 69.66,35.84 EC8942.2 70.14,36.48 70.14,37.28 v3(70.33,37.46) ; C2411.2 16.68,13.62 C2410.2 16.06,13.63 15.7,13.99 15.7,14.71 15.95,14.97 v2(16.02,14.97) ; v2(18.96,72.4) 18.96,71.76 R7428.2 ; v2(17.44,11.3) 17.88,10.86 R2504.2 ; DB1.3 v2(30.36,14.67) ; C2718.2 179.51,20.8 C2717.2 179.79,21.08 179.79,22.91 EC8950.2 179.72,22.99 v2(178.07,22.99) ; DB3.7 33.89,10.29 34.94,9.24 34.94,7.59 DB3.8 33.89,4.22 v2(33.64,3.97) ; R2706.2 193.01,12.4 R2705.2 193.01,11.12 R2704.2 ; C8603.2 148.57,82.31 v2(148.55,82.33) ; PC4451.1 146.47,8.56 PC4440.2 ; R6120.1 v2(170.38,30.47) ; v2(170.38,30.47) 170.45,30.53 C6106.2 ; v2(170.38,30.47) 169.94,30.02 C6104.2 ; v2(27.39,80.08) 27.39,79.61 C4303.2 ; v2(27.39,80.08) 27.39,80.6 R4308.2 ; v2(27.39,80.08) 28.07,80.08 C4305.2 C4304.2 ; USB1.21 6.9,40.01 ; USB1.21 5.56,39.17 ; USB1.21 8.23,39.17 ; USB1.21 8.23,40.01 ; R1229.2 62.47,36.7 63.34,37.56 64.45,37.56 v2(64.56,37.46) ; 39.5,82.7 39.49,82.7 C5507.2 39.5,81.86 C5508.2 ; EC2703.2 181.78,7.2 181.95,7.37 v2(181.93,7.37) ; v2(18.71,21.9) 18.48,21.68 R2445.1 ; v2(177.93,67.83) 177.79,67.98 176.84,67.98 C8210.2 176.55,68.14 176.09,68.14 R7807.2 175.99,68.19 R7806.2 ; CARD1.11 13.91,8.46 13.91,7.38 12.83,6.3 CARD1.10 v2(10.51,6.3) ; C1130.2 54.7,33.14 v3(54.77,33.07) ; ED1702.2 176.23,30.58 v2(176.62,30.97) ; R8111.2 180.62,62.38 R7820.2 180.23,62.39 v2(179.95,62.11) ; R6118.1 166.85,27.63 R6119.1 166.25,27.64 v2(165.89,28) ; v2(19.82,4.51) 19.63,4.51 19.4,4.28 19.4,4.07 R2518.2 ; EC8920.2 63.74,2.14 EC8928.2 63.77,0.91 63.84,0.84 ; v2(141.39,26.04) 142.26,26.04 PR8569.2 ; 10.02,67.24 10.91,66.35 HDMI1.21 9.89,65.01 9.89,64.85 ; v2(25.77,46.92) 25.76,46.92 PC5307.2 ; R7821.2 177.88,69.63 v2(177.73,69.78) ; PC1058.2 v2(75.86,58.43) ; HS2.1 41.27,25.14 ; HS2.1 36.9,25.14 ; HS2.1 39.09,22.95 ; HS2.1 39.09,27.32 ; R8604.2 187.62,38.93 188.66,37.89 EC2601.2 ; v2(190.17,26.98) 190.17,26.17 C9106.2 189.93,25.15 EC8923.2 ; v2(190.17,26.98) 190.13,26.94 C9108.2 ; v2(60.72,84.03) 60.36,83.67 C5516.2 59.38,83.04 C5518.2 ; v2(14.03,45.57) 13.81,45.57 C6715.2 ; C4009.2 11.89,29.1 R7123.2 ; EC8953.2 189.7,7.73 v2(189.7,8.21) ; v2(192.4,14.04) 193.03,14.67 EC2704.2 EC2705.2 ; v2(61.91,83.85) 62.85,82.91 C5517.2 ; v2(51.6,62.74) 51.6,62.77 PC4633.2 ; PC1063.2 64.76,54.54 v2(63.54,54.54) PC1039.2 ; v2(108.21,34.49) 108.1,34.6 108.1,36.12 C1803.2 ; v2(194.94,38.93) 194.2,38.93 C2604.2 ; C2428.2 23.6,26.47 v2(23.69,26.56) ; PC8561.2 140.75,28.19 v2(140.78,28.15) ; C5503.2 57.22,80.18 v2(56.78,80.62) ; Q2510.S 24.74,12.3 25.66,11.37 DB1.15 ; PR8632.2 179,35.13 179,35.66 v2(178.88,35.77) 178.41,36.25 PR8626.2 178.15,37.05 PC8618.2 ; v2(80.51,0.76) 80.02,1.25 80.02,1.66 PR4556.2 ; C4039.2 196.91,17.33 v2(197.24,17.66) ; PR4718.2 89.25,85.74 v2(89.38,85.61) ; C6505.2 118.29,6.13 118.34,6.08 v2(118.34,6.08) ; v2(22.42,3.22) 22.42,4.94 EC8954.2 ; v2(175.86,15.62) 175.86,14.87 C2722.2 ; R2453.2 61.01,1.1 61.28,0.84 ; C1276.2 59.14,22.92 v2(59.4,23.17) ; v2(188.14,32.82) 187.98,32.97 186.86,32.97 EC8914.2 ; v2(188.14,32.82) C9104.2 ; v2(188.14,32.82) 188.14,33.41 EC2602.2 ; HDMI1.20 10.02,53.06 10.02,53.07 ; C4037.2 197.15,16.39 ; v2(110.01,63.16) 109.34,63.83 R403.1 ; PC4501.2 85.17,0.93 85.15,0.91 ; R1321.2 R1322.2 68.77,36.7 68.42,37.05 v2(66.87,37.05) ; C2215.2 134.07,80.98 v2(133.97,80.88) ; 17.92,73.91 18.08,73.75 R6413.2 ; R7146.2 v2(25.56,34.3) ; 7.06,36.3 USB1.B1 7.69,37.34 ; R7002.2 v2(195.71,27.09) ; v2(25.23,55.81) 24.3,56.75 C7218.2 ; R4316.2 26.62,79.58 v2(26.62,80.22) ; C6308.2 114.72,17.16 C6306.2 114.72,14.91 116.65,12.99 ED4305.1
  L3 w0.127: v2(148.17,66.16) 148.17,66.96 143.77,71.35 143.17,71.35 142.19,72.33 142.19,75.35 142.89,76.05 142.89,76.35 142.82,76.42 142.82,76.56 140.15,79.23 136.62,79.23 136.45,79.06 134.15,79.06 v2(134.13,79.08) ; v2(146.43,65.54) 146.23,65.54 141.01,70.76 141.01,75.54 139.25,77.3 130.92,77.3 128.84,75.22 128.84,74.11 128.04,73.3 128.04,72.47 127.74,72.17 127.49,72.17 126.29,70.98 123.1,70.98 121.26,72.81 120.42,72.81 120.04,73.2 v2(120.04,73.23) ; v2(93.43,61.18) 93.49,61.24 93.49,62.78 93.7,62.99 v2(93.7,63.34)
  L3 w0.203: v2(134.13,79.08) 130.49,79.08 128.33,76.92 127.85,76.92 126,75.06 124.53,75.06 v2(124.17,75.42)
  L3 w0.305: HDMI1.21 10.92,66.35 9.89,65.32 ; HDMI1.20 11.23,52.58 10.71,53.1 ; 7.41,28.6 9.2,28.6 USB1.15
  L3 w0.508: 4.36,27.02 USB1.13 3.03,26.19 ; USB1.21 8.23,39.17 ; USB1.21 5.56,39.17 ; USB1.21 8.23,40.01 ; USB1.21 6.9,40.01 ; 4.61,23.1 H20.1 ; H20.1 8.98,23.1 ; H20.1 6.8,25.28 ; USB1.14 8.23,26.19 ; USB1.14 5.56,26.19 ; USB1.14 6.9,26.19 ; USB1.14 5.56,27.02 ; 7.8,42.31 H5.1 ; H5.1 5.61,44.5 ; H5.1 7.8,46.68 ; 3.03,40.01 USB1.22 4.36,39.17
  L5 w0.127: v2(106.11,46.89) 106.23,46.89 106.55,46.57 106.55,46.04 107.16,45.43 v2(107.17,45.43)
  L5 w0.305: HDMI1.21 10.92,66.35 9.85,65.29 ; HDMI1.20 11.14,51.85 9.89,53.11
  L5 w0.508: 7.8,42.31 H5.1 ; H5.1 5.61,44.5 ; H5.1 7.8,46.68 ; USB1.21 6.9,40.01 ; USB1.21 8.23,40.01 ; USB1.21 5.56,39.17 ; USB1.21 8.23,39.17 ; 4.36,39.17 USB1.22 3.03,40.01
  L6 w0.305: 9.9,65.29 10.97,66.35 HDMI1.21 ; HDMI1.20 11.03,51.85 9.97,52.92
  L6 w0.508: H14.1 169.03,43.33 ; H14.1 164.45,43.33 ; H14.1 166.74,41.04 ; H14.1 166.74,45.62 ; 6.9,26.19 USB1.14 ; USB1.14 5.56,26.19 ; USB1.14 5.56,27.02 ; USB1.14 8.23,26.19 ; USB1.21 6.9,40.01 ; USB1.21 8.23,40.01 ; USB1.21 8.23,39.17 ; USB1.21 5.56,39.17 ; 7.8,42.31 H5.1 ; H5.1 7.8,46.68 ; H5.1 5.61,44.5 ; 6.8,20.91 H20.1 ; H20.1 4.61,23.1 ; H20.1 6.8,25.28 ; 3.03,26.19 USB1.13 4.36,27.02 ; 4.36,39.17 USB1.22 3.03,40.01
  L8 w0.127: v2(107.91,48.18) 108.36,47.74 108.36,47.31 v2(108.83,46.84) ; v2(104.27,48.23) 103.82,47.78 103.82,47.31 v2(103.36,46.85) ; v2(106.11,46.89) 106.11,46.89 106.57,47.35 106.57,47.73 v2(106.13,48.17)
  L8 w0.305: 9.9,52.84 10.89,51.85 HDMI1.20 ; 9.84,65.42 10.77,66.35 HDMI1.21
  BOTTOM w0.076: v3(66.54,49.1) 66.73,48.9 66.93,48.9 66.95,48.89 67.25,48.89 67.27,48.9 67.29,48.9 67.55,49.16 CPU1.B27 ; CPU1.CP15 113.12,56.73 113.21,56.82 113.24,56.82 113.31,56.89 v3(113.31,56.89) ; CPU1.B23 68.12,51.72 67.53,51.72 67.15,52.1 66.03,52.1 v3(64.91,53.22) ; CPU1.B31 67.33,46.64 65.9,45.22 65.9,44.65 v3(64.89,43.64) ; v2(95.36,69.7) 95.36,68.93 96.07,68.22 96.07,67.43 97.14,66.35 97.15,66.34 97.15,66.27 97.36,66.05 97.47,65.9 CPU1.BK2 ; CPU1.B29 68.15,47.9
  BOTTOM w0.102: CPU1.T36 76.31,42.31 v3(76.31,42.31) ; v3(97.09,39.13) 97.09,39.15 96.04,40.2 96.04,41.11 95.45,41.69 95.45,42.22 95.18,42.49 CPU1.BF36 ; CPU1.P36 75.05,41.91 v3(74.73,41.59) ; CPU1.J36 72.53,41.91 v3(72.38,41.75)
  BOTTOM w0.127: CPU1.CJ14 109.21,57.69 v2(109.61,58.09) 109.85,57.86 110.38,57.86 CPU1.CM13 ; USB1.18 v3(10.16,34.1) ; CPU1.CJ11 109.12,59.58 108.8,59.26 v2(108.8,59.09) ; CPU1.CK4 110.01,63.2 110.01,63.16 v2(110.01,63.16) ; CPU1.CK4 109.06,63.54 CPU1.CJ4 CPU1.CJ3 CPU1.CJ2 109.06,64.87 CPU1.CK1 109.82,65.52 112,67.7 112.65,67.7 112.69,67.66 v2(112.69,67.65) ; CPU1.CK4 109.84,63.71 CPU1.CM4 110.49,63.01 CPU1.CM5 110.53,63 CPU1.CN5 ; 113.56,66.87 112.46,66.87 111.98,66.4 v2(111.98,66.3) ; CPU1.BE10 94.2,59.39 94.2,59.23 v2(94.18,59.21) ; CPU1.CM37 110.71,42.77 111.01,42.46 111.01,41.39 111.83,40.57 v2(112.5,40.57) 112.5,41.31 112.39,41.42 ; 112.39,41.42 112.38,41.44 112.38,42.32 112.01,42.69 CPU1.CP37 ; 112.39,41.42 111.88,41.42 111.44,41.86 111.44,42.81 CPU1.CN37 ; CPU1.D6 70.03,62.34 70.24,62.55 v2(70.24,62.58) 69.84,62.99 CPU1.D5 ; CPU1.BT16 100.91,56.27 100.91,56.46 CPU1.BT15 ; v2(104.29,41.93) 104.32,41.93 104.45,42.05 104.45,42.58 103.99,43.03 CPU1.BY36 ; 110.31,55.56 110.02,55.85 109.02,55.85 108.92,55.96 v2(108.92,55.96) ; v2(86.46,59.36) 86.46,59.48 86.45,59.49 CPU1.AM10 ; 109.6,64.24 109.68,64.24 109.81,64.37 109.82,64.37 109.98,64.53 109.98,64.88 CPU1.CL2 110.29,65.11 CPU1.CM1 ; WLAN1.45 161.14,20.3 161.39,20.06 ; v2(85.4,87.48) 84.21,88.67 73.01,88.67 72.33,87.99 72.33,87.4 PR4617.2 ; v2(104.43,63.13) 104.12,62.83 CPU1.BY5 ; CPU1.AB4 80.18,63.74 v3(80.18,64.01) 80.39,64.22 CPU1.AB3 ; GPU1.AF23 155.24,76.44 v2(154.16,77.53) ; 161.39,20.06 162.64,20.06 v2(162.84,19.86) ; 161.39,20.06 161.21,20.06 160.97,19.82 160.97,18.92 160.85,18.8 WLAN1.51 ; v3(93.39,41.56) 92.68,42.26 92.68,43.08 92.67,43.1 CPU1.BB36 ; CPU1.CM33 110.82,44.65 110.89,44.57 ; v2(148.17,66.16) 147.3,67.03 147.1,67.03 146.88,67.26 GPU1.AF8 ; CPU1.C4 69.18,63.26 v2(69.18,62.91) 68.63,62.91 CPU1.B5 ; CPU1.BT15 101.59,56.43 v2(101.59,56.37) 101.61,56.35 101.61,56.32 101.73,56.2 101.73,56.1 CPU1.BU16 ; CPU1.BT15 101.03,56.99 101.03,57.42 CPU1.BT14 ; CPU1.F4 70.62,63.99 ; CPU1.CP35 CPU1.CR36 ; CPU1.CP35 CPU1.CR34 ; CPU1.CP35 111.31,44.48 111.06,44.48 110.94,44.51 110.89,44.57 ; CPU1.BR19 100.55,54.3 99.97,54.3 CPU1.BP19 99.94,54.26 v2(99.56,53.89) ; 110.89,44.57 110.55,44.36 110.19,44.45 109.93,44.45 109.6,44.13 CPU1.CJ35 ; CPU1.BD6 CPU1.BD7 ; CPU1.BD7 93.78,61.53 v2(93.43,61.18) 93.13,60.88 CPU1.BC8 ; CPU1.BD7 93.91,61.53 v2(94.24,61.2) 94.45,61.2 CPU1.BE8 ; USB1.17 9.75,32.1 9.97,31.88 10.1,31.88 v2(10.12,31.86) ; CPU1.CJ23 109.48,51.58 109.48,51.85 v3(109.49,51.85) ; CPU1.BP15 99.94,56.67 100.24,56.36 100.24,56.29 CPU1.BR16 ; CPU1.CN9 CPU1.CM9 110.04,60.98 v2(110.04,61.41) 109.93,61.53 CPU1.CK7 ; CPU1.BU20 101.89,53.3 101.6,53.01 v2(101.58,53.01) ; v2(100.26,53.03) 100.26,52.85 100.53,52.58 CPU1.BR22 ; v2(105.45,53.83) 105.14,53.52 CPU1.CB20 ; v2(105.45,53.83) 105.45,53.95 CPU1.CB19 ; v2(105.45,53.83) 105.62,53.83 105.79,53.66 CPU1.CC20 ; v2(103.36,46.85) 103.29,46.85 102.98,46.54 CPU1.BV31 ; R2008.2 119.85,59.3 120.56,60.02 v2(120.61,60.02) ; v2(155.14,72.03) 155.19,71.98 GPU1.AB20 ; CPU1.AB36 80.08,41.35 79.65,40.93 v3(79.63,40.93) ; CPU1.V3 77.95,64.25 v2(77.77,64.07) 77.95,63.89 CPU1.V4 ; CPU1.BB3 92.59,64.24 v2(92.77,64.06) ; v2(192.47,6.84) 192.47,7.27 192.9,7.7 IO2.7 ; CPU1.AT4 88.68,63.65 v2(88.68,63.17) ; CPU1.CJ19 109.21,54.06 v2(109.35,53.92) ; CPU1.BP3 CPU1.BP4 99.91,63.49 100.22,63.19 100.73,63.19 v2(100.81,63.11) 100.87,63.04 100.92,63.04 101.14,62.83 CPU1.BT5 101.66,63.25 102.07,63.25 CPU1.BV4 CPU1.BV3 ; CPU1.CF4 107.6,63.17 108.15,63.17 ; CPU1.CR6 113,62.44 v2(113.82,63.26) ; CPU1.BK3 CPU1.BK2 ; CPU1.P4 75.51,63.96 v2(75.58,64.04) 75.51,64.11 CPU1.P3 ; CPU1.BW15 103.19,56.67 v2(103.49,56.36) 103.67,56.54 103.67,56.56 103.84,56.72 CPU1.BY15 104.14,56.48 v2(104.14,56.36) 104.16,56.36 104.49,56.69 CPU1.CA15 ; v3(29.85,65.14) 29.57,65.14 U7201.A1 ; CPU1.CD20 106.82,53.81 v2(106.82,53.82) 106.82,53.98 CPU1.CF19 ; CPU1.CC14 105.79,57.55 106.08,57.25 106.08,57.21 v2(106.08,57.21) 106.44,57.56 CPU1.CD14 107.18,57.62 CPU1.CF14 ; v3(70.35,41.57) 71.27,42.49 71.27,43.1 71.27,43.12 CPU1.G36 ; CPU1.CC16 105.79,55.84 v2(105.45,55.5) 105.14,55.19 CPU1.CB18 ; CPU1.BY19 103.84,54.36 v2(103.5,54.69) 103.84,55.03 CPU1.BY18 ; CPU1.AV36 90.15,41.73 90.03,41.61 v3(90.03,41.52) ; v3(100.04,42.34) 100.02,42.35 100.02,43.03 CPU1.BP36 ; CPU1.CE36 CPU1.CE35 ; CPU1.CA22 104.49,52.59 ; 70.62,65.73 v2(70.6,65.76) ; CPU1.AW1 90.65,65.52 v2(90.3,65.88)
  BOTTOM w0.152: v2(29.6,59.13) 29.59,59.13 U7201.L1 ; CPU1.CB4 CPU1.CB3 CPU1.CB2 ; v3(84.79,41.37) 84.79,41.45 84.72,41.53 84.72,42 85.12,42.4 CPU1.AK36 ; CPU1.AM33 86.77,45.17 86.77,45.16 87.19,45.16 87.2,45.17 CPU1.AP33 ; v3(77.3,41.43) 77.53,41.66 77.53,43.19 CPU1.V36 ; CPU1.BE31 CPU1.BE30 94.77,47.19 v2(95.16,47.58) ; CPU1.CF2 107.3,65.14 107.3,64.6 CPU1.CF3 CPU1.CF4 ; CPU1.AF36 82.6,43 82.57,42.93 82.57,42.03 82.02,41.48 82.02,40.27 v3(81.57,39.82) ; LCD1.54 53.64,78.07 53.2,78.51 LCD1.37 ; CPU1.AP36 87.65,43.2 87.65,42.5 87.95,42.2 87.95,40.83 87.77,40.65 87.77,40.22 v3(87.17,39.62) ; CPU1.CP27 112.34,49.17 112.76,48.74 v2(113.24,48.74)
  BOTTOM w0.178: CPU1.AH24 v2(84.68,50.8) ; CPU1.AG24 v2(83.77,50.8) ; CPU1.CP11 113.06,59.25 v2(113.09,59.22) ; CPU1.BF33 95.69,45.17 95.7,45.18 95.97,45.18 96.05,45.09 96.37,45.09 CPU1.BH33 ; CPU1.U24 CPU1.U26 ; 70.13,45.45 CPU1.E33
  BOTTOM w0.18: CPU1.CF2 107.84,66.05 v2(108.29,66.38) ; CPU1.CB2 v2(104.79,66.28)
  BOTTOM w0.2: CPU1.AH33 83.86,44.63 ; 83.86,44.63 v3(83.91,44.63) ; 83.86,44.63 83.86,44.57 ; CPU1.AW29 v2(91.52,47.58) ; CPU1.AR28 88.73,48.25 v2(88.78,48.25) ; v2(93.35,47.57) CPU1.BC29 ; CPU1.AU28 v2(89.69,48.21) ; CPU1.AU29 v2(89.69,47.58) ; CPU1.BE28 v2(95.16,48.21) CPU1.BG28 ; v2(98.81,46.94) CPU1.BL30 ; CPU1.BE29 v2(95.16,47.58) ; CPU1.AV28 v2(90.61,48.21) ; 96.92,45.56 96.92,45.66 CPU1.BH32 ; CPU1.BD28 v2(94.25,48.21) ; CPU1.BH28 v2(96.99,48.21)
  BOTTOM w0.203: v2(166.94,48.54) 171.34,44.15 171.34,39.98 172.23,39.08 172.23,38.33 172.67,37.89 174.16,37.89 174.44,38.18 175.32,38.18 176.86,39.71 176.86,41.2 174.95,43.1 174.05,43.1 173.37,43.79 173.37,45.86 v2(170.29,48.93) ; U2401.64 31.16,13.87 v2(30.36,14.67) ; v2(121,16.11) 121.23,15.89 SSD1.1 ; v2(121,16.11) 121,15.05 121.27,14.79 SSD1.76 ; v2(121,16.11) 121.22,16.11 121.5,16.39 SSD1.3 ; GPU1.AC2 v2(145.28,62.03) ; CPU1.AM5 86.79,62.49 v2(86.86,62.49) 86.86,62.79 87.24,63.17 87.34,63.17 CPU1.AP4 ; CPU1.BL28 98.08,48.21 v2(97.9,48.21) ; LCD1.12 43.2,78.27 LCD1.45 ; v3(120.69,30.1) 120.93,30.1 121.14,29.89 SSD1.57 ; IO1.9 176.35,7.66 176.31,7.63 176.31,7.61 176.05,7.34 176.03,7.34 175.91,7.22 v3(175.85,7.22) ; C8604.2 133.78,72.89 133.24,72.34 v2(133.16,72.34) ; R3322.2 12.85,13.96 v2(13.17,14.29) ; CPU1.BK10 97.64,59.96 v2(97.96,59.64) ; v2(15.61,24.57) 15.71,24.67 U2401.124 ; v2(132.75,52.73) 132.08,52.73 131.9,52.55 131.88,52.55 ED1706.2 130.6,52.17 RN1703.1 130.4,51.94 130.25,51.79 129.94,51.79 129.75,51.98 RN1703.2 ; v2(87.87,48.21) 87.5,47.84 CPU1.AN29 CPU1.AN30 CPU1.AN31 87.82,46.14 87.82,45.6 87.63,45.41 CPU1.AP33 87.71,45.24 88.82,45.24 CPU1.AT33 88.84,45.12 v3(88.84,44.56) 88.89,44.51 CPU1.AT35 ; GPU1.E2 155.24,51.44 v2(154.74,50.94) ; Q8603.S 129.97,67.82 v2(130.12,67.97) ; R1505.2 121.77,56.07 119.83,56.07 R1552.2 ; CPU1.CE33 106.77,45.43 v2(107.17,45.43) 107.57,45.43 107.77,45.23 CPU1.CG33 108.2,45.17 v3(108.44,45.41) 108.44,45.4 108.67,45.17 CPU1.CJ33 ; CPU1.CE33 106.72,44.96 106.72,44.17 CPU1.CE35 ; CPU1.CE33 106.46,45.12 106.12,45.12 106.04,45.19 105.76,45.19 105.74,45.17 CPU1.CB33 ; 44.79,78.06 44.8,78.07 LCD1.16 ; SSD1.39 121.5,25.39 121.25,25.14 v2(120.55,25.14) 121.8,23.89 SSD1.33 ; 104.49,52.59 105.14,53.24 CPU1.CB20 ; CPU1.BY28 104.02,48.49 104.24,48.27 104.24,48.27 v2(104.27,48.23) ; C2427.2 15.66,29.01 16.29,29.64 16.29,30.61 v2(15.79,31.12) ; v2(106.11,46.89) 105.99,46.89 CPU1.CC31 ; v2(16.02,14.97) 16.12,15.07 U2401.100 ; CPU1.BY33 v2(103.99,44.54) CPU1.BY35 ; PC4405.2 143.34,11 143.34,10.86 143.25,10.78 143.25,9.75 144.09,8.91 144.93,8.91 145.26,8.58 Q9202.S 145.86,8.93 147.94,8.93 PC4431.2 ; CPU1.CN29 CPU1.CM29 110.08,47.91 v2(109.95,48.04) 109.74,48.04 CPU1.CJ28 ; FC8941.2 162.78,40.11 FC8939.2 162.2,40.68 FC8901.2 161.65,41.57 C8031.2 ; v2(165.89,28) 165.89,27.87 166.71,27.05 WLAN1.18 ; R8534.2 147.72,83.61 146.59,83.61 146.06,84.15 U8502.3 ; v3(120.86,28.09) 121.16,28.39 SSD1.51 ; v2(143.38,66.27) 143.75,66.27 144.53,65.5 GPU1.AF5 ; v2(108.83,46.84) 108.53,46.54 CPU1.CH31 ; CPU1.BV33 102.33,45.17 v2(102.15,45.35) 101.97,45.17 CPU1.BT33 ; CPU1.BR16 100.59,56.01 100.91,56.34 ; v2(34.07,19.44) 33.57,19.44 33.2,19.07 U2401.51 ; CPU1.AC5 81.23,63.15 v3(81.41,63.15) ; WLAN1.39 158.76,21.8 v2(157.6,22.95) ; v2(106.13,48.17) 105.81,48.49 CPU1.CC28 ; 118.48,74.02 118.48,73.62 117.69,72.83 117.09,72.83 116.31,72.05 116.31,71.12 114.92,69.73 v2(114.92,68.79) 114.92,68.22 113.56,66.87 ; IO2.25 193.76,4.1 193.79,4.07 ; v2(23.69,26.56) 23.7,26.56 23.96,26.82 24.76,26.82 24.76,26.82 24.77,26.82 24.9,26.96 24.9,26.96 24.97,27.03 U2401.17 ; CPU1.A32 67.79,45.98 v3(66.96,45.15) ; v2(54.6,61.9) 54.6,62.42 PC4651.2 54.2,62.81 PC4612.2 ; v2(13.17,14.29) 12.73,14.73 R3323.2 ; v2(13.17,14.29) 14.12,13.34 R3314.2 14.12,12.31 C2406.2 ; CPU1.BR25 100.59,50.15 v2(100.9,50.46) 101.24,50.13 CPU1.BT25 CPU1.BU25 ; PC4430.2 156.07,11.27 156.45,10.88 v2(156.45,10.77) ; LCD1.22 47.2,78.15 ; v2(148.66,10.05) 148.45,10.25 PC4433.2 ; v2(15.04,64.46) 15.09,64.46 15.1,64.45 C5710.2 ; R1521.2 125.04,49.8 124.66,50.18 124.66,53.58 124.92,53.83 125.67,53.83 R1523.2 126.42,53.69 v2(126.48,53.74) ; CPU1.BK28 97.72,48.21 v2(97.9,48.21) ; 192.42,8.95 192.84,9.37 IO2.41 ; 192.42,8.95 v2(192.38,8.95) ; 192.42,8.95 192.47,8.9 IO2.1 ; v2(96.99,48.21) 96.61,47.84 CPU1.BH29 ; PU5101.32 32.22,39.51 v2(32.74,40.04) 33.02,39.77 PU5101.30 ; 193.79,4.07 193.79,4.07 194.12,3.74 194.17,3.74 v2(194.32,3.59) 194.3,3.59 193.61,2.9 IO2.31 ; 193.79,4.07 193.79,5.14 193.63,5.3 IO2.19 ; v2(97.9,48.21) 98.27,47.84 CPU1.BL29 ; IO1.12 177.85,9.64 177.95,9.74 177.95,10.14 177.55,10.54 v2(177.11,10.54) ; PC4620.2 37.55,62.9 37.31,62.9 37.07,63.14 37.07,63.15 36.97,63.25 36.97,63.91 C7244.2 ; USB1.B12 8.14,30.35 USB1.A1 ; CPU1.BN30 99.05,47.19 v2(98.81,46.94) ; v2(128.77,62.37) 128.37,61.97 127.64,61.97 127.05,62.57 Q401.4 127.46,62.93 127.91,63.39 127.91,63.82 128.33,64.23 Q401.1 ; U2401.84 v2(23.37,11.39) ; CPU1.CF28 107.6,48.49 v2(107.91,48.18) ; WLAN1.77 159.91,12.47 WLAN1.75 159.16,12.8 158.91,13.05 158.91,13.17 157.57,14.51 157.57,15.03 v2(157.59,15.05) 156.78,15.86 PC4422.2 ; PU8602.8 178.88,33.62 179.08,33.42 v2(179.24,33.42) 179.24,33.69 179.33,33.78 PU8602.7 ; WLAN1.63 161.36,15.8 161.38,15.82 ; v3(124.34,20.85) 124.3,20.89 SSD1.21 ; v2(141.77,62.35) 141.77,62.56 GPU1.AF1 GPU1.AG2 ; 161.4,15.85 161.4,14.84 160.87,14.3 WLAN1.69 ; v2(192.47,6.84) 192.81,6.5 IO2.13 ; v2(30.8,40.59) 30.87,40.59 31,40.72 31.61,40.72 PU5101.4 ; U4001.11 v2(65.32,11.27) ; CPU1.AY33 91.86,45.17 91.87,45.19 92.16,45.19 92.18,45.17 CPU1.BB33 ; CPU1.CJ35 CPU1.CJ36 CPU1.CK37 109.52,42.41 v2(109.68,42.26) ; WLAN1.57 161.1,17.3 161.62,17.82 v2(161.62,18.05) ; CPU1.AL7 85.21,61.21 v2(85.08,61.21) 84.93,61.21 CPU1.AJ7 84.29,61.21 v2(84.15,61.21) ; GPU1.AC5 146.93,63.76 v2(146.99,63.83) ; IO1.31 171.42,8.85 171.42,12.44 171.56,12.59 171.56,13.08 171.44,13.2 v2(171.44,13.44) ; SSD1.45 124.29,26.89 EC2501.2 126,26.44 126.95,26.44 v3(127,26.39) ; v2(120.71,18.33) 120.71,18.33 120.73,18.31 121.29,18.31 121.7,17.89 SSD1.9 ; R2426.2 26.65,31.14 26.99,31.47 PR5156.2 ; PR4628.2 43.11,69.56 41.34,69.56 PC4603.1 ; CPU1.BL25 98.35,50.8 v2(98.32,50.83) ; CPU1.AV25 v2(90.15,50.79) ; PR4614.2 50.46,67.92 50.72,67.66 v2(50.79,67.66) 51.22,67.24 PR4621.1 ; WLAN1.13 159.14,28.3 158.91,28.07 158.91,26.93 159.04,26.8 ; LCD1.23 47.6,78.27 LCD1.49 ; CPU1.BY22 CPU1.CA22 ; LCD1.13 43.6,78.11 ; 113.33,71.28 113.33,71.37 113.69,71.73 113.69,72.13 113.41,72.41 113.41,72.41 112.86,72.96 112.86,73.36 113.17,73.67 113.17,74.12 ; 113.33,71.28 113.33,68.36 113.29,68.31 113.29,68.26 112.69,67.66 ; 113.33,71.28 v2(113.35,71.28) ; GPU1.AB7 148.17,63.82 v2(148.22,63.76) GPU1.AA7 ; SSD1.27 121.48,22.39 121.16,22.07 121.16,20.49 v2(121.03,20.36) 121.13,20.36 121.56,19.93 121.56,19.64 121.81,19.39 SSD1.15 ; CPU1.AN7 87.3,61.53 86.96,61.19 86.96,61.16 v2(86.96,61.16) 86.96,61.16 87.24,60.88 CPU1.AN8 ; GPU1.B11 162.18,55.05 162.04,55.73 162.04,55.73 v2(161.65,56.12) ; v2(164.87,71.82) 164.84,71.82 163.97,70.95 163.97,70.76 GPU1.P26 ; v2(141.03,81.79) 141.13,81.69 141.86,81.69 142.33,81.21 Q8509.1 ; v2(86.05,48.85) 86.15,48.85 CPU1.AM28 ; CPU1.C29 CPU1.B29 ; CN1.11 123.85,76.09 124.17,75.77 v2(124.17,75.42) ; v3(175.07,7.21) 174.8,7.48 174.8,8.14 174.85,8.19 IO1.6 ; CPU1.BL32 98.35,45.78 CPU1.BM33 98.51,45.17 98.49,45.19 98.21,45.19 98.19,45.17 CPU1.BK33 ; R7911.2 140.62,50.7 139.53,49.61 FC8902.2 ; LCD1.50 49.11,78.07 49.61,77.57 v2(49.61,77.35) ; v2(92.87,50.83) 92.88,50.83 CPU1.BC25 ; PU8602.18 v2(178.88,37.91) ; CPU1.CM31 110.03,46.68 v2(109.92,46.79) ; v2(16.45,8.79) 16.45,9.09 17.35,10 18.08,10 18.47,9.61 C2503.2 19.25,10 C6501.2 ; CPU1.AN25 87.42,50.75 87.44,50.78 87.44,50.78 v2(87.43,50.78) ; LCD1.19 46,78.15 ; CPU1.BT36 CPU1.BT35 ; CPU1.BK4 CPU1.BK3 ; 77.74,47.45 v2(77.85,47.56)
  BOTTOM w0.254: v2(137.99,8.41) 137.6,8.41 137,9.02 ED9201.8 ED9201.3 137,10.83 137.38,11.21 138.26,11.21 138.75,10.72 138.75,10.39 139.03,10.11 140.14,10.11 140.35,9.91 FP1.5 ; v2(178.21,59.5) 178.7,59 VRAM1.C1 ; v2(28.31,39.53) 28,39.83 PR5106.2 ; v2(187.09,56.99) 186.72,57.36 VRAM1.N3 ; VRAM4.C3 184,74.49 v2(184.4,74.89) 184.02,75.27 VRAM4.C4 ; Q6701.4 14.74,52.52 14.99,52.27 15.83,52.27 16.04,52.06 Q6701.1 ; CPU1.CM21 CPU1.CN21 CPU1.CP21 112.07,52.95 112.15,53.03 112.99,53.03 v2(113.01,53.06) ; CPU1.CC24 CPU1.CD24 106.86,50.9 CPU1.CF23 106.89,51.68 v2(106.89,51.96) ; CPU1.CC24 CPU1.CB24 104.81,51.23 v2(104.81,51.31) ; CPU1.CC24 CPU1.CC25 ; 85.75,45.37 85.73,45.34 CPU1.AK33 ; 85.75,45.37 86.18,45.37 CPU1.AM33 v3(86.37,44.57) CPU1.AM35 ; 85.75,45.37 85.75,45.45 CPU1.AL32 ; CPU1.BP25 CPU1.BR25 ; CPU1.F24 70.11,51.35 CPU1.E23 ; CPU1.B15 68.81,57.03 v2(68.81,57.18) ; v2(72.06,58.12) 72.06,58.27 CPU1.J12 ; LCD1.53 52.6,77.5 v2(52.62,77.5) ; CPU1.CN17 CPU1.CM17 110.4,55.47 110.31,55.56 ; CPU1.CM13 CPU1.CN13 CPU1.CP13 ; VRAM1.A12 177.1,50.18 v2(176.67,50.61) ; CPU1.F12 70.11,58.27 v2(70.11,58.12) ; CPU1.K25 73.03,50.23 v2(72.71,50.55) ; VRAM1.K13 v2(183.9,48.96) 184.3,48.56 VRAM1.K14 ; v2(182.34,84.36) 182.34,83.83 182.4,83.77 VRAM4.E14 ; v2(178.95,52.31) 179.5,51.76 VRAM1.D10 ; CPU1.G35 CPU1.G36 ; v2(100.67,45.4) 100.18,45.89 CPU1.BP32 ; v2(100.67,45.4) 101.25,45.4 CPU1.BT33 CPU1.BT35 ; v2(100.67,45.4) 100.45,45.17 CPU1.BP33 ; CPU1.BB33 93.08,45.17 93.4,45.49 ; VRAM1.K1 184.3,59.86 v2(184.33,59.89) ; CPU1.BU23 102.02,51.61 102.02,51.04 CPU1.BU24 101.89,50.81 v2(102.2,50.49) 101.89,50.18 CPU1.BU25 ; v2(177.88,55.18) 177.9,55.2 VRAM1.B5 ; VRAM1.A1 177.06,58.96 v2(176.6,59.42) ; v2(186.3,51.36) 185.9,51.76 VRAM1.M10 ; GPU1.Y23 158.77,73.12 v2(158.78,73.12) ; v2(179.9,50.56) 180.3,50.16 VRAM1.E12 ; CPU1.BH35 v2(96.44,44.57) CPU1.BH33 96.92,45.56 CPU1.BK33 ; v2(70.76,57.18) 70.76,57.03 CPU1.F15 ; v2(182.45,48.02) 182.7,48.27 VRAM1.H14 VRAM1.H13 ; VRAM1.F10 181.1,51.88 v2(181.5,52.29) 181.9,51.89 VRAM1.G10 ; CPU1.B34 CPU1.C33 CPU1.E33 ; v2(186.69,59.52) 186.7,59.51 VRAM1.N1 ; VRAM1.U14 189.9,48.03 v2(189.84,47.97) ; v3(84.08,63.23) CPU1.AG5 83.54,62.83 CPU1.AF4 CPU1.AF3 ; CPU1.W30 v2(77.85,47.56) CPU1.V30 ; CPU1.CC25 CPU1.CB25 CPU1.CA25 104.49,50.18 v2(104.17,50.49) 104.17,50.4 CPU1.BY25 103.53,50.37 v2(103.53,50.48) 103.19,50.83 CPU1.BW24 ; CPU1.CC25 CPU1.CD25 ; v2(72.71,50.55) 73.03,50.88 CPU1.K24 ; v2(72.71,50.55) 72.71,50.7 CPU1.J24 ; v2(35.85,60.94) 35.47,60.56 C4344.2 ; v2(98.81,46.94) CPU1.BL31 CPU1.BL32 ; 93.4,45.49 93.46,45.49 CPU1.BD33 v2(93.93,44.61) CPU1.BD35 CPU1.BD36 ; 93.4,45.49 93.39,45.54 CPU1.BC32 ; 83.86,44.57 CPU1.AH35 ; v2(68.16,54.35) 68.16,54.5 CPU1.B18 ; VRAM1.F5 181.1,55.6 v2(180.73,55.23) ; CPU1.B25 CPU1.C25 ; CPU1.CN25 CPU1.CM25 ; VRAM1.H1 182.76,58.89 182.76,58.22 VRAM1.H2 ; CPU1.AN28 v2(87.87,48.21) ; VRAM1.N14 186.7,47.18 v2(186.65,47.13) ; CPU1.N27 CPU1.N25 ; v2(186.24,55.23) 185.9,55.57 VRAM1.M5 ; VRAM1.A3 177.1,57.35 v2(177.5,56.95) ; CPU1.BD28 93.68,48.49 92.9,47.93 CPU1.BC29 ; v2(176.52,47.95) 177.1,48.54 VRAM1.A14 ; v2(72.06,54.35) 72.06,54.5 CPU1.J18 ; v2(190.33,50.56) 189.94,50.16 VRAM1.U12 ; VRAM1.R1 188.3,59.42 v2(188.45,59.57) ; VRAM1.T5 189.1,55.78 v2(188.71,56.17) ; VRAM1.R3 188.3,57.34 v2(188.7,56.94) 188.31,56.56 VRAM1.R4 ; CPU1.AF33 82.21,45.17 82.17,45.21 81.38,45.21 CPU1.AD33 ; v2(190.41,57.05) 190.1,57.36 VRAM1.U3 ; CPU1.BG25 v2(95.62,50.8) ; v2(184.26,83.93) 184,83.68 VRAM4.C14 ; v2(179.87,59.5) 180.3,59.07 VRAM1.E1 ; CPU1.F18 70.11,54.5 v2(70.11,54.35) ; VRAM1.U1 189.92,58.96 v2(190.33,59.37) ; v2(72.71,57.18) 72.71,57.03 CPU1.J15 ; VRAM1.L10 185.1,52.31 v2(185.07,52.33) ; CPU1.AW30 v2(91.52,46.94) 91.49,46.94 91.06,46.57 CPU1.AW31 ; v2(181.18,76.51) 180.8,76.13 VRAM4.G5 ; v2(185.4,55.28) 185.1,55.58 VRAM1.L5 ; v2(112.86,54.21) CPU1.CP19 ; v2(178.66,47.99) 178.7,48.02 VRAM1.C14 ; CPU1.AT35 CPU1.AT36 ; CPU1.B12 68.16,58.27 v2(68.16,58.12) ; CPU1.AK3 CPU1.AK4 ; v2(187.36,52.39) 187.5,52.25 VRAM1.P10 ; 89.25,1.06 89.22,1.03 89.22,0.64 ; VRAM4.L5 177.6,76.2 v2(177.2,76.6) 176.8,76.19 VRAM4.M5 ; GPU1.B8 160.47,52.99 v2(161.23,52.23) ; VRAM1.R14 188.3,48 v2(188.42,47.88) ; CPU1.CP9 CPU1.CN9 ; CPU1.AV33 CPU1.AU32 89.33,45.63 89.15,45.26 CPU1.AT33 ; v2(40.25,64.93) 40.31,64.86 PR4627.1 40.98,64.88 PC4613.2 ; v2(187.9,51.36) 188.3,50.97 VRAM1.R11 188.37,50.89 188.37,50.23 VRAM1.R12 ; CPU1.BA28 v2(92.43,48.21) ; v2(180.03,47.2) 180.3,47.48 VRAM1.E14 ; v2(188.91,52.34) 189.1,52.15 VRAM1.T10 ; VRAM1.C12 178.7,50.17 v2(178.3,50.57) 178.31,50.57 VRAM1.C11 178.3,51.36 v2(178.3,51.37) 178.29,51.37 VRAM1.B10 177.9,51.76 v2(177.37,52.29) ; CPU1.BM36 CPU1.BM35 98.96,44.53 98.94,44.55 98.96,44.57 CPU1.BM33 ; CPU1.AY35 v3(91.41,44.57) 91.43,44.59 91.41,44.62 CPU1.AY33 ; CPU1.AW28 v2(91.52,48.21) ; v2(94.25,48.21) CPU1.BE28
  BOTTOM w0.279: v2(165.22,65.55) 165.78,65.55 GPU1.H23 ; GPU1.U26 162.22,72.6 162.85,73.23 v2(163.03,73.23) ; GPU1.B23 169.24,62.03 169.72,61.55 v2(169.76,61.55) ; v2(165.75,61.39) 165.75,61.93 GPU1.E20 ; GPU1.B14 163.97,56.76 163.97,56.44 164.25,56.16 165.01,56.16 v2(165.09,56.24) ; v2(172.35,63.2) 172.25,63.1 171.64,63.1 GPU1.A26 ; v2(159.45,76.97) 159.44,76.97 159.44,76.98 158.71,76.25 GPU1.AC26 ; GPU1.P23 162.28,69.07 162.28,68.54 v2(162.24,68.5) ; GPU1.B20 167.48,60.27 v2(167.48,59.7) ; v2(166.34,63.19) 166.4,63.13 GPU1.E22 ; v2(164.62,68.47) 164.64,68.47 164.67,68.44 GPU1.L25 ; GPU1.L23 164.03,67.31 164,67.28 v2(164,66.74) ; GPU1.H25 v2(167.46,66.69)
  BOTTOM w0.305: VRAM4.R4 174.4,75.3 v2(174.04,75.66) ; GPU1.L14 v2(158.41,61.64) GPU1.M13 ; v3(140.29,51.3) 140.46,51.47 R7929.2 140.9,51.46 R7911.2 ; 157.68,67.3 158.21,67.3 158.25,67.34 v2(158.27,67.34) 158.31,67.3 159.1,67.3 ; GPU1.L10 156.84,58.81 v2(156.96,58.93) 157.08,58.81 157.68,58.81 GPU1.K11 ; GPU1.M15 v2(159.87,63.06) GPU1.L16 GPU1.K17 ; VRAM4.A12 185.86,81.67 v2(186.11,81.93) ; PC4614.2 54.52,61.93 54.55,61.9 v2(54.6,61.9) ; VRAM4.B10 184.76,80.07 v2(184.38,80.45) ; R7927.2 150.29,49.84 v2(150.48,49.65) ; GPU1.V11 v2(152.79,64.47) GPU1.U12 ; VRAM4.R1 v2(174.4,72.19) ; EC8904.2 86.66,72.48 FC8923.2 87.44,72.49 FC8926.2 ; v2(166.27,57.88) 165.73,58.42 165.73,58.51 GPU1.B17 ; 156.27,67.3 v2(155.61,67.3) 154.85,67.3 ; Q6501.S 38.15,9.94 R6509.2 ; v2(16.64,44.7) 16.4,44.7 15.86,45.24 C6703.2 ; CPU1.AL29 85.91,47.53 v2(86.09,47.53) ; PC4641.2 45.86,57.79 v2(45.78,57.71) ; PC5102.2 26.71,30.54 R2426.2 ; v2(66.58,41.82) 66.86,41.82 67.14,42.11 67.16,42.11 67.84,42.78 CPU1.A36 ; GPU1.AC22 GPU1.AD22 GPU1.AD21 v2(155.21,73.19) ; CPU1.BA10 92,59.45 v2(91.99,59.45) ; GPU1.E8 158.77,54.36 v2(158.76,54.35) ; PC8626.2 140.08,82.74 PC8625.2 140.11,83.58 140.19,83.66 v2(140.19,83.68) ; VRAM4.F10 182.15,79.52 v2(182.22,79.52) ; GPU1.K15 160.51,61.64 160.98,61.64 161.07,61.55 161.18,61.55 v2(161.18,61.57) ; v3(133.69,22.75) 133.75,22.69 133.75,22.4 133.87,22.28 133.87,22.27 134.18,21.95 136.73,21.95 137.2,22.42 BIOS1.4 ; R2120.1 136.82,52.37 136.82,52.78 v2(136.71,52.88) ; v2(80.94,59.46) 80.94,59.46 80.94,59.48 80.91,59.5 CPU1.AC10 ; v2(186.1,74.77) 185.8,74.47 VRAM4.A3 ; v2(42.53,46.92) 42.08,46.46 PR4812.2 ; v2(2.63,10.31) C3303.2 3.29,10.31 C3312.2 ; U2502.2 167.89,35.22 168.39,35.71 168.39,36.73 167.72,37.4 164.68,37.4 v2(164.53,37.55) ; CPU1.CM25 110.42,50.43 v2(110.11,50.74) ; v2(113.35,73.16) 113.41,73.22 C1808.2 ; v2(147.5,23.77) 147.5,23.73 147.29,23.52 PC8564.2 ; v2(117.49,73.31) 117.4,73.22 C1807.2 ; R7926.2 140.37,53.77 v2(139.58,54.55) ; CPU1.AK4 85.27,63.26 v3(85.08,63.07) ; C2601.2 125.49,42.23 125.18,41.93 v2(124.5,41.93) ; VRAM4.P10 175.2,79.99 v2(174.83,79.62) ; GPU1.T15 v2(157.04,65.88) GPU1.R16 ; VRAM4.A14 185.66,83.27 v2(186.02,83.64) ; v2(182.89,79.59) 183.2,79.9 VRAM4.D10 ; PR8614.2 v2(132.37,75.76) ; GPU1.R12 v2(154.17,63.06) GPU1.T11 GPU1.U10 ; CPU1.AE7 82.08,61.53 v2(82.3,61.74) 82.51,61.53 CPU1.AF7 ; VRAM4.R14 174.4,83.32 v2(173.89,83.83) ; GPU1.P13 v2(156.99,63.06) GPU1.N14 ; VRAM4.N12 176,81.66 v2(176.4,81.26) ; Q8616.1 187.2,40.25 v2(186.65,39.71) ; PQ4416.4 152.71,22.94 v3(152.37,22.6) 152.37,22.41 152.61,22.17 153.72,22.17 154.21,21.69 PQ4416.1 ; v2(173.26,76.55) 173.19,76.55 173.19,76.47 VRAM4.T5 ; LCD1.51 LCD1.52 51.4,77.65 v2(51.1,77.35) ; 72.69,60 v2(72.7,60) ; 72.69,60 72.69,60 73.06,60.37 CPU1.K9 ; 72.69,60 72.69,59.98 72.25,60.42 CPU1.H9 71.99,60.42 v2(71.66,60.09) 71.66,60.09 71.66,60.05 71.3,60.42 CPU1.G9 71.15,60.42 v2(70.75,60.02) 70.35,60.42 CPU1.E9 70.19,60.51 CPU1.D9 ; CPU1.AV8 89.96,60.88 v2(89.68,61.16) ; VRAM4.C12 184.01,81.67 v2(184.41,81.27) 184,80.87 VRAM4.C11 ; 113.17,74.12 113.17,76.33 v2(113.38,76.54) 113.57,76.74 117.64,76.74 117.81,76.57 117.81,76.1 v2(118.08,75.83) 118.48,75.43 118.48,74.02 ; VRAM4.H13 180.39,82.86 v2(180.42,82.86) 180.02,83.27 VRAM4.H14 ; CPU1.D8 69.78,60.65 CPU1.D9 ; GPU1.U2 148.22,58.5 v2(147.84,58.12) ; v2(19.89,44.79) 19.93,44.75 Q5703.S 19.76,43.47 R7331.2 ; PC4712.2 85.96,87.43 85.4,87.43 v2(85.4,87.48) ; GPU1.E14 162.23,58.51 v2(161.67,58.51) ; CPU1.AD35 81.34,44.37 v3(81.48,44.5) 81.34,44.64 CPU1.AD33 ; v2(177.18,79.55) 177.6,79.97 VRAM4.L10 ; C2423.2 36.03,19.09 v2(36.03,19.44) ; v2(130.02,73.63) 129.84,73.44 C8602.2 130.47,72.13 Q8612.4 ; GPU1.V17 v2(157.04,68.71) GPU1.U18 ; PR4508.2 84.27,11.88 v2(85.07,12.68) ; U8604.3 148.22,79.15 v2(148.27,79.2) ; v2(26.45,39.7) 26.24,39.49 EC4402.2 ; PR4717.2 63.77,87.52 v2(63.76,87.53) ; PR5156.2 26.4,32.02 26.13,32.3 25.7,32.3 25.58,32.17 25.58,32.17 v2(25.59,32.17) ; GPU1.L5 v2(153.43,56.14) ; Q8616.4 v2(189.97,41.7) ; VRAM4.K13 178.79,82.86 v2(178.79,82.88) 178.41,83.27 VRAM4.K14 ; R2002.1 33.59,28.86 EC8921.2 34.44,27.96 v2(34.44,27.64) ; IO2.42 196.38,9.37 196.96,9.96 197.11,9.96 197.14,9.93 ; 130.15,59.2 130.19,59.2 130.77,59.78 R2009.2 131.17,59.53 ED1701.2 ; 130.15,59.2 v2(130.15,59.23) ; 130.15,59.2 129.57,58.62 127.92,58.62 127.6,58.31 127.6,58.31 127.3,58 R1717.1 ; GPU1.U14 154.26,65.88 v2(154.23,65.86) 154.21,65.88 GPU1.V13 ; PC4624.2 39.7,59.62 PC4601.2 38.77,59.62 v2(38.34,60.05) ; Q8509.4 v2(143.63,78.66) ; PR8564.2 140.81,28.21 140.78,28.17 v2(140.78,28.15) 140.78,28.07 140.95,27.9 PR8571.2 ; v2(44.62,73.84) 44.57,73.8 FC8909.2 ; v2(53.12,39.93) 53.12,38.65 51.92,37.45 Q501.S 50.74,38.07 50.46,38.07 C1247.2 ; GPU1.Y5 v2(148.17,61.38) ; VRAM4.K1 178.36,72.87 v2(178,73.23) 178.4,73.63 VRAM4.K2 ; v2(176.37,39.91) 176.37,40.99 C7907.2 ; C7301.2 23.03,57.89 23.41,58.26 v2(23.41,58.36) ; CPU1.AG10 83.68,59.45 v2(83.7,59.45) ; Q6701.4 13.87,53.06 HDMI1.2 ; v2(6.14,68.59) 7.38,68.59 7.82,69.02 EC6401.2 ; GPU1.R10 GPU1.P11 155.58,61.64 v2(155.58,61.64) 155.58,61.64 GPU1.N12 ; v2(63.56,67.95) 63.85,68.24 R1517.2 63.59,69.51 R1518.2 ; EC8902.2 76.33,71.82 75.75,71.82 FC8960.2 74.89,71.7 FC8925.2 74.24,71.73 PC1018.2 PC1019.2 72.15,72.12 v2(71.66,71.63) ; VRAM4.H2 180,73.63 v2(180.36,73.26) 180.36,73.23 VRAM4.H1 ; X7901.4 174.97,40.66 174.54,41.09 v2(174.47,41.09) ; v2(75.58,5.36) v2(75.58,6) ; PU5201.4 125.71,86.02 125.66,86.07 v2(125.64,86.07) ; v2(103.74,86.47) 103.04,87.18 EC8916.2 ; EC8937.2 85.54,72.19 PC1022.2 84.47,71.86 EC8938.2 83.01,71.86 v2(82.64,71.49) 82.22,71.91 FC8924.2 80.8,71.91 v2(80.48,71.59) 80.12,71.23 PC1002.2 78.28,71.23 PC1079.2 77.69,71.25 EC8903.2 ; U7202.4 31.1,70.88 DCIN1.9 31.19,71.8 32.01,72.62 32.86,72.62 32.87,72.61 35.04,72.61 EC4401.2 ; GPU1.Y26 160.68,74.48 v2(160.68,74.86) ; X7901.2 v2(173.56,38.38) ; v2(175.54,83.84) 175.54,83.73 VRAM4.N14 ; 9.88,65.28 10.95,66.35 HDMI1.21 ; GPU1.AE14 v2(150.54,69.65) ; v2(38.21,60.76) 38.21,60.89 38.16,60.94 PC4621.1 PC4620.2 ; GPU1.B1 156.41,49.16 v2(155.92,48.67) ; v2(176.46,79.62) 176.8,79.96 VRAM4.M10 ; v2(132.19,69.4) 132.09,69.5 132.09,69.98 132.08,70 Q8612.1 ; v2(173.08,72.29) 172.8,72.57 VRAM4.U1 ; IO1.31 171.43,8.79 170.04,8.79 168.87,7.63 168.87,6.38 IO1.33 ; v2(152.28,69.03) 152.27,69.02 GPU1.AB14 ; v2(182.03,81.28) 182.4,81.65 VRAM4.E12 ; v2(156.08,78.82) 156.41,78.49 GPU1.AG26 ; VRAM1.H2 183.11,57.75 v2(183.11,57.75) ; GPU1.B5 158.71,51.49 v2(159.62,50.58) ; TPAD1.5 126.1,6.72 125.42,6.04 v2(125.42,5.97) 125.42,5.82 124.96,5.36 122.81,5.36 122.51,5.67 122.51,8.63 122.82,8.94 PC4429.2 ; v3(158.78,26.35) 158.78,26.54 159.04,26.8 WLAN1.19 ; GPU1.A2 157.54,48.97 v2(157.14,48.57) ; v2(149.57,56.4) 149.61,56.4 GPU1.P2 ; GPU1.H2 v2(154.07,53.26) ; v2(172.25,74.83) 172.44,74.83 VRAM4.U3 ; GPU1.L2 151.39,54.67 v2(151.27,54.67) ; VRAM4.A1 185.6,72.4 v2(185.76,72.24) ; v2(10.35,20.28) 10.4,20.23 10.4,19.6 11.1,18.91 C2416.2 C2421.2 ; GPU1.M17 161.21,64.47 v2(161.22,64.46) 161.23,64.47 GPU1.L18 ; U2601.5 128.26,36.92 v2(127.69,37.49) ; PU5201.19 123.05,82.52 123.02,82.49 122.88,82.49 122.67,82.28 v2(122.49,82.28) ; GPU1.E17 163.48,60.21 v2(163.45,60.25) ; v2(57.32,13.08) 57.24,13.16 56.54,13.16 56.24,12.86 56.24,11.83 56.52,11.55 FC8932.2 57.96,10.83 C4005.2 58.88,11.2 C4004.2 60.48,11.4 C4001.2 C4002.2 ; R3324.2 2.05,16.52 v2(2.51,16.06) ; WLAN1.7 161.15,29.8 161.2,29.85 161.43,29.85 161.43,29.86 v2(161.45,29.86) ; v4(23.16,70.77) 23.12,70.73 R7422.2 23.18,69.94 R4310.2 ; R7218.2 26.39,67.33 25.68,68.04 R7219.2 25.53,68.47 v2(25.18,68.81) ; PU4701.28 66.69,84.35 v2(66.35,84.02) ; v3(68.01,53.35) 68.01,53.18 CPU1.B21 ; v2(182.02,74.87) 182.4,74.49 VRAM4.E3 ; GPU1.U5 v2(150.48,60.21) ; GPU1.N18 v2(159.81,65.88) GPU1.P17 ; FC8965.2 57.15,61.93 FC8928.2 56.8,61.91 56.62,62.09 55.62,62.09 v2(55.41,61.88) ; CPU1.D9 69.65,60.26 v2(69.41,60.03) 68.92,60.51 CPU1.C9 CPU1.B9 ; v2(15.79,31.12) 16.87,32.2 C7305.2 ; R7214.1 17.67,62.54 R7231.2 17.28,63.18 v2(17,63.18) ; v2(75.37,59.36) 75.37,59.36 CPU1.P10 ; VRAM4.R12 174.4,81.62 v2(174.79,81.23) 174.76,81.23 VRAM4.R11 ; v2(187.13,50.56) 186.73,50.16 VRAM1.N12 ; 97.16,72.73 97.71,73.28 97.71,76.43 v2(97.46,76.67) 95.69,76.67 94.03,75.02 ED301.3 ; VRAM4.T10 173.6,79.88 v2(173.33,79.61) ; PU4702.28 87.43,84.68 86.87,84.12 PC4766.2 v2(86.83,83.54) ; GPU1.AF11 148.78,69.01 v2(148.79,69.02) GPU1.AE11 ; v2(151.67,57.85) 151.67,57.85 GPU1.P5 ; GPU1.AC8 v2(148.17,66.16) ; v2(37.05,6.57) 36.34,7.28 36.34,12.31 R2455.2 ; IO1.34 189.95,7.96 v2(189.7,8.21) ; v2(173.21,81.27) 172.81,81.67 VRAM4.U12 ; CPU1.AU10 89.23,59.44 v2(89.24,59.44) ; v2(52.85,11.65) 52.34,12.16 EC8919.2 ; Q502.S 52.43,42.24 53.81,40.85 v2(53.81,40.64) ; R1507.2 106.95,39.64 v2(107.35,39.64) 107.38,39.62 107.6,39.62 R1509.2 ; v2(101.92,83.44) 101.92,84.58 FC8959.2 ; R7939.2 142.78,49.02 v2(142.54,48.78) ; v2(67.07,62.2) 67.5,61.78 CPU1.B7 ; GPU1.AD16 v2(152.27,70.21) ; GPU1.L12 157.67,60.22 v2(156.95,60.22) 156.94,60.23 GPU1.M11 GPU1.N10 ; v2(94.4,71.48) 94.29,71.37 93.57,71.37 ED1707.2 ; v2(131.97,89.24) 131.91,89.18 PC5208.2 ; 161.38,15.82 v2(161.45,15.89) ; GPU1.T13 155.51,64.47 v2(155.54,64.5) 155.56,64.47 GPU1.R14 ; C7908.2 171.93,41.32 171.93,42.52 v2(172.15,42.75) ; v2(42.84,74.07) 42.8,74.11 Q5510.E ; C2425.2 14.41,22.96 14.16,22.71 12.69,22.71 v2(12.53,22.56) 12.1,22.56 11.8,22.87 11.8,26.77 11.86,26.83 11.86,26.9 12.02,27.07 14.01,27.07 14.17,26.9 14.17,26.84 v2(14.41,26.6) C2424.2 ; v2(22.29,69.31) Q7407.1 ; R1511.2 108.82,40.33 v2(109.38,40.89) ; GPU1.E25 v2(169.25,64.93) ; v2(150.54,28.4) 150.54,28.44 150.28,28.17 149.14,28.17 PQ4417.S ; v2(53.42,46.41) 53.61,46.61 PC1070.2 PC1057.2 55.65,48.23 FC8927.2 56.99,48.23 FC8964.2 ; PC5003.2 v2(97.23,79.73) ; v2(154.01,73.16) 154.05,73.2 GPU1.AE20 ; v2(171.74,64.93) 171.74,64.53 GPU1.B27 ; v2(184.15,72.28) 184,72.44 VRAM4.C1 ; ED1704.2 71.92,12.22 PC4513.2 FC8966.2 ; GPU1.AB24 v2(158.18,73.75) ; VRAM4.F5 181.63,76.07 v2(181.99,75.71) ; v2(180.98,79.41) 180.8,79.59 VRAM4.G10 ; R7912.2 136.13,61.47 v2(136.64,61.98) ; 153.45,71.98 v2(153.45,72.53) ; CPU1.W10 v2(78.14,59.38) ; PR4659.1 44.28,60.2 PC4637.2 v2(44.34,60.91) ; C1711.2 91.04,72.01 R1719.2 91.25,71.81 v2(91.25,71.32) ; v3(122.94,88.37) 122.94,88.11 122.68,87.85 PC5213.2 ; PR4628.2 PR4629.2 ; v2(151.06,66.76) 150.99,66.76 150.96,66.72 GPU1.AB11 ; GPU1.Y2 v2(145.89,60.27) ; v2(124.26,37.05) 124.24,37.02 123.35,37.02 C2609.2 ; C2502.2 127.58,30.65 C2501.2 126.48,30.14 v2(126.23,29.89) ; CPU1.BA6 91.89,62.18 v2(91.57,61.86) ; v2(19.45,28.95) 18.49,29.91 D7301.A ; GPU1.P15 v2(158.43,64.47) GPU1.N16 ; v2(39.17,9.94) 39.49,10.26 EC4405.2 ; v3(108.15,63.17) 108.15,63.17 108.15,63.18 108.29,63.18 108.69,63.57 CPU1.CJ4 ; H13.1 134.56,64.91 EC8911.2 ; GPU1.AB17 v2(153.47,70.23) ; CPU1.AL28 85.91,48.18 v2(86.1,48.18) ; VRAM4.E1 182.28,72.75 v2(182.28,71.59) ; ED5502.3 ED5502.8 48.73,74.95 48.26,74.48 v2(48.02,74.48) ; C1806.2 102.21,37.65 v2(102.74,37.65) ; C2436.2 37.4,15.24 R2457.2 37.87,14.77 37.87,13.96 37.96,13.88 v2(37.96,13.86) ; VRAM4.N3 175.61,74.86 v2(175.6,74.86) ; R2435.1 15.09,22.74 v2(15.39,23.04) ; GPU1.AD15 v2(151.7,69.65) ; GPU1.AD19 v2(154.02,71.96) ; v2(159.93,70.77) 159.93,70.77 159.93,70.74 160.01,70.82 160.52,70.82 GPU1.U23 ; 9.78,52.97 10.9,51.85 HDMI1.20 ; C3302.2 2.75,14.32 v2(2.54,14.32) ; GPU1.K13 159.1,60.23 159.87,60.23 v2(159.94,60.29) ; R6508.2 12.15,16.24 C3309.2 11.68,16.53 11.13,17.08 R3333.2 11.06,17.05 10.78,16.77 10.72,16.77 10.27,16.32 v2(10.27,16.26) ; v2(137.3,4.43) 137.15,4.58 FP1.9 FP1.10 ; v2(129.36,34.38) 129.72,34.75 131.51,34.75 131.98,34.27 U4008.3 ; VRAM4.N1 v2(176,72.32) ; FP1.8 138.85,8.9 138.37,8.41 v2(137.99,8.41) ; PC5107.2 v4(48.08,41.75) ; PC4610.1 v2(51.6,62.74) ; v2(89.66,61.85) 89.66,61.88 89.85,61.88 CPU1.AV6 ; WLAN1.33 v2(159.91,23.86) ; C7306.2 14.11,37.51 v2(13.41,36.8) 13.24,36.64 C7304.2 ; GPU1.AD12 GPU1.AD13
  BOTTOM w0.33: v2(184.7,58.57) 184.7,58.56 VRAM1.K2
  BOTTOM w0.356: VRAM1.C3 178.71,57.36 v2(179.11,56.96) 178.71,56.56 VRAM1.C4 ; U7601.3 135.07,75.85 135.62,75.3 v2(135.62,75) ; v3(145.81,80.61) 146.2,80.23 146.84,80.23 Q8615.4 ; 154.44,81.3 155.19,80.55 v2(155.25,80.55) ; v2(160.5,56.1) 160.52,56.13 160.52,56.7 GPU1.E11 ; v2(173.99,74.88) 174.4,74.48 VRAM4.R3 ; GPU1.H5 155.18,54.95 154.62,54.95 v2(154.61,54.95) ; v2(152.63,80.43) 152.35,80.71 Q8614.4 ; v2(180.7,56.96) 180.3,57.36 VRAM1.E3 ; v2(139.13,76.11) 139.13,76.54 139.3,76.72 U8605.3 ; v2(156.96,52.66) 156.96,53.21 GPU1.E5 ; v2(139.06,74.71) 138.81,74.45 138.37,74.45 138.14,74.22 R7606.2 ; Q7407.4 18.49,68.01 v2(18.44,67.96) ; VRAM4.B5 184.8,76.12 v2(185.2,76.53) ; Q8615.1 v2(148.55,82.33) ; v2(172.4,83.68) 172.8,83.28 VRAM4.U14 ; v2(181.52,55.23) 181.52,55.38 VRAM1.G5 ; v2(53.86,77.17) 53.91,77.22 53.91,77.96 LCD1.54 LCD1.55 55.83,78.07
  BOTTOM w0.381: C2602.2 129.32,34.34 v2(129.36,34.38) ; v2(145.23,52.81) 145.23,52.85 144.97,53.1 R7902.2 ; v2(143.15,51.18) 143.39,50.94 R7908.2
  BOTTOM w0.508: PR4514.2 85.05,10.72 PR4508.2 ; v2(26.93,71.23) 26.93,70.31 C4306.2 27.49,69.75 29.01,69.75 R7407.2 29.25,69.99 30.21,69.99 U7202.4 ; R7143.2 16.1,34.87 v2(15.74,34.5) ; 50.97,75.47 51.1,75.6 v2(51.1,77.35) ; v2(170.61,54.04) 170.61,53.49 Q8101.S ; R7408.2 18.22,68.18 v2(18.44,67.96) ; C5502.2 64.22,77.17 EC8912.2 64.3,76.58 65.32,75.56 v2(65.32,75.44) ; X1801.2 114.57,74.35 v2(113.75,75.16) ; v2(32.38,81.39) 32.17,81.39 32.16,81.4 DCIN1.10 ; PC4607.2 v2(46.06,70.55) ; v2(22.42,3.22) 22.42,3.33 22.85,3.77 KBBL1.5 ; v2(109.38,40.89) 109.59,40.67 R1555.2 ; v2(150.54,69.65) 150.51,69.62 GPU1.AD13 ; v2(16.69,5.65) 16.37,5.33 RTC1.2 ; C7217.2 21.74,57.03 22.51,57.79 C7301.2 ; 159.67,42.79 159.43,43.03 158.91,43.03 158.54,43.4 158.54,43.92 C7745.2 157.14,45.32 v2(157.14,48.57) ; 159.67,42.79 160.27,42.18 C8031.2 ; 159.67,42.79 159.84,42.96 159.84,44 R7901.2 ; FAN1.5 191.6,40.09 v2(191.2,40.49) ; v2(119.65,56.72) 119.65,56.23 R1552.2 ; R5510.2 56.54,76.44 57.19,77.09 v4(57.19,77.12) 57.22,77.09 57.81,77.09 C5505.2 58.43,76.66 59.12,75.98 U5501.2 ; PC8564.2 146.9,22.93 PQ4402.S ; R7237.1 30.08,54.51 R7242.1 30.88,54.51 R7241.1 ; R7237.1 29.28,53.67 R4302.1 28.77,53.66 v2(28.63,53.52) ; R7237.1 28.9,54.51 v2(28.59,54.82) ; 8.14,28.62 USB1.15 ; USB1.15 10.32,28.62 ; USB1.15 9.23,27.84 ; v2(2.51,16.06) 2.72,15.85 C3310.2 ; R7921.2 174.14,48.87 174.34,48.87 174.62,49.16 174.62,49.41 v2(174.9,49.68) ; IO1.32 188.41,8.82 188.5,8.91 189.2,8.91 189.57,8.54 189.57,8.34 v2(189.7,8.21) ; R7932.2 172.96,51.87 R7910.1 173.9,52.13 v2(174.1,52.33) ; v2(100.66,48.82) 100.71,48.82 101.04,48.49 CPU1.BT28 ; H11.1 122.06,43.01 ; H11.1 118.92,39.87 ; H11.1 118.92,46.15 ; H11.1 115.78,43.01 ; Q4302.E 33.31,53.49 v2(33.39,53.57) ; X1801.4 117.76,75.14 v2(117.84,75.14) ; R7602.2 143.43,76.64 Q8504.S 143.74,76.78 144.64,75.87 v2(144.81,75.87) ; R7915.2 142.79,48.53 v2(142.54,48.78) ; PC8613.2 174.48,45.07 PC8621.2 174.47,46.89 v2(173.71,47.65) ; D4303.3 24.27,54.15 24.77,53.64 v2(25.23,53.64) ; PC4615.1 v2(55.5,61.12) ; 7.8,41.36 H5.1 ; H5.1 4.66,44.5 ; H5.1 7.8,47.64 ; PU44B1.2 153.88,28.63 PU44A1.2 153.66,27.19 v3(153.54,27.07) ; v2(130.63,64.55) 130.63,63.73 130.86,63.5 Q8602.S ; v2(150.78,78.13) Q8605.S 152.16,78.76 R7601.2 ; R8107.2 174.1,52.91 v2(174.1,52.33) ; EC8937.2 85.83,72.45 EC8904.2 ; v3(124.49,55.56) 124.49,55.78 123.95,56.32 R2112.2 R2118.2 ; v2(16.91,53.02) 17.42,52.51 D4302.1 ; v2(10.87,8.53) 10.71,8.68 R3326.2 ; v2(148.55,82.33) 148.55,82.78 R8534.2 ; FAN1.6 193.81,33.7 v2(194.76,34.66) ; EC8901.2 100.19,72.87 PC1074.2 98.49,72.36 PC1078.2 98.12,72.73 C801.1 ; v2(7.39,19.22) 7.98,18.64 C3311.2 7.81,18.06 C3301.2 ; R7924.2 172.31,48.89 v2(172.4,48.8) ; PC5002.2 v2(101.92,83.44) ; Q8613.S 125.2,65.87 v2(125.2,68.67) ; v2(188.14,32.82) 187.27,33.69 FC8908.2 ; EC8903.2 77.23,71.71 EC8902.2 ; C4003.2 68.95,10.42 EC8929.2 69.54,10.12 v2(70.6,11.18) 71.3,11.88 PC4513.2 ; v2(14.52,43.34) 15.36,43.34 C6702.2 ; C7206.2 21.09,63.99 v2(21.07,64.01) 21.07,64.58 C7205.2 ; PR4629.2 v2(44.34,70.12) ; C7816.2 174.45,51.66 174.1,52.01 v2(174.1,52.33) ; EC6402.2 10.22,72.98 v2(10.27,73.03) ; FAN1.2 v2(190.88,37) ; v2(39.17,9.94) R6509.2 ; PC8617.2 172.41,37.21 v2(172.34,37.28) ; v2(18.58,45.74) 18.55,45.74 18.55,46.13 R5718.2 ; v2(23.05,43.34) 22.49,42.78 22.44,42.78 C5701.2 ; v2(20.79,60.76) 20.79,61.11 20.71,61.19 20.71,61.4 R7208.1 ; v2(89.32,11.29) 89.32,11.16 89.31,11.15 PC4507.2 ; BATT1.14 v2(116.29,6.16)
  vias: v1(19.39,36.61) v1(35.7,5.62) v1(37.21,34.03) v1(43.61,26.66) v1(46.3,54.73) v1(50.41,40.31) v1(51.49,73.27) v1(65.58,5.96) v1(71.8,82.22) v1(75.61,12.47) v1(85.66,78.31) v1(88.28,81.83) v1(116.6,6.79) v1(127.02,19.66) v1(129.33,7.56) v1(130.23,85.12) v1(142.3,57.76) v1(144.59,11.64) v1(158.65,36.91) v1(165.9,86.97) v1(167.28,86.73) v1(173.21,44.47) v1(185.18,44.05) v1(187.04,42.06) v2(0.76,7.75) v2(0.88,49.45) v2(0.88,47.43) v2(2.43,72.76) v2(2.42,69.74) v2(2.54,46.65) v2(2.54,41.57) v2(2.54,23.91) v2(2.54,21.37) v2(2.6,44.9) v2(3.56,43.21) v2(4.42,73.99) v2(5.23,41.16) v2(5.7,6.81) v2(5.88,50.54) v2(5.92,48.89) v2(6.51,5.49) v2(6.63,67.66) v2(6.76,73.01) v2(6.97,74) v2(7.25,13.8) v2(8.23,40.8) v2(8.27,14.81) v2(8.27,13.8) v2(8.27,12.78) v2(8.55,50.54) v2(8.9,2.7) v2(9.28,13.8) v2(9.44,39.11) v2(9.38,0.77) v2(9.54,74) v2(9.95,40.46) v2(10.22,35.92) v2(11.05,7.7) v2(11.32,34.85) v2(11.8,48.34) v2(11.85,0.76) v2(12.15,74) v2(12.52,39.58) v2(14.21,48.65) v2(14.44,73.99) v2(14.72,15.15) v2(16.51,74) v2(17.13,54.95) v2(17.76,61.22) v2(19.21,37.25) v2(19.21,35.98) v2(19.21,34.71) v2(19.56,78.97) v2(19.58,77.06) v2(19.7,2.19) v2(19.97,37.25) v2(19.97,35.98) v2(19.97,34.71) v2(20.73,37.25) v2(20.73,35.98) v2(20.73,34.71) v2(20.67,29.05) v2(21.55,1.8) v2(21.91,79.26) v2(21.85,28.97) v2(24.04,79.58) v2(24.85,48.67) v2(25.39,44.53) v2(25.63,35.96) v2(25.74,41.58) v2(25.82,50.04) v2(25.77,47.63) v2(26.07,82.65) v2(26.06,46.1) v2(26.73,52.06) v2(26.94,36.55) v2(27.04,54.77) v2(27.2,49.44) v2(27.17,0.76) v2(27.7,43.69) v2(28.26,82.74) v2(28.85,36.36) v2(29.53,36.3) v2(29.71,0.76) v2(32.25,0.76) v2(33.34,82.74) v2(33.8,47.63) v2(33.87,48.8) v2(35.88,82.74) v2(36.83,3.02) v2(37.33,0.76) v2(37.73,65.9) v2(38.87,2.57) v2(39.84,33.46) v2(39.87,0.76) v2(40.1,34.25) v2(40.6,33.46) v2(40.92,34.28) v2(40.96,82.74) v2(41.26,52.71) v2(41.29,52.02) v2(41.29,51.26) v2(41.4,50.6) v2(41.65,77.28) v2(42.01,52.71) v2(41.99,52.07) v2(41.99,51.3) v2(42.15,50.57) v2(42.29,77.28) v2(42.63,49.98) v2(42.73,52.72) v2(42.71,51.23) v2(42.76,52.03) v2(42.94,0.78) v2(43.01,77.32) v2(43.5,82.74) v2(44.54,77.4) v2(44.65,80.43) v2(44.67,54.79) v2(44.67,54.03) v2(45.48,64.88) v2(45.48,0.78) v2(45.59,80.38) v2(45.55,65.97) v2(45.55,64.06) v2(46.04,82.74) v2(46.16,73.82) v2(46.57,65.99) v2(46.57,64.88) v2(46.57,63.78) v2(47.29,80.35) v2(47.46,65.97) v2(47.59,63.94) v2(47.71,64.88) v2(48.58,82.74) v2(48.66,0.78) v2(48.75,80.98) v2(51.12,82.74) v2(51.2,0.78) v2(53.66,82.74) v2(54.54,0.79) v2(56.76,88.24) v2(56.78,85.35) v2(57.65,0.76) v2(58.31,89.24) v2(60.19,0.76) v2(60.6,30.15) v2(60.85,89.24) v2(61.01,30.64) v2(62.73,0.76) v2(63.77,62.02) v2(64.91,62.03) v2(64.98,62.74) v2(65.27,0.76) v2(65.7,62.74) v2(66.56,65.32) v2(66.59,64.46) v2(67.37,65.02) v2(67.63,65.84) v2(67.81,0.76) v2(68.22,82.83) v2(68.47,89.24) v2(68.48,85.28) v2(68.48,66.01) v2(68.92,82.72) v2(69.04,83.99) v2(69.03,83.35) v2(69.55,82.72) v2(69.68,83.99) v2(69.68,83.35) v2(70.19,82.72) v2(70.31,83.99) v2(70.31,83.35) v2(70.35,0.76) v2(70.82,82.72) v2(70.95,83.99) v2(70.95,83.35) v2(71.01,89.24) v2(72.13,62.56) v2(72.38,48.85) v2(72.43,48.17) v2(72.89,51.51) v2(72.89,0.76) v2(72.96,64.03) v2(73.05,62.56) v2(73.22,45.39) v2(74.18,48.88) v2(74.89,5.9) v2(74.89,5.26) v2(74.97,61.2) v2(75.13,48.86) v2(75.15,11.49) v2(75.83,61.18) v2(75.82,53.61) v2(75.86,57.41) v2(75.86,56.39) v2(75.86,55.38) v2(75.86,54.36) v2(75.86,52.33) v2(76.72,61.18) v2(77.74,61.19) v2(77.71,6) v2(78.05,18.68) v2(78.09,69.84) v2(78.19,23.86) v2(78.61,61.3) v2(78.74,68.96) v2(78.72,18.73) v2(78.76,48.85) v2(79.36,70.04) v2(79.54,61.26) v2(79.85,6.26) v2(79.97,28.76) v2(79.97,28.12) v2(79.97,27.49) v2(79.97,26.85) v2(80.37,22.26) v2(80.58,48.91) v2(80.99,21.39) v2(81.95,50.8) v2(82.23,69.98) v2(82.4,51.25) v2(82.53,57.85) v2(82.53,57.1) v2(82.54,56.37) v2(82.52,55.7) v2(82.52,55.07) v2(82.53,54.42) v2(82.55,58.58) v2(82.58,53.71) v2(82.58,52.94) v2(82.86,50.8) v2(83.31,51.25) v2(84.23,51.25) v2(84.25,48.23) v2(84.2,47.58) v2(84.94,6.17) v2(85.43,68.64) v2(86.96,48.85) v2(87.12,68.46) v2(87.17,6.45) v2(87.48,70.3) v2(88.49,58.68) v2(88.48,57.96) v2(88.48,57.21) v2(88.48,56.48) v2(88.46,55.81) v2(88.46,55.17) v2(88.47,54.53) v2(88.48,53.88) v2(88.48,53.14) v2(89.36,83.1) v2(89.62,6.45) v2(90,83.1) v2(90.25,84.37) v2(90.25,83.74) v2(90.31,64.02) v2(90.67,0.76) v2(90.76,83.1) v2(90.89,84.37) v2(90.89,83.74) v2(91.33,69.91) v2(91.4,83.1) v2(91.52,84.37) v2(91.52,83.74) v2(91.51,63.3) v2(91.61,68.13) v2(92.03,83.1) v2(92.16,84.37) v2(92.16,83.74) v2(92.8,13.97) v2(92.97,68.48) v2(93.21,0.76) v2(93.39,70.3) v2(93.43,13.97) v2(93.83,82.93) v2(93.82,82.29) v2(94.07,13.97) v2(94.2,13.1) v2(94.47,82.93) v2(94.48,82.29) v2(94.45,67.54) v2(94.55,57.62) v2(94.55,56.87) v2(94.53,55.47) v2(94.53,54.83) v2(94.54,54.18) v2(94.55,53.54) v2(94.56,58.34) v2(94.56,56.13) v2(94.7,13.97) v2(94.88,64.05) v2(94.98,78.28) v2(95.16,82.91) v2(95.75,0.76) v2(96.18,61.87) v2(96.46,71.38) v2(96.47,69.61) v2(96.93,67.9) v2(97.1,61.78) v2(97.9,48.85) v2(98.29,0.76) v2(98.39,27.87) v2(98.4,27.22) v2(98.38,26.58) v2(98.91,61.79) v2(99.1,19.59) v2(99.76,69.95) v2(99.76,18.6) v2(100.03,68.06) v2(100.39,18.6) v2(100.77,60.48) v2(100.83,0.76) v2(102.63,61.8) v2(102.65,59.87) v2(102.83,67.62) v2(102.86,70.04) v2(103.24,84.05) v2(103.37,0.76) v2(103.94,84.05) v2(104.43,70.59) v2(104.45,68.09) v2(104.46,69.86) v2(104.59,84.05) v2(104.76,59.73) v2(105.91,0.76) v2(106.11,58.86) v2(107.97,71.33) v2(108.45,0.76) v2(108.47,67.63) v2(109.3,9.67) v2(109.81,70.94) v2(110.17,75.21) v2(110.87,76.87) v2(110.99,0.76) v2(111.47,12.79) v2(111.58,75.43) v2(111.77,88.19) v2(112.03,78.1) v2(112.14,73.12) v2(112.06,71.35) v2(112.51,87.98) v2(112.68,9.7) v2(113.43,13.27) v2(113.53,0.76) v2(113.87,12.79) v2(114.21,40.95) v2(115.41,48.08) v2(115.63,47.04) v2(116.07,0.76) v2(117.89,87.45) v2(118.53,87.45) v2(118.61,0.76) v2(119.95,89.22) v2(120.05,53.57) v2(120.62,88.41) v2(121.15,0.76) v2(121.34,89.22) v2(123.46,4.33) v2(123.69,0.76) v2(123.96,79.08) v2(126.23,0.76) v2(126.3,79.99) v2(127.11,89.24) v2(127.43,45.6) v2(127.42,44.73) v2(128.77,0.76) v2(129.43,89.24) v2(129.5,87.89) v2(130.14,87.89) v2(131.08,7.85) v2(131.72,7.85) v2(133.85,0.76) v2(134.83,89.23) v2(134.8,42.1) v2(134.81,41.4) v2(134.81,40.73) v2(134.8,40.1) v2(134.81,39.42) v2(137.02,49.78) v2(139.09,89.24) v2(139.05,86.21) v2(139.61,84.51) v2(141.3,23.82) v2(143.18,60.78) v2(143.34,71.94) v2(143.42,56.14) v2(143.83,55.66) v2(144.23,72.83) v2(144.27,14.53) v2(144.67,89.24) v2(144.75,14.95) v2(144.84,29.39) v2(144.82,28.62) v2(144.81,12.57) v2(145.12,73.72) v2(145.07,54.74) v2(145.47,28.75) v2(145.55,29.4) v2(146.14,74.48) v2(146.06,52.81) v2(146.55,0.76) v2(146.82,52.81) v2(147.21,89.24) v2(148.73,51.59) v2(149.19,0.77) v2(149.34,67.33) v2(149.58,71.14) v2(149.94,65.54) v2(150.03,14.28) v2(151.05,15.3) v2(151.05,14.28) v2(151.05,13.27) v2(151.31,72.93) v2(151.67,67.3) v2(153.07,74.68) v2(153.32,78.8) v2(155.23,87.56) v2(155.22,85.25) v2(155.31,25.02) v2(156.3,89.23) v2(156.59,86.68) v2(156.74,0.77) v2(156.81,25.99) v2(157.76,4.02) v2(158.03,87.98) v2(158.79,25.48) v2(158.91,35.78) v2(159.05,89.23) v2(159.57,35.76) v2(159.73,78.77) v2(159.86,3.46) v2(160.2,35.87) v2(160.77,35.59) v2(161.28,76.64) v2(161.35,35.87) v2(161.64,89.24) v2(162.02,50.34) v2(162.42,35.86) v2(162.61,49.85) v2(162.78,74.55) v2(163.67,22.83) v2(163.97,72.47) v2(164.18,89.24) v2(164.74,20.05) v2(166.13,1.99) v2(166.48,56.29) v2(166.72,89.24) v2(166.87,0.76) v2(169.08,58.32) v2(169.26,89.24) v2(169.75,17.75) v2(169.91,60.05) v2(171.62,2.77) v2(171.8,89.24) v2(172.08,61.93) v2(174.34,89.24) v2(174.71,2.76) v2(176.88,89.24) v2(177.54,16.69) v2(177.66,33.51) v2(178.18,2.76) v2(178.3,33.48) v2(179.42,89.24) v2(180.82,2.76) v2(181.44,16.43) v2(181.44,15.16) v2(181.44,13.89) v2(181.96,89.24) v2(182.18,32.57) v2(182.71,16.43) v2(182.71,15.16) v2(182.71,13.89) v2(183.36,2.77) v2(183.53,28.94) v2(183.86,32.57) v2(183.98,16.43) v2(183.98,15.16) v2(183.98,13.89) v2(184.4,67.08) v2(184.42,64.25) v2(184.5,89.24) v2(184.62,29.88) v2(184.59,28.91) v2(184.59,27.95) v2(184.89,42.88) v2(185.07,66.15) v2(185.13,42.29) v2(185.36,43.34) v2(185.59,28.89) v2(185.65,2.76) v2(186.04,43.29) v2(186.23,64.28) v2(186.45,66.15) v2(186.66,43.16) v2(186.95,89.14) v2(187.43,86.68) v2(187.86,84.15) v2(188.19,2.76) v2(188.3,81.67) v2(188.75,79.16) v2(188.68,18) v2(189.19,76.67) v2(189.79,23.88) v2(190.07,71.65) v2(190.38,44.29) v2(190.52,69.15) v2(190.87,42.43) v2(190.96,66.66) v2(191.39,64.15) v2(191.38,6.84) v2(191.84,61.66) v2(191.94,3.51) v2(191.99,46.77) v2(192.55,41.19) v2(193.16,54.14) v2(193.61,51.65) v2(193.94,47.11) v2(194.05,49.14) v2(194.37,10.34) v2(194.84,41.08) v2(195.83,38.97) v2(196.47,35.35) v2(196.92,32.87) v2(197.24,30.36) v2(197.24,27.82) v2(197.24,12.58) v2(197.23,2.59) v3(19.19,55.17) v3(22.35,52.04) v3(22.81,53.74) v3(22.9,50.47) v3(22.9,48.9) v3(22.96,55.51) v3(37.94,19.98) v3(46.89,27.43) v3(46.88,26.62) v3(47.63,28.91) v3(48.85,27.4) v3(48.89,26.61) v3(49.51,27.4) v3(49.51,26.59) v3(50.02,28.95) v3(50.13,29.82) v3(51.9,28.88) v3(53.41,27.39) v3(53.42,26.62) v3(54.04,27.42) v3(54.05,26.6) v3(54.71,29.83) v3(55.35,27.41) v3(55.35,26.59) v3(62.9,46.09) v3(63.04,50.36) v3(63.36,43.54) v3(64.48,51.38) v3(64.58,45.86) v3(64.87,41.83) v3(65.08,48.28) v3(66.22,53.27) v3(66.41,50.6) v3(66.67,47.57) v3(69.77,44.26) v3(70.3,39.24) v3(72.2,40.1) v3(72.16,38.35) v3(73.62,39.88) v3(73.62,36.88) v3(75.43,39.05) v3(75.4,37.3) v3(77.33,38.71) v3(78.8,44.6) v3(79.64,39.17) v3(79.62,37.97) v3(81.57,37.85) v3(83.27,39.13) v3(84.79,40.04) v3(84.79,38.14) v3(85.84,38.07) v3(85.88,41.6) v3(85.86,39.85) v3(87.19,41.46) v3(88.43,39.8) v3(88.41,38.63) v3(89.97,39.97) v3(89.97,38.8) v3(90.03,37.49) v3(91.55,38.6) v3(91.56,40.36) v3(93.37,39.81) v3(93.37,38.05) v3(94.94,40.05) v3(94.94,38.22) v3(94.91,35.32) v3(97.09,40.99) v3(97.09,37.34) v3(98.59,39.24) v3(113.35,43.94) v3(120.86,27.15) v3(129.69,23.82) v3(130.85,22.85) v3(131.66,23.82) v3(192.33,5.64) v4(22.34,73.36) v4(22.37,72.52) v4(33.76,45.79) v4(33.76,44.84) v4(34.63,45.81) v4(34.63,44.89) v4(42.84,45.65) v4(43.01,56.32) v4(43.01,55.43) v4(43.01,54.54) v4(43.62,56.98) v4(43.83,45.62) v4(43.9,56.06) v4(43.85,55.17) v4(43.85,54.28) v4(44.67,56.82) v4(44.79,55.94) v4(44.79,45.62) v4(45.73,56.04) v4(46.7,56.04) v4(48.09,45.24) v4(74.05,81.74) v4(75.19,81.74) v4(76.13,78.67) v4(77.07,78.67) v4(77.91,78.67) v4(78.85,78.67) v4(79.36,84) v4(79.36,83.11) v4(79.41,82.12) v4(79.69,78.67) v4(80.19,84) v4(80.19,83.11) v4(80.25,82.12) v4(80.63,78.67) v4(81.16,84) v4(81.16,83.11) v4(81.21,82.12) v4(81.46,78.67) v4(82.05,84) v4(82.05,83.11) v4(82.1,82.12) v4(82.66,78.59) v4(83.5,78.59) v4(85.51,82.12) v4(85.6,84) v4(85.6,83.11) v4(135.89,16.18) v4(135.98,18.95) v4(135.99,17.19) v4(136.91,16.17) v4(137,17.18) v4(137.46,20.38) v4(143.14,39.53) v4(143.1,38.39) v4(143.15,37.52) v4(143.09,36.53) v4(143.12,35.62) v4(143.14,34.75) v4(143.17,41.76) v4(143.22,40.65) v4(143.93,36.53) v4(143.9,33.86) v4(143.98,38.38) v4(143.98,37.44) v4(143.95,35.62) v4(143.98,34.75) v4(144.74,33.86) v4(144.82,38.38) v4(144.82,37.44) v4(144.77,36.53) v4(144.79,35.62) v4(144.82,34.75) v4(145.61,36.53) v4(145.63,35.62) v4(145.58,33.86) v4(145.66,38.38) v4(145.66,37.44) v4(145.66,34.75) v4(146.52,35.62) v4(146.55,34.75) v4(146.47,33.86) v4(146.57,41.76) v4(146.62,40.75) v4(146.62,39.65) v4(146.63,38.35) v4(146.56,37.49) v4(146.57,36.58)
